# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UNNAMED_55_HPA022642RTJ_I496_7: length 2
  TOP w0.254: R558.1 310.27,57.39 311.19,58.31 U551.7
UNNAMED_55_HPA022642RTJ_I496_8: length 3
  TOP w0.254: U551.8 311.69,58.28 310.56,57.15 310.56,56.98 R559.1
UNNAMED_55_HPA022642RTJ_I496__1: length 6.1
  TOP w0.254: R569.1 311.07,56.6 311.07,56.94 312.13,58 312.84,58 313.21,58.37 313.21,59.17 313.66,59.62 U551.11
UNNAMED_55_HPA022642RTJ_I496_HP: length 7.9
  TOP w0.254: U551.14 314.69,61.32 v1(314.81,61.2) 314.81,59.14 314.38,58.71 314.38,57.58 313.07,56.27 313.07,55.29 R568.1
UNNAMED_55_HPA022642RTJ_I496_LE: length 3.4
  TOP w0.254: U551.1 309.46,62.07 308.11,62.07 307.83,62.34 R560.1 307.16,62.6 R561.1
UNNAMED_55_HPA022642RTJ_I496_RI: length 3.6
  TOP w0.254: U551.5 309.57,59.68 309.4,59.68 309.15,59.42 308.39,59.42 v1(308.26,59.29) 307.83,58.87 R565.1 307.71,58.53 R564.1
UNNAMED_56_DB3X313J0L_I357_3: length 7.9
  TOP w0.102: v1(294.98,79.74) 295.01,79.71 R808.2 295.01,78.68 294.42,78.09 294.42,77.64 D801.3 293.22,75.96 294.67,74.51 294.67,73.64 294.55,73.52 U800.1
UNNAMED_56_NMOS_I358_D: length 13.2
  BOTTOM w0.254: Q801.1 286.36,60.63 284.96,59.23 Q800.3 ; Q801.1 287.56,62.82 287.56,66.3 v2(287.18,66.69) ; Q801.1 286.89,61.62 288.79,59.72 R803.2
UNNAMED_56_NMOS_I363_S: length 10.1
  TOP w0.254: v2(292.89,75.58) 293.15,75.58 294.34,74.38 294.34,73.87 294.15,73.68 U800.2
  BOTTOM w0.254: Q802.2 290.1,78.52 R809.2 289.76,77.5 289.57,77.31 289.57,76.08 290.33,75.32 v1(291.45,75.32) 292.64,75.32 v2(292.89,75.58)
UNNAMED_56_RSC0402_I275_B: length 7
  TOP w0.102: R801.2 285.57,73.14 286.59,73.14 286.8,72.93 286.8,72.76 287.15,72.4 287.61,72.4 287.84,72.17 v1(288.27,72.17) 288.65,72.17 288.93,72.45 290.2,72.45 290.51,72.76 U800.9
UNNAMED_57_2322BY2ST3DC302A_I15: length 8
  TOP w0.102: v1(309.79,149.97) 309.87,150.05 R115.1 308.95,151.91 308.95,152.69 308.42,153.22 308.42,154.96 309.24,155.78 D110.4 D110.3
UNNAMED_57_2322BY2ST3DC302A_I_1: length 8.2
  TOP w0.102: D110.2 306.1,156.83 305.67,156.4 v1(305.67,151.24) 305.67,150.53 306.23,149.97 Q110.3
UNNAMED_57_2322BY2ST3DC302A_I_2: length 28.6
  TOP w0.102: D126.3 323.12,156.83 323.5,156.45 v3(323.5,155.78) D126.4 ; R126.1 306.82,148.68 v2(306.84,148.7)
  L3 w0.102: v3(323.5,155.78) 321.1,155.78 315.17,149.85 312.22,149.85 311.03,151.04 308.8,151.04 306.84,149.07 v2(306.84,148.7)
UNNAMED_57_2322BY2ST3DC302A_I_3: length 12.1
  TOP w0.102: Q125.3 312.9,148.92 v1(313.67,148.14) 314.69,148.14 315.37,148.83 315.37,150.48 317.79,152.89 317.79,154.8 318.76,155.78 D126.1
UNNAMED_57_2322BY2ST3DC302A_I_4: length 25.4
  TOP w0.102: v3(306.03,144.16) 306.05,144.13 R130.2 ; D126.2 318.8,156.83 318.17,156.2 318.17,155.56 317.53,154.93 317.53,153.02 315.01,150.5 Q125.6 314.17,150.5 v2(314.15,150.48) 314.15,149.97 314.28,149.85 Q125.5
  L3 w0.102: v2(314.15,150.48) 313.72,150.05 312.38,150.05 311.18,151.24 308.72,151.24 306.03,148.55 v3(306.03,144.16)
UNNAMED_57_CSC0402_I213_A: length 3.3
  TOP w0.102: Q114.1 285.15,118.73 v1(285.45,118.73) C9114.1 286.24,117.84 R136.2
UNNAMED_57_LEDSINGLE_I235_A2: length 4.3
  BOTTOM w0.381: D9100.2 265.85,28.18 v1(264.7,29.33) R9100.1
UNNAMED_57_NMOS_I256_D: length 9.5
  TOP w0.102: R136.1 287.18,117.84 288.07,118.73 288.83,118.73 289.21,118.35 289.21,117.21 288.07,116.06 R135.2 287.37,115.79 Q113.3 287.37,113.72 v1(287.81,113.27)
UNNAMED_58_1222Y2ST3DC302C_I4_1: length 55.9
  TOP w0.102: D9033.3 v4(25.27,158.25) ; Q9031.3 70.9,139.18 70.26,139.81 v3(70.26,140.19)
  L6 w0.102: v3(70.26,140.19) 69.88,140.19 54.47,155.6 36.18,155.6 34.7,157.08 26.43,157.08 v4(25.27,158.25)
UNNAMED_58_1222Y2ST3DC302C_I4_2: length 62
  TOP w0.102: v3(74.3,125.74) 74.3,125.14 Q9032.6 ; D9030.2 41.59,155.46 v4(40.93,154.8)
  L6 w0.102: v3(74.3,125.74) 78.14,129.57 78.14,134.61 74.58,138.16 71.28,138.16 54.64,154.8 v4(40.93,154.8)
UNNAMED_58_1222Y2ST3DC302C_I436: length 83
  TOP w0.254: R9032.1 68.61,121.14 v3(68.99,121.52)
  TOP w0.381: v4(35.34,154.29) 35.34,155.05 38.15,157.87 D9032.1
  L6 w0.254: v3(68.99,121.52) 68.49,121.02 68.49,117.71 66.07,115.3 38.64,115.3 35.34,118.6 v4(35.34,154.29)
UNNAMED_58_1222Y2ST3DC302C_I437: length 52.9
  TOP w0.254: R9033.1 70.9,140.83 70.14,141.59 v3(70.14,142.23) ; D9033.1 v4(28.27,158.61)
  L6 w0.254: v4(28.27,158.61) 29.03,159.37 36.35,159.37 38.13,157.59 53.88,157.59 64.93,146.54 66.2,146.54 70.14,142.61 v3(70.14,142.23)
UNNAMED_58_1222Y2ST3DC302C_I438: length 96.4
  TOP w0.254: v4(33.05,151.75) 38.64,151.75 43.09,156.2 D9030.1 ; R9034.1 74.2,122.08 v3(74.2,122.03)
  L6 w0.254: v4(33.05,151.75) 33.94,150.86 33.94,117.97 37.88,114.03 66.45,114.03 74.2,121.78 v3(74.2,122.03)
UNNAMED_58_6712KF08M02L_I525_8: length 8.1
  TOP w0.356: CN9021.8 69.55,147.35 69.37,147.18 69.37,144.13 70.01,143.5 v1(70.26,143.5) C9021.1
  TOP w0.381: R9038.1 71.28,141.8 71.28,142.52 R9040.1 71.28,142.69 71.28,143.41 C9021.1
UNNAMED_58_AU9542B55GBSGR_I52_1: length 3.4
  TOP w0.356: C9011.1 72.46,119.66 72.46,118.9 v1(72.42,118.86) 72.46,118.82 U9000.23
  TOP w0.381: R9002.2 72.42,119.7 C9011.1
UNNAMED_58_AU9542B55GBSGR_I52_2: length 10.2
  TOP w0.102: v1(67.39,115.05) R9000.2 R9001.2 72.17,113.27 73.11,112.32 U9000.7
UNNAMED_58_AU9542B55GBSGR_I523_: length 3.4
  TOP w0.381: U9000.26 70.51,118.72 v1(70.64,118.86) R9011.1 70.73,119.62 71.45,119.62 R9012.1
UNNAMED_58_CN152G_I567_4: length 19.8
  TOP w0.102: CN9002.4 79.65,155.19 84.74,150.1 84.74,146.8 TP9002.1
UNNAMED_58_CN152G_I567_10: length 18.1
  TOP w0.102: CN9002.10 82.65,153.59 85.88,150.35 85.88,147.51 v1(87.74,145.65) 88.08,145.32 R9044.1
UNNAMED_58_CN152G_I567_12: length 15.5
  TOP w0.356: v1(87.41,149.34) 87.41,150.23 83.65,153.98 CN9002.12
  TOP w0.381: R9049.2 89.1,148.19 88.38,148.19 R9048.1 88.22,148.19 87.49,148.19 C9035.1 v1(87.41,149.34)
UNNAMED_58_CN152G_I567_13: length 7.8
  TOP w0.102: CN9002.13 84.15,157.29 87.28,154.16 TP9001.1
UNNAMED_58_CN152G_I567_15: length 26.2
  TOP w0.356: CN9002.2 78.65,158.99 78.65,158.99 78.9,158.99 79.15,159.24 CN9002.3 ; v2(85.38,158.86) 85.15,159.09 CN9002.15
  TOP w0.381: C9036.1 v2(73.82,159.12) ; C9036.1 74.25,158.4 74.84,158.99 78.65,158.99 ; C9036.1 73.82,158.4 R9045.2 72.85,158.48 72.12,158.48 R9046.1 71.96,158.48 71.24,158.48 R9047.2 v1(70.31,158.4)
  L3 w0.508: v2(73.82,159.12) 78.26,159.12 79.28,160.13 84.36,160.13 85.38,159.12 v2(85.38,158.86)
UNNAMED_58_LEDSINGLE3PINB_I518_: length 82.5
  TOP w0.254: R9031.1 69.37,119.32 v3(69.37,118.86) ; D9031.2 33.21,157.75 32.29,156.83 32.29,153.91 v2(32.93,153.27)
  L6 w0.254: v2(32.93,153.27) 34.65,151.55 34.65,118.27 38.26,114.67 66.33,114.67 69.37,117.71 v3(69.37,118.86)
UNNAMED_64_BEADSINGLE_I40_INA: length 3.4
  BOTTOM w0.254: CN600.4 240.6,45.98 240.07,46.51 239.91,46.51 239.25,47.17 v1(239.25,47.36)
  BOTTOM w0.381: L603.1 v1(239.25,47.36)
UNNAMED_64_RSC0402_I32_B: length 6.5
  BOTTOM w0.254: R640.2 197.46,43.04 v1(196.36,43.04) 195.75,43.04 195.24,43.55 193.43,43.55 193.09,43.89 193.09,44.54 193.62,45.07 MIC600.2
UNNAMED_64_RSC0402_I34_A: length 6
  BOTTOM w0.254: R641.1 244.15,47.86 247.16,47.86 247.86,47.15 247.86,46.45 247.35,45.93 MIC601.2
USB30_D_RX2_DN: length 65.3
  TOP w0.114: U2550.15 276.16,55.25 276.16,54.8 276.49,54.47 278.04,54.47 279.2,55.64 279.2,55.94 v3(278.95,56.2)
  L6 w0.114: CN2400.5 317.7,72.75 317.7,71.87 317.46,71.63 317.21,71.63 316.84,71.99 314.51,71.99 313.86,71.34 313.86,68.49 312.91,67.54 311.83,67.54 310.42,68.95 310.42,72.44 309.31,73.56 303.48,73.56 302.41,72.49 297.38,72.49 296.75,71.87 292.72,71.87 291.48,70.64 291.48,69.06 288.9,66.47 288.71,66.47 288.51,66.47 285.84,63.8 283.43,63.8 282.99,63.36 279.18,63.36 278.55,62.73 278.55,57.27 278.71,57.11 278.71,56.76 278.95,56.51 v3(278.95,56.2)
USB30_D_RX2_DP: length 65.3
  TOP w0.114: v2(279.61,56.25) 279.43,56.07 279.43,55.54 278.13,54.24 276.39,54.24 275.98,54.65 275.98,54.65 275.71,54.92 U2550.14
  L6 w0.114: v2(279.61,56.25) 279.56,56.25 278.95,56.86 278.95,57.21 278.79,57.37 278.79,62.63 279.28,63.12 283.09,63.12 283.53,63.55 285.94,63.55 288.61,66.23 289,66.23 291.73,68.96 291.73,70.54 292.82,71.63 296.85,71.63 297.48,72.25 302.51,72.25 303.58,73.32 309.21,73.32 310.18,72.34 310.18,68.85 311.73,67.3 313.01,67.3 314.1,68.39 314.1,71.24 314.61,71.75 316.74,71.75 317.11,71.39 317.31,71.39 317.7,71 CN2400.6
USB30_D_RX3_DN: length 58.5
  TOP w0.114: U2550.23 278.91,59.06 279.03,58.93 280.45,58.93 280.93,58.46 v2(280.93,58.41)
  L6 w0.114: CN2401.5 317.7,54.25 317.7,53.53 317.5,53.33 317.26,53.33 316.63,53.96 316.63,56.81 316.81,56.98 316.81,59.98 315.88,60.9 315.72,60.9 310.86,65.76 310.86,66.32 306.89,70.29 301.71,70.29 299.55,68.13 292.77,68.13 289.45,64.81 288.94,64.81 286.29,62.17 284.38,62.17 283.25,61.04 283.25,59.64 281.71,58.1 281.24,58.1 v2(280.93,58.41)
USB30_D_RX3_DP: length 58.4
  TOP w0.114: U2550.22 277.84,58.55 278.11,58.83 278.81,58.83 278.94,58.7 279.97,58.7 v3(280.27,58.41)
  L6 w0.114: v3(280.27,58.41) 280.82,57.86 281.81,57.86 283.49,59.54 283.49,60.94 284.48,61.93 286.39,61.93 289.04,64.57 289.55,64.57 292.87,67.89 299.65,67.89 301.81,70.05 306.79,70.05 310.62,66.22 310.62,65.66 315.62,60.66 315.78,60.66 316.57,59.88 316.57,57.08 316.39,56.91 316.39,53.86 317.16,53.09 317.4,53.09 317.7,52.79 317.7,52.25 CN2401.6
USB30_D_TX2_C_DN: length 6.4
  TOP w0.114: C2404.2 314.02,68.39 314.33,68.08 314.76,68.08 v1(315.12,68.44) 315.69,67.87 315.94,67.87 316.39,67.42 316.39,66.47 316.97,65.89 317.34,65.89 317.7,66.25 317.7,66.25 CN2400.8
USB30_D_TX2_C_DP: length 6.4
  TOP w0.114: CN2400.9 317.7,65.28 317.7,65.28 317.33,65.66 316.88,65.66 316.16,66.37 316.16,67.33 315.85,67.64 315.59,67.64 v1(315.12,67.17) 315.12,67.32 314.59,67.85 314.12,67.85 314.02,67.75 C2405.2
USB30_D_TX2_DN: length 60.6
  TOP w0.114: U2550.12 274.71,54.96 274.5,54.75 274.5,54.6 274.81,54.29 v2(274.95,54.29) ; v2(312.33,68.79) 312.68,68.44 313.04,68.44 C2404.1
  L6 w0.114: v2(312.33,68.79) 312.33,68.67 312.53,68.46 312.68,68.46 313.07,68.86 313.07,71.64 309.63,75.09 299.3,75.09 298.83,74.62 296.8,74.62 295.46,73.28 292.13,73.28 285.25,66.39 278.71,66.39 277.25,64.92 277.25,57.99 275.71,56.45 275.13,56.45 274.51,55.83 274.51,55.57 274.64,55.43 274.78,55.43 274.91,55.3 274.91,55.11 274.78,54.98 274.64,54.98 274.51,54.84 274.51,54.64 274.86,54.29 v2(274.95,54.29)
USB30_D_TX2_DP: length 60.6
  TOP w0.114: v2(274.27,54.26) 274.21,54.33 U2550.11 ; C2405.1 312.76,68.08 v3(312.33,68.08)
  L6 w0.114: v3(312.33,68.08) 312.46,68.22 312.78,68.22 313.32,68.76 313.32,71.74 309.73,75.33 299.2,75.33 298.73,74.86 296.7,74.86 295.36,73.52 292.03,73.52 285.15,66.63 278.61,66.63 277.01,65.02 277.01,58.09 275.61,56.69 275.03,56.69 274.27,55.93 v2(274.27,54.26)
USB30_D_TX3_C_DN: length 4.2
  TOP w0.114: C2406.2 315.98,48.97 315.98,48.28 317,47.25 317.56,47.25 317.7,47.4 317.7,48.25 CN2401.8
USB30_D_TX3_C_DP: length 4.2
  TOP w0.114: C2407.2 315.75,48.99 315.75,48.18 316.91,47.03 317.28,47.03 317.7,46.6 317.7,46.25 CN2401.9
USB30_D_TX3_DN: length 60
  TOP w0.114: v3(280.95,57.31) 280.37,57.9 279.71,57.9 279.37,57.55 U2550.20 ; C2406.1 316.11,50.37 316.11,51.52 315.4,52.24 314.55,52.24 314.03,52.76 314.03,56.1 314.9,56.98 315,56.98 v2(315.27,56.7)
  L6 w0.114: v3(280.95,57.31) 281.18,57.08 281.76,57.08 283.99,59.31 283.99,60.56 284.86,61.43 286.6,61.43 289.14,63.97 293.21,63.97 296.25,67.02 303.69,67.02 304.32,67.65 307.71,67.65 315.19,60.17 315.58,60.17 316.07,59.67 316.07,57.3 315.78,57.01 315.58,57.01 v2(315.27,56.7)
USB30_D_TX3_DP: length 59.9
  TOP w0.114: U2550.19 277.85,57.05 278.12,57.33 279.46,57.33 279.81,57.67 280.14,57.67 280.29,57.52 v2(280.29,57.31) ; v3(315.3,57.41) 315.09,57.21 314.81,57.21 313.8,56.2 313.8,52.66 314.45,52.01 315.3,52.01 315.88,51.43 315.88,50.61 C2407.1
  L6 w0.114: v2(280.29,57.31) 280.76,56.84 281.86,56.84 284.23,59.21 284.23,60.46 284.96,61.19 286.7,61.19 289.24,63.73 293.31,63.73 296.35,66.77 303.79,66.77 304.42,67.41 307.61,67.41 315.09,59.93 315.48,59.93 315.83,59.57 315.83,57.4 315.68,57.25 315.46,57.25 v3(315.3,57.41)
USB30_RX0_DN: length 177.9
  L3 w0.102: v3(185.25,78.09) 185.35,78.19 186.01,78.19 187.32,76.87 207.98,76.87 208.72,77.62 208.72,81.92 209.19,82.39 209.19,84.3 209.94,85.06 211.38,85.06 212.3,85.98 214.78,85.98 215.37,86.57 220.23,86.57 223.89,90.24 227.61,90.24 229.28,88.57 231.91,88.57 234.2,90.86 247.73,90.86 248.83,91.96 255.55,91.96 256.89,90.61 260.12,90.61 261.65,92.14 261.65,96.53 264.24,99.12 264.24,101.08 267.07,103.91 267.07,106.57 268.88,108.39 268.88,111.65 269.36,112.13 269.91,112.13 271.34,110.69 282.55,110.69 286.31,114.45 286.31,117.52 291.46,122.67 295.93,122.67 300.54,127.28 302.71,127.28 303.09,126.9 307.75,126.9 308.35,127.49 315.72,127.49 316.23,128 318.06,128 318.89,127.17 318.89,126.15 318.66,125.92 v2(318.58,125.92)
  BOTTOM w0.114: v3(185.25,78.09) 185,78.09 U4555.G20 ; CN3601.88 320.41,127.2 320.28,127.07 319.65,127.07 318.87,126.28 318.87,126.13 318.65,125.91 318.65,125.92 v2(318.58,125.92)
USB30_RX0_DP: length 177.9
  L3 w0.102: v2(185.15,78.75) 185.5,78.4 186.1,78.4 187.41,77.09 207.89,77.09 208.51,77.71 208.51,82.01 208.97,82.48 208.97,84.39 209.85,85.27 211.29,85.27 212.21,86.2 214.69,86.2 215.28,86.79 220.14,86.79 223.8,90.45 227.7,90.45 229.37,88.79 231.82,88.79 234.11,91.08 247.64,91.08 248.74,92.17 255.63,92.17 256.98,90.82 260.03,90.82 261.44,92.23 261.44,96.62 264.03,99.21 264.03,101.17 266.85,104 266.85,106.66 268.67,108.48 268.67,111.74 269.27,112.34 270,112.34 271.43,110.91 282.46,110.91 286.09,114.54 286.09,117.61 291.37,122.88 295.84,122.88 300.45,127.49 302.8,127.49 303.18,127.11 307.66,127.11 308.26,127.71 315.63,127.71 316.14,128.22 318.15,128.22 319.1,127.26 319.1,126.01 v3(319.26,125.85)
  BOTTOM w0.114: CN3601.87 320.41,126.7 320.28,126.84 319.75,126.84 319.1,126.19 319.1,126.01 v3(319.26,125.85) ; v2(185.15,78.75) 185,78.75 184.71,78.45 U4555.H20
USB30_RX1_DN: length 209.5
  L6 w0.114: v2(184.22,76.09) 184.03,76.09 182.54,74.6 178.53,74.6 176.82,72.9 176.6,72.9 176.6,72.9 173.36,72.9 171.72,71.26 170.58,71.26 170.22,70.9 168.98,70.9 168.93,70.9 168.93,70.9 166.17,70.9 165.53,71.55 153.56,71.55 151.98,73.13 151.98,75.76 149.15,78.59 147.09,78.59 144.69,80.99 143.71,80.99 142.99,81.7 142.99,82.73 142.01,83.72 141.13,83.72 137.26,87.59 126.41,87.59 124.28,89.71 119.86,89.71 118.52,91.04 118.52,91.78 117.51,92.8 116.01,92.8 112.64,96.17 107.34,96.17 106,94.83 103.51,94.83 101.91,96.43 98.56,96.43 96.22,94.09 93.08,94.09 91.84,92.85 91.84,91.73 88.13,88.03 88.13,84.9 87.05,83.82 82.7,83.82 82.06,84.46 51.26,84.46 48.7,81.9 47.99,81.9 46.48,80.39 45.4,80.39 41.66,76.65 41.66,61.18 43.25,59.59 43.25,41.72 42.31,40.78 41.59,40.78 41.2,40.39 CN2500.5
  BOTTOM w0.114: U4555.E18 183.76,76.5 184.17,76.09 v2(184.22,76.09)
USB30_RX1_DP: length 209.5
  L6 w0.114: CN2500.6 41.2,41.57 41.75,41.02 42.21,41.02 43.01,41.82 43.01,59.49 41.42,61.08 41.42,76.75 45.3,80.63 46.38,80.63 47.89,82.14 48.6,82.14 51.16,84.7 82.16,84.7 82.8,84.06 86.95,84.06 87.89,85 87.89,88.13 91.6,91.83 91.6,92.95 92.98,94.33 96.12,94.33 98.46,96.67 102.01,96.67 103.61,95.07 105.9,95.07 107.24,96.41 112.74,96.41 116.11,93.04 117.61,93.04 118.76,91.88 118.76,91.14 119.96,89.95 124.38,89.95 126.51,87.83 137.36,87.83 141.23,83.96 142.11,83.96 143.23,82.83 143.23,81.8 143.81,81.23 144.79,81.23 147.19,78.83 149.25,78.83 152.22,75.86 152.22,73.23 153.66,71.79 165.63,71.79 166.28,71.14 170.12,71.14 170.48,71.5 171.62,71.5 173.26,73.14 176.62,73.14 176.62,73.14 176.72,73.14 178.43,74.84 182.43,74.84 183.86,76.27 183.86,76.37 v2(184.21,76.72)
  BOTTOM w0.114: U4555.F18 183.76,77.15 184.19,76.72 v2(184.21,76.72)
USB30_RX2_C_DN: length 2.6
  TOP w0.114: C2567.2 266.44,60.61 266.89,60.61 267.06,60.44 267.63,60.44 267.71,60.36 267.71,60.19 267.85,60.05 U2550.56
USB30_RX2_C_DP: length 2.6
  TOP w0.114: C2568.2 266.27,61.21 266.64,60.84 266.98,60.84 267.18,60.64 267.72,60.64 267.8,60.55 U2550.55
USB30_RX2_DN: length 99.4
  TOP w0.114: C2567.1 265.31,60.54 264.6,60.54 v2(264.09,61.05)
  L6 w0.114: v3(183.2,77.48) 183.2,77.33 183.34,77.19 183.66,77.19 183.85,77.38 184.46,77.38 184.86,76.98 184.86,76.34 186.63,74.57 203.31,74.57 203.89,73.99 208.05,73.99 209.77,72.26 211.16,72.26 212.31,71.11 212.31,70.28 213.09,69.5 213.09,60.95 214.51,59.52 221.56,59.52 222.33,60.3 226.75,60.3 228.77,62.32 255.78,62.32 256.76,61.34 260.32,61.34 261.4,60.26 263.92,60.26 264.31,60.64 264.31,60.83 v2(264.09,61.05)
  BOTTOM w0.114: v3(183.2,77.48) 183.13,77.48 182.8,77.8 U4555.G17
USB30_RX2_DP: length 99.4
  TOP w0.114: v2(264.75,61.03) 264.88,60.9 265.43,60.9 265.56,61.03 265.56,61.22 265.46,61.33 C2568.1
  L6 w0.114: v2(264.75,61.03) 264.71,61.03 264.55,60.87 264.55,60.54 264.02,60.01 261.3,60.01 260.22,61.1 256.66,61.1 255.68,62.08 228.87,62.08 226.85,60.05 222.43,60.05 221.66,59.28 214.41,59.28 212.85,60.84 212.85,69.4 212.07,70.18 212.07,71.01 211.06,72.02 209.67,72.02 207.95,73.75 203.79,73.75 203.21,74.33 186.53,74.33 184.61,76.24 184.61,76.88 184.36,77.14 183.95,77.14 183.76,76.95 183.32,76.95 183.2,76.83 v2(183.2,76.81)
  BOTTOM w0.114: v2(183.2,76.81) 183.15,76.81 182.8,77.15 U4555.F17
USB30_TX0_DN: length 167
  L3 w0.102: v4(193.92,72.72) 194.49,72.15 194.49,71.32 194.71,71.11 195.28,71.11 195.92,71.74 195.92,72.83 197.29,74.21 216.65,74.21 222.61,80.17 224.1,80.17 224.49,80.17 226.05,81.73 226.05,82.56 227.8,84.31 230.89,84.31 232.55,85.98 233.33,85.98 235.37,88.01 242.79,88.01 245.57,85.24 249.8,85.24 250.77,84.27 254.85,84.27 256.38,85.8 257.5,85.8 264.36,92.66 264.36,96.55 268.54,100.73 268.54,105.39 271.44,108.28 272.75,108.28 274.67,110.21 282.75,110.21 286.79,114.25 286.79,117.32 291.66,122.18 296.13,122.18 300.04,126.1 307.79,126.1 308.64,126.95 316.55,126.95 316.76,127.15 316.76,127.31 v3(316.52,127.55)
  BOTTOM w0.076: v4(193.92,72.72) 193.92,73.1 193.71,73.32 193.61,73.41 193.61,74.65 193.54,74.73 193.54,74.91 U4555.C33
  BOTTOM w0.114: v3(316.52,127.55) 316.79,127.82 316.79,128.27 317.08,128.56 320.28,128.56 320.41,128.7 CN3601.91
USB30_TX0_DP: length 167.1
  L3 w0.102: v2(317.28,127.55) 316.98,127.24 316.98,127.06 316.64,126.73 308.73,126.73 307.88,125.88 300.13,125.88 296.22,121.97 291.75,121.97 287.01,117.23 287.01,114.16 282.84,109.99 274.76,109.99 272.84,108.07 271.53,108.07 268.76,105.3 268.76,100.64 264.57,96.46 264.57,92.57 257.59,85.58 256.47,85.58 254.94,84.06 250.68,84.06 249.71,85.02 245.48,85.02 242.7,87.8 235.46,87.8 233.42,85.76 232.64,85.76 230.98,84.1 227.89,84.1 226.27,82.47 226.27,81.64 224.58,79.95 224.01,79.95 224.01,79.95 222.7,79.95 216.74,73.99 197.38,73.99 196.13,72.74 196.13,71.65 195.37,70.89 194.62,70.89 194.28,71.24 194.28,71.69 v3(193.95,72.02)
  BOTTOM w0.076: U4555.B34 193.78,74.81 193.78,73.48 193.87,73.39 193.87,73.39 194.33,72.93 194.33,72.56 193.95,72.18
  BOTTOM w0.114: 193.95,72.18 v3(193.95,72.02) ; CN3601.90 320.41,128.2 320.28,128.34 317.17,128.34 317.01,128.18 317.01,127.82 v2(317.28,127.55)
USB30_TX1_C_DN: length 7.8
  BOTTOM w0.114: CN2500.8 41.2,46.25 41.55,46.6 41.86,46.6 42.64,47.38 42.64,50.64 v1(43.14,51.15) 42.61,51.68 42.61,51.92 C2500.2
USB30_TX1_C_DP: length 7.7
  BOTTOM w0.114: CN2500.9 41.2,47.02 41.39,46.83 41.76,46.83 42.41,47.48 42.41,50.61 v1(41.87,51.15) 42.38,51.65 42.38,51.95 C2501.2
USB30_TX1_DN: length 209
  L6 w0.114: v2(193.06,72.97) 192.93,72.84 192.61,72.84 191.83,73.62 188.48,73.62 187.28,72.42 184.2,72.42 182.73,73.89 178.79,73.89 177.35,72.46 173.51,72.46 172.61,71.56 172.61,70.7 171.88,69.96 167.94,69.96 167.66,69.68 164.99,69.68 164.61,70.06 164.61,70.57 164.13,71.05 152.98,71.05 151.35,72.68 151.35,73.42 145.69,79.08 144.62,79.08 143.98,79.73 143.98,79.84 142.22,81.6 141.79,81.6 140.23,83.17 140.23,83.69 136.82,87.09 127.8,87.09 126.2,87.09 124.3,89 119.83,89 118.85,89.98 118.03,89.98 112.42,95.59 107.76,95.59 106.51,94.33 103.26,94.33 101.79,95.8 98.63,95.8 96.31,93.47 95.6,93.47 94.02,91.89 94.02,88.14 93.36,87.48 90.72,87.48 90.08,86.83 89.16,86.83 88.68,86.35 88.68,85.46 89.24,84.9 89.24,83.13 88.14,82.03 86.31,82.03 85.98,82.35 73.71,82.35 72.85,83.21 51.04,83.21 49,81.18 48.58,81.18 47.15,79.74 45.45,79.74 42.2,76.48 42.2,63.03 42.45,62.78 42.81,62.78 42.97,62.61 v4(42.97,62.6)
  BOTTOM w0.114: U4555.B33 193.26,74.53 193.26,74.33 192.9,73.97 192.9,73.41 193.06,73.25 v2(193.06,72.97) ; C2500.1 42.87,53.12 42.56,53.43 42.56,53.8 43.23,54.47 43.23,59.79 42.31,60.71 42.31,62.77 42.49,62.94 42.63,62.94 v4(42.97,62.6)
USB30_TX1_DP: length 208.9
  L6 w0.114: v3(42.97,63.54) 42.97,63.19 42.8,63.02 42.55,63.02 42.44,63.13 42.44,76.38 45.55,79.5 47.25,79.5 48.68,80.93 49.1,80.93 51.14,82.97 72.75,82.97 73.61,82.11 85.88,82.11 86.21,81.79 88.24,81.79 89.48,83.03 89.48,85 88.92,85.56 88.92,86.24 89.26,86.59 90.18,86.59 90.82,87.23 93.46,87.23 94.27,88.04 94.27,91.79 95.7,93.23 96.41,93.23 98.73,95.56 101.69,95.56 103.16,94.09 106.61,94.09 107.86,95.34 112.32,95.34 117.93,89.74 118.75,89.74 119.73,88.76 124.2,88.76 126.1,86.85 127.9,86.85 136.72,86.85 139.99,83.59 139.99,83.07 141.69,81.36 142.12,81.36 143.74,79.74 143.74,79.63 144.52,78.84 145.59,78.84 151.11,73.32 151.11,72.58 152.88,70.81 164.03,70.81 164.37,70.47 164.37,69.96 164.89,69.44 167.76,69.44 168.04,69.72 171.98,69.72 172.85,70.6 172.85,71.46 173.61,72.22 177.45,72.22 178.89,73.65 182.63,73.65 184.1,72.18 187.38,72.18 188.58,73.37 191.73,73.37 192.51,72.59 192.85,72.59 v2(193.1,72.35)
  BOTTOM w0.114: v3(42.97,63.54) 42.6,63.17 42.39,63.17 42.08,62.86 42.08,60.61 43,59.69 43,54.56 42.34,53.89 42.34,53.38 C2501.1 ; U4555.A33 193.26,73.88 193.26,73.37 193.49,73.15 193.49,72.79 193.1,72.4 v2(193.1,72.35)
USB30_TX2_C_DN: length 2.6
  TOP w0.114: C2569.2 266.55,58.06 266.98,58.06 267.61,58.69 267.98,58.69 268.12,58.55 U2550.59
USB30_TX2_C_DP: length 2.7
  TOP w0.114: U2550.58 268.12,59.06 267.98,58.92 267.52,58.92 266.88,58.28 266.64,58.28 C2570.2
USB30_TX2_DN: length 92.3
  TOP w0.114: v3(264.53,58.74) 264.88,58.74 265.01,58.61 265.01,58.31 265.42,57.9 C2569.1
  L6 w0.114: v3(264.53,58.74) 264.44,58.74 264.22,58.96 264.22,59.25 263.94,59.52 261.09,59.52 260.01,60.6 256.23,60.6 255.37,61.47 229.24,61.47 227.33,59.55 222.66,59.55 221.87,58.76 213.66,58.76 212.3,60.12 212.3,66.28 209.91,68.67 209.91,70.8 207.4,73.31 197.24,73.31 195.15,71.22 193.22,71.22 192.61,71.84 192.61,71.91 v2(192.28,72.23)
  BOTTOM w0.076: v2(192.28,72.23) 192.4,72.34 192.4,73.38 192.18,73.6 192.18,73.96 192.12,74.08 192.12,74.3 192.14,74.38 192.15,74.39 192.18,74.45 192.18,74.58 192.15,74.69 191.94,74.89 191.76,74.89 191.59,75.06 191.59,75.24 191.32,75.51 U4555.C30
USB30_TX2_DP: length 92.3
  TOP w0.114: C2570.1 265.42,58.68 264.85,59.24 264.29,59.24 263.85,58.8 v2(263.85,58.75)
  L6 w0.114: v2(192.28,71.54) 192.48,71.54 193.04,70.98 195.25,70.98 197.34,73.07 207.3,73.07 209.67,70.7 209.67,68.57 212.06,66.18 212.06,60.02 213.56,58.52 221.97,58.52 222.76,59.31 227.43,59.31 229.34,61.22 255.27,61.22 256.13,60.36 259.91,60.36 260.99,59.28 263.84,59.28 263.98,59.15 263.98,58.83 263.89,58.75 v2(263.85,58.75)
  BOTTOM w0.076: U4555.C31 192.02,75.07 192.2,74.91 192.3,74.76 192.34,74.61 192.34,74.42 192.33,74.39 192.31,74.34 192.31,74.33 192.28,74.27 192.28,74.16 192.34,73.99 192.34,73.67 192.56,73.45 192.56,72.49 192.67,72.39 192.67,71.92 v2(192.28,71.54)
USB_D_P1_DN: length 196.5
  TOP w0.114: U2550.2 269.68,55.28 269.68,54.49 v2(269.88,54.28) ; v3(129.01,76.92) 128.86,77.07 128.11,77.07 127.39,77.79 127.39,79.24 128.33,80.18 128.33,82.79 128.33,83.08 128.61,83.36 128.61,85.97 128.31,86.27 128.31,90.96 128.56,91.21 128.56,92.73 127.84,93.44 122.43,93.44 120.63,95.24 120.63,97.6 120.4,97.83 120.4,99.65 121.89,101.14 122.55,101.14 122.84,101.43 122.84,101.84 122.59,102.09 L3001.1
  L6 w0.114: v3(129.01,76.92) 128.99,76.95 128.73,76.95 128.62,76.83 128.62,75.93 129.59,74.95 130.23,74.95 132.11,73.07 132.11,70.06 139.2,62.98 152.89,62.98 153.4,63.49 160.47,63.49 163.17,60.78 170.15,53.81 173.05,53.81 175.03,51.83 228.55,51.83 228.85,51.54 230.34,51.54 230.92,52.12 230.92,52.34 232.96,54.38 238.37,54.38 239.19,53.57 247.11,53.57 248.6,52.08 260.53,52.08 261.11,51.5 266.71,51.5 268.33,53.12 268.33,54.39 268.91,54.98 269.49,54.98 269.74,54.72 269.74,54.42 v2(269.88,54.28)
USB_D_P1_DP: length 196.4
  TOP w0.114: v2(269.22,54.28) 269.33,54.28 269.45,54.39 269.45,54.65 269.21,54.89 U2550.1 ; v4(128.51,77.53) 128.51,77.51 128.3,77.3 128.2,77.3 127.62,77.89 127.62,79.15 128.56,80.09 128.56,82.89 128.56,82.98 128.84,83.26 128.84,86.07 128.54,86.36 128.54,90.87 128.78,91.11 128.78,92.82 127.94,93.67 122.52,93.67 120.86,95.33 120.86,97.7 120.63,97.93 120.63,99.56 121.98,100.91 122.64,100.91 123.07,101.34 123.07,101.66 123.18,101.78 123.29,101.78 123.6,102.09 L3001.4
  L6 w0.114: v2(269.22,54.28) 269.31,54.28 269.5,54.47 269.5,54.62 269.39,54.73 269.01,54.73 268.57,54.29 268.57,53.02 266.81,51.25 261.01,51.25 260.43,51.84 248.5,51.84 247.01,53.33 239.09,53.33 238.27,54.14 233.06,54.14 231.16,52.24 231.16,52.02 230.44,51.29 228.75,51.29 228.45,51.59 174.93,51.59 172.95,53.56 170.05,53.56 163.07,60.54 160.37,63.24 153.5,63.24 152.99,62.74 139.1,62.74 131.87,69.96 131.87,72.97 130.13,74.71 129.49,74.71 128.38,75.83 128.38,77.4 v4(128.51,77.53)
USB_D_P1_L_DN: length 13.2
  TOP w0.114: v3(122.71,105.1) 122.86,105.1 123.06,104.9 123.06,104.57 122.59,104.11 L3001.2
  BOTTOM w0.114: CN3000.39 113.48,106.75 113.61,106.89 122.24,106.89 123.04,106.09 123.04,105.43 v3(122.71,105.1)
USB_D_P1_L_DP: length 13.3
  TOP w0.114: L3001.3 123.6,104.13 123.29,104.44 123.29,104.9 v4(123.48,105.1)
  BOTTOM w0.114: CN3000.38 113.47,107.25 113.6,107.12 122.34,107.12 123.27,106.18 123.27,105.31 v4(123.48,105.1)
USB_D_P2_DN: length 60
  TOP w0.114: U2550.10 273.59,55.19 273.59,54.57 v2(273.68,54.48) ; v3(310.87,69.78) 311.05,69.96 311.44,69.96 311.88,69.52 L2400.4
  L6 w0.114: v3(310.87,69.78) 311.01,69.92 311.66,69.92 311.94,70.2 311.94,72.06 309.69,74.31 302.8,74.31 302.29,73.81 299.5,73.81 299.28,74.03 296.98,74.03 295.64,72.68 292.24,72.68 284.47,64.91 278.29,64.91 277.79,64.41 277.79,57.78 276.22,56.21 276.22,54.01 275.65,53.44 273.54,53.44 273.4,53.58 273.4,54.2 v2(273.68,54.48)
USB_D_P2_DP: length 59.8
  TOP w0.114: U2550.9 273.31,55.2 273.31,54.65 273.15,54.49 v2(272.99,54.49) ; L2400.1 311.74,70.52 311.41,70.19 311.15,70.19 310.87,70.47 v2(310.87,70.47)
  L6 w0.114: v2(272.99,54.49) 273.16,54.32 273.16,53.48 273.44,53.2 275.75,53.2 276.46,53.91 276.46,56.11 278.04,57.68 278.04,64.31 278.39,64.67 284.57,64.67 292.34,72.44 295.74,72.44 297.08,73.78 299.18,73.78 299.4,73.57 302.39,73.57 302.9,74.07 309.59,74.07 311.7,71.96 311.7,70.3 311.56,70.17 311.17,70.17 v2(310.87,70.47)
USB_D_P2_L_DN: length 7.6
  TOP w0.114: CN2400.2 319.2,68.44 319.2,68.44 318.04,69.61 317.33,69.61 316.74,69.02 315.36,69.02 314.47,69.91 314.13,69.91 313.74,69.52 L2400.3
USB_D_P2_L_DP: length 7.6
  TOP w0.114: L2400.2 313.8,70.52 314.18,70.14 314.56,70.14 315.45,69.25 316.64,69.25 317.23,69.84 318.03,69.84 318.53,70.34 318.53,70.46 318.73,70.66 319.01,70.66 319.2,70.46 CN2400.3
USB_D_P3_DN: length 62.9
  TOP w0.114: U2550.18 277.93,56.55 v2(278.29,56.2) ; L2404.4 314.87,55.51 314.87,55.64 315.44,56.21 315.48,56.21 315.77,56.5 315.77,56.5 315.98,56.7 315.98,60.01 315.68,60.31 315.68,61.7 315.94,61.96 316.39,61.96 v2(316.52,62.09)
  L6 w0.114: v2(278.29,56.2) 278.65,55.84 278.87,55.61 279.76,55.61 280.05,55.9 280.05,56.48 279.5,57.03 279.5,58.56 280.02,59.09 281.64,59.09 282.51,59.96 282.51,61.65 283.77,62.91 285.99,62.91 288.82,65.74 289.27,65.74 293.09,69.56 294.01,69.56 295.1,70.65 297.06,70.65 297.8,71.38 302.95,71.38 303.87,72.3 306.81,72.3 309.65,69.47 309.65,68.65 311.68,66.62 311.68,66.2 315.92,61.96 316.39,61.96 v2(316.52,62.09)
USB_D_P3_DP: length 62.8
  TOP w0.114: v2(278.14,55.48) 278.14,55.71 277.79,56.06 U2550.17 ; v2(316.52,61.45) 316.52,61.5 316.29,61.73 316.03,61.73 315.91,61.61 315.91,60.4 316.2,60.11 316.2,56.61 315.87,56.27 315.86,56.27 315.57,55.98 315.53,55.98 315.37,55.82 315.37,55.52 L2404.1
  L6 w0.114: v2(316.52,61.45) 316.52,61.52 316.31,61.72 315.82,61.72 311.44,66.1 311.44,66.52 309.4,68.55 309.4,69.37 306.71,72.06 303.97,72.06 303.05,71.14 297.9,71.14 297.16,70.41 295.2,70.41 294.11,69.31 293.19,69.31 289.37,65.5 288.92,65.5 286.09,62.66 283.87,62.66 282.75,61.55 282.75,59.86 281.74,58.85 280.12,58.85 279.74,58.46 279.74,57.14 280.3,56.58 280.3,55.8 279.86,55.37 278.77,55.37 278.49,55.66 278.31,55.66 v2(278.14,55.48)
USB_D_P3_L_DN: length 7.1
  TOP w0.114: CN2401.2 318.53,49.92 318.53,50.65 318.09,51.09 316.94,51.09 316.6,51.43 316.6,51.73 315.6,52.73 315.36,52.73 314.62,53.47 L2404.3
USB_D_P3_L_DP: length 7.2
  TOP w0.114: CN2401.3 319.2,51.25 319.2,52.21 319.01,52.41 318.78,52.41 318.53,52.16 318.53,51.81 318.04,51.32 317.04,51.32 316.83,51.52 316.83,51.82 315.7,52.96 315.45,52.96 315.32,53.09 315.32,53.37 L2404.2
USB_HUB_RST#: length 197.5
  TOP w0.076: 175.04,94.22 175.57,93.69 175.57,91.81 175.77,91.6 v2(176,91.6)
  TOP w0.102: v2(261.53,58.74) 262.36,58.74 D2551.2 263,59.38 R4839.1 ; v2(170.05,107.98) 170.05,107.58 170.84,106.79 v1(173.39,106.79) 173.77,106.79 174.24,106.32 174.24,105.78 174.02,105.56 174.02,100.82 173.39,100.19 173.39,96.79 174.61,95.57 174.61,94.65 175.04,94.22 ; v2(260.69,110.35) 260.69,110.86 260.26,111.29 260.26,112.46 261.4,113.6 v2(263.66,113.6)
  L3 w0.076: v2(170.44,90.56) 171.89,92.01 174.38,92.01 174.76,91.63 175.97,91.63 v2(176,91.6)
  L5 w0.102: v2(262.77,70.09) 262.77,70.65 264.9,72.78 264.9,77.1 266.33,78.52 266.33,80.93 266.91,81.52 266.91,85.08 265.79,86.19 265.79,90.81 264.45,92.15 264.45,101.1 266.22,102.88 266.22,105.65 265.06,106.82 263.71,106.82 260.69,109.84 v2(260.69,110.35)
  BOTTOM w0.076: U4555.AL2 174.19,90.85 173.73,90.39 170.55,90.39 170.44,90.5 v2(170.44,90.56)
  BOTTOM w0.102: v2(261.53,58.74) 260.74,59.52 260.74,62.57 261.25,63.08 261.25,65.64 261.78,66.18 261.78,69.76 262.03,70.01 262.69,70.01 v2(262.77,70.09) ; v2(170.05,107.98) 170.21,108.15 170.21,108.82 174.4,113.02 207.06,113.02 207.06,113.01 212.03,113.01 212.32,113.01 212.33,113.02 212.7,113.39 243.53,113.39 243.74,113.6 244.11,113.97 244.91,113.97 245.88,114.93 256.03,114.93 256.55,114.41 262.29,114.41 263.1,113.6 v2(263.66,113.6)
USB_P0_DN: length 188.5
  L3 w0.102: CN3601.45 324.23,128.88 324.23,129.52 323.61,130.14 322.75,130.14 322.05,129.43 313,129.43 312.16,128.6 308.93,128.6 307.84,129.69 303.8,129.69 303.13,129.02 300.95,129.02 296.38,124.45 293.45,124.45 292.77,123.76 291.26,123.76 288.86,121.36 287.93,121.36 285.4,118.83 285.4,114.83 282.27,111.71 271.9,111.71 271.39,112.21 271.39,112.55 270.71,113.23 269.11,113.23 267.68,111.8 267.68,111 266.1,109.42 266.1,104.25 263.27,101.42 262.8,101.42 254.51,93.13 248.7,93.13 247.39,91.81 233.86,91.81 231.53,89.48 229.66,89.48 227.99,91.15 223.49,91.15 219.84,87.5 213.51,87.5 213.21,87.79 212.32,87.79 211.24,86.71 207.59,86.71 207.05,86.18 207.05,81.84 205.28,80.06 189.76,80.06 187.93,81.89 187.93,84 186.1,85.82 185.36,85.82 185.01,86.18 185.01,87.97 184.56,88.42 181.73,88.42 179.79,90.36 179.79,90.65 179.79,90.92 178.99,91.71 178.62,91.71 178.32,92.02 v2(178.32,92.03)
  BOTTOM w0.114: v2(178.32,92.03) 178.26,91.97 177.94,91.97 177.84,92.07 U4555.AN8
USB_P0_DP: length 188.7
  L3 w0.102: CN3601.44 323.2,128.36 324.01,129.17 324.01,129.43 323.52,129.92 322.84,129.92 322.14,129.22 313.09,129.22 312.25,128.38 308.84,128.38 307.75,129.47 303.89,129.47 303.22,128.8 301.04,128.8 296.47,124.23 293.54,124.23 292.86,123.54 291.34,123.54 288.95,121.15 288.02,121.15 285.61,118.74 285.61,114.74 282.36,111.49 271.81,111.49 271.18,112.13 271.18,112.46 270.62,113.02 269.2,113.02 267.89,111.71 267.89,110.91 266.31,109.33 266.31,104.16 263.35,101.2 262.89,101.2 254.6,92.91 248.79,92.91 247.48,91.6 233.94,91.6 231.62,89.27 229.57,89.27 227.9,90.93 223.58,90.93 219.93,87.28 213.42,87.28 213.13,87.58 212.41,87.58 211.33,86.5 207.68,86.5 207.27,86.09 207.27,81.75 205.37,79.84 189.67,79.84 187.71,81.8 187.71,83.91 186.01,85.61 185.27,85.61 184.79,86.09 184.79,87.88 184.47,88.2 181.64,88.2 179.57,90.27 179.57,90.74 179.57,90.83 178.92,91.48 178.4,91.48 v2(178.3,91.38)
  BOTTOM w0.114: U4555.AM8 177.84,91.64 177.87,91.67 178.01,91.67 v2(178.3,91.38)
USB_P1_CH_DN: length 29.7
  TOP w0.114: L2500.2 41.7,54.02 42,54.32 42,54.96 v3(41.73,55.22)
  BOTTOM w0.114: v3(41.73,55.22) 41.91,55.4 41.91,59.39 41.18,60.11 41.18,63.1 41.75,63.67 41.75,76.06 39.95,77.85 39.95,80.62 40.29,80.96 40.36,80.96 40.57,81.16 U2511.11
USB_P1_CH_DP: length 29.7
  TOP w0.114: v4(42.51,55.24) 42.35,55.24 42.23,55.12 42.23,54.38 42.7,53.92 L2500.3
  BOTTOM w0.114: U2511.10 40.94,80.73 40.39,80.73 40.18,80.53 40.18,77.95 41.97,76.15 41.97,63.57 41.41,63.01 41.41,60.21 42.14,59.48 42.14,55.41 42.3,55.24 v4(42.51,55.24)
USB_P1_CH_L_DN: length 11.1
  TOP w0.114: CN2500.2 39.7,44.73 39.82,44.61 40.44,44.61 40.77,44.94 41.65,44.94 42.47,45.76 42.47,47.3 42.25,47.52 42.25,47.76 42.47,47.98 42.47,48.22 42.25,48.44 42.25,48.68 42.47,48.9 42.47,49.14 42.25,49.36 42.25,49.6 42.47,49.82 42.47,50.06 42.25,50.28 42.25,50.52 42.47,50.74 42.47,51.23 42.33,51.38 41.86,51.38 41.7,51.54 L2500.1
USB_P1_CH_L_DP: length 11.1
  TOP w0.114: L2500.4 42.7,45.66 41.75,44.71 40.87,44.71 39.7,43.55 CN2500.3
USB_P1_DN: length 146.5
  L3 w0.102: v3(44.99,81.54) 45.12,81.41 45.12,81.16 45.04,81.09 45.04,80.71 45.33,80.41 46.34,80.41 47.86,81.93 48.78,81.93 53.15,86.3 62.52,86.3 66.42,90.19 72.46,90.19 74.71,87.95 81.01,87.95 81.95,88.89 87.26,88.89 89.03,87.11 91.17,87.11 91.35,87.28 100.72,87.28 103.08,89.65 118.3,89.65 118.98,88.97 126.37,88.97 127.56,87.77 138.39,87.77 139.44,86.72 141.9,86.72 142.19,87.01 143.24,87.01 144,86.25 147.46,86.25 149.9,88.69 156.5,88.69 156.95,89.13 159.34,89.13 159.57,89.37 163.85,89.37 165.01,90.53 168.82,90.53 170.99,92.69 175.29,92.69 175.74,93.15 176.6,93.15 v2(176.86,92.88)
  BOTTOM w0.114: U4555.AR7 177.24,93.26 v2(176.86,92.88) ; U2511.2 43.98,81.14 44.77,81.14 44.99,81.36 v3(44.99,81.54)
USB_P1_DP: length 146.5
  L3 w0.102: v2(176.86,93.53) 176.69,93.36 175.65,93.36 175.2,92.91 170.9,92.91 168.73,90.75 164.92,90.75 163.76,89.58 159.48,89.58 159.25,89.35 156.86,89.35 156.41,88.9 149.81,88.9 147.37,86.46 144.09,86.46 143.33,87.23 142.1,87.23 141.81,86.93 139.53,86.93 138.48,87.99 127.65,87.99 126.46,89.18 119.07,89.18 118.39,89.86 102.99,89.86 100.63,87.5 91.26,87.5 91.08,87.32 89.12,87.32 87.35,89.1 81.86,89.1 80.92,88.16 74.8,88.16 72.55,90.41 66.33,90.41 62.43,86.51 53.06,86.51 48.69,82.14 47.77,82.14 46.25,80.63 45.42,80.63 45.26,80.8 45.26,81 45.4,81.14 v2(45.63,81.14)
  BOTTOM w0.114: v2(45.63,81.14) 45.09,81.14 44.86,80.91 44.61,80.91 44.36,80.66 U2511.3 ; U4555.AT7 176.89,93.53 v2(176.86,93.53)
USB_P2_DN: length 139
  TOP w0.114: v2(267.47,61.3) 267.77,61.3 268.02,61.05 U2550.54
  L3 w0.076: v2(178.23,93.91) 177.93,93.61 177.63,93.61 177.24,93.23 177.24,91.43 177.01,91.2 175.8,91.2 175.6,91.4 174.93,91.4 173.52,91.4
  L3 w0.102: 173.52,91.4 173.26,91.14 172.66,91.14 171.87,90.35 170.99,90.35 168.25,87.61 168.25,80.63 167.8,80.18 167.8,78.22 169.79,76.22 170.05,76.22 172.57,73.7 182.73,73.7 183.15,73.28 183.15,72.97 183.91,72.22 184.46,72.22 186.38,70.3 186.38,68.78 187.26,67.9 189.87,67.9 190.41,67.36 190.41,63.1 191.43,62.08 197.56,62.08 198.96,60.68 217.19,60.68 217.46,60.95 217.46,61.29 v3(217.64,61.48)
  L6 w0.114: v2(267.47,61.3) 267.32,61.45 267.32,61.81 267.05,62.08 257.07,62.08 256.56,62.58 256.09,63.05 228.29,63.05 226.27,61.03 221.86,61.03 221.34,60.51 217.8,60.51 217.49,60.82 217.49,61.33 v3(217.64,61.48)
  BOTTOM w0.114: U4555.AR8 178.17,93.91 v2(178.23,93.91)
USB_P2_DP: length 138.9
  TOP w0.114: v2(266.85,61.33) 267.23,61.71 267.64,61.71 267.79,61.55 U2550.53
  L3 w0.076: v2(178.25,93.22) 178.02,93.45 177.7,93.45 177.41,93.16 177.41,91.36 177.08,91.03 175.74,91.03 175.53,91.23 174.87,91.23 174.22,91.23 174.22,91.23 173.66,91.23 173.57,91.14
  L3 w0.102: 173.57,91.14 173.35,90.92 172.75,90.92 171.96,90.13 171.08,90.13 168.46,87.52 168.46,80.54 168.01,80.09 168.01,78.31 169.88,76.44 170.14,76.44 172.66,73.91 182.82,73.91 183.37,73.37 183.37,73.06 184,72.43 184.55,72.43 186.6,70.39 186.6,68.87 187.35,68.12 189.96,68.12 190.62,67.45 190.62,63.19 191.52,62.29 197.65,62.29 199.05,60.89 217.1,60.89 217.24,61.03 217.24,61.31 217.07,61.48 v2(216.96,61.48)
  L6 w0.114: v2(216.96,61.48) 217.25,61.19 217.25,60.72 217.7,60.27 221.44,60.27 221.96,60.79 226.37,60.79 228.39,62.81 255.99,62.81 256.39,62.41 256.96,61.83 266.95,61.83 267.07,61.71 267.07,61.56 v2(266.85,61.33)
  BOTTOM w0.114: v2(178.25,93.22) 178.05,93.22 177.84,93 177.84,92.94 U4555.AP8
USB_P3_DN: length 238.3
  L6 w0.114: v2(178.75,93.61) 178.89,93.61 179.51,94.23 179.51,95.75 178.5,96.77 176.74,96.77 175.9,97.61 175.9,97.94 175.52,98.31 174.31,98.31 171.67,100.96 170.88,100.96 161.45,110.39 161.45,113.9 163.86,116.32 163.86,141.39 165.18,142.71 195.55,142.71 196.34,143.51 199.64,143.51 200.78,142.36 224.99,142.36 225.55,142.93 235.58,142.93 236.23,142.28 263.3,142.28 264.21,141.37 271.92,141.37 275.67,137.62 275.67,137.26 275.67,136.43 277.07,135.03 277.77,134.33 282.18,129.92 282.18,126.02 282.18,125.51 283.78,123.91 283.78,120.88 285.17,119.49 288.97,119.49 291.77,122.29 301.01,122.29 302.17,121.14 302.17,120.91 302.99,120.08 310.12,120.08 310.75,120.71 310.75,121.14 v2(310.89,121.27)
  BOTTOM w0.114: CN1300.5 314.59,111.65 314.45,111.51 314.05,111.51 313.75,111.82 313.75,116.39 310.75,119.39 310.75,121.14 v2(310.89,121.27) ; U4555.AR10 179.19,93.26 179.09,93.26 v2(178.75,93.61)
USB_P3_DP: length 238.3
  L6 w0.114: v3(178.8,94.27) 178.9,94.17 179.1,94.17 179.27,94.34 179.27,95.65 178.4,96.52 176.64,96.52 175.65,97.51 175.65,97.84 175.42,98.07 174.21,98.07 171.57,100.72 170.78,100.72 161.21,110.29 161.21,114 163.62,116.42 163.62,141.49 165.08,142.96 195.45,142.96 196.24,143.75 199.74,143.75 200.88,142.61 224.89,142.61 225.45,143.17 235.68,143.17 236.33,142.52 263.4,142.52 264.31,141.61 272.02,141.61 275.91,137.72 275.91,137.16 275.91,136.53 277.24,135.2 277.94,134.5 282.42,130.02 282.42,126.12 282.42,125.61 284.02,124.01 284.02,120.98 285.27,119.73 288.87,119.73 291.67,122.53 301.11,122.53 302.41,121.24 302.41,121.01 303.09,120.32 310.02,120.32 310.51,120.81 310.51,121.07 310.3,121.27 v2(310.23,121.27)
  BOTTOM w0.114: v3(178.8,94.27) 178.84,94.27 179.19,93.91 U4555.AT10 ; CN1300.3 314.59,111.15 314.45,111.29 313.96,111.29 313.52,111.72 313.52,116.3 310.52,119.29 310.52,121.07 310.31,121.27 v2(310.23,121.27)
USB_P4_DN: length 162.8
  TOP w0.114: v2(279.94,53.43) 279.94,52.57 D2201.1 280.29,52.38 280.45,52.54 280.45,53.07 280.6,53.22 280.61,53.22 280.9,53.22 281.06,53.38 281.26,53.58 281.26,55.72 281.43,55.89 281.64,55.89 282.03,55.5 282.35,55.5 282.35,55.5 CN2200.2 ; v3(182.19,92.02) 182.37,91.84 183.03,91.84 183.27,91.6 183.27,90.32 183.47,90.12 183.47,84.72 182.46,83.7 181.03,83.7 180.79,83.95 175.73,83.95 175.55,83.77 174.66,83.77 173.4,82.5 173.4,79.3 173.11,79.01 173.11,71.94 172.75,71.58 172.75,70.37 173.36,69.76 173.36,66.55 174,65.92 174,65.22 v2(174.21,65.01)
  L3 w0.102: v2(279.94,53.43) 279.91,53.43 279.74,53.6 279.74,53.62 279.67,53.68 279.67,53.85 279.43,54.09 278.75,54.09 277.98,53.32 268.3,53.32 267.89,52.91 244.06,52.91 244.06,52.91 243.28,52.91 240.37,55.81 232.23,55.81 230.49,54.07 230.09,54.07 227.43,54.07 226.25,52.89 180.25,52.89 173.98,59.16 173.98,64.79 v2(174.21,65.01)
  BOTTOM w0.114: U4555.AM15 181.81,91.64 v3(182.19,92.02)
USB_P4_DP: length 162.6
  TOP w0.114: CN2200.3 282.35,56.5 282,56.5 282,56.5 281.61,56.11 281.33,56.11 281.03,55.81 281.03,53.68 280.9,53.54 280.81,53.45 280.64,53.45 280.44,53.66 280.44,54.07 280.23,54.27 D2201.2 279.8,54.27 279.34,53.82 279.34,53.46 v2(279.33,53.45) ; v2(182.27,91.3) 182.27,91.41 182.38,91.53 182.39,91.53 182.48,91.61 182.93,91.61 183.04,91.5 183.04,90.23 183.25,90.02 183.25,84.81 182.36,83.93 181.12,83.93 180.88,84.17 175.64,84.17 175.46,83.99 174.56,83.99 173.17,82.6 173.17,79.4 172.88,79.11 172.88,72.03 172.52,71.68 172.52,70.27 173.13,69.66 173.13,66.46 173.77,65.82 173.77,65.23 v3(173.55,65.01)
  L3 w0.102: v2(279.33,53.45) 279.46,53.58 279.46,53.76 279.34,53.87 278.84,53.87 278.07,53.1 268.39,53.1 267.98,52.69 244.15,52.69 243.19,52.69 240.28,55.6 232.32,55.6 230.58,53.86 230,53.86 227.52,53.86 226.34,52.68 180.16,52.68 173.77,59.07 173.77,64.81 173.56,65.01 v3(173.55,65.01)
  BOTTOM w0.114: v2(182.27,91.3) 181.82,91.3 181.68,91.16 U4555.AL15
USB_P5_DN: length 117.2
  L3 w0.076: v2(180.63,91.03) 180.63,91.18 180.48,91.32 179.94,91.32 178.98,92.29 178.6,92.29 178.47,92.41 178.45,92.41 178.43,92.42 178.09,92.42 177.8,92.14 177.8,91.05 177.37,90.63 175.54,90.63 175.33,90.84 174.7,90.84 174.7,90.84 174.39,90.84 174.38,90.84 174.25,90.84 174.15,90.74
  L3 w0.102: v3(215.45,61.52) 215.3,61.52 215.12,61.71 215.12,62.04 214.89,62.27 213.57,62.27 213.23,61.92 199.89,61.92 199.22,62.59 199.22,66.74 195.7,70.26 188.2,70.26 183.85,74.61 176.84,74.61 176.19,75.26 175.63,75.26 175.38,75 172.55,75 169.98,77.58 169.73,77.58 168.71,78.6 168.71,79.8 169.16,80.25 169.16,86.71 171.55,89.09 172.5,89.09 174.15,90.74
  L6 w0.114: v4(245.32,68.4) 245.09,68.16 245.09,66.52 242.19,63.62 227.96,63.62 226.56,62.23 215.42,62.23 215.18,61.99 215.18,61.69 215.35,61.52 v3(215.45,61.52)
  BOTTOM w0.114: v2(180.63,91.03) 180.83,91.03 U4555.AM13 ; v4(245.32,68.4) 245.04,68.68 245.04,69.24 245.39,69.59 245.39,69.84
USB_P5_DP: length 117.3
  L3 w0.076: 173.95,90.85 174.11,91 174.32,91 174.32,91.01 174.77,91.01 175.4,91.01 175.61,90.79 177.3,90.79 177.64,91.12 177.64,92.07 177.64,92.21 178.02,92.59 178.5,92.59 178.51,92.57 178.54,92.57 178.67,92.45 179.04,92.45 180.01,91.49 180.57,91.49 v2(180.72,91.64)
  L3 w0.102: 173.95,90.85 172.41,89.3 171.46,89.3 168.95,86.8 168.95,80.34 168.5,79.89 168.5,78.51 169.64,77.37 169.89,77.37 172.46,74.79 175.47,74.79 175.72,75.04 176.1,75.04 176.75,74.39 183.76,74.39 188.11,70.05 195.61,70.05 199,66.65 199,62.51 199.8,61.71 213.32,61.71 213.66,62.05 214.8,62.05 214.9,61.95 214.9,61.69 v2(214.72,61.51)
  L6 w0.114: v2(244.54,68.39) 244.84,68.08 244.84,66.62 242.09,63.87 227.86,63.87 226.46,62.47 215.32,62.47 214.94,62.09 214.94,61.73 v2(214.72,61.51)
  BOTTOM w0.114: v2(244.54,68.39) 244.79,68.64 244.79,69.15 244.39,69.55 244.39,69.84 ; U4555.AN13 180.79,91.64 v2(180.72,91.64)
USB_P5_L_DN: length 5.7
  BOTTOM w0.114: L1400.4 245.39,71.6 244.96,72.02 244.96,72.15 v1(245.42,72.6) 244.99,72.6 244.75,72.84 244.75,73.39 244.88,73.52 246.38,73.52 246.65,73.25 CN1400.9
USB_P5_L_DP: length 5.7
  BOTTOM w0.114: CN1400.7 244.78,73.75 244.52,73.49 244.52,72.97 v1(244.15,72.6) 244.29,72.6 244.74,72.16 244.74,72.02 244.39,71.67 L1400.1
USB_P6_DN: length 102.1
  TOP w0.114: v3(117.89,123.14) 117.89,122.86 117.64,122.61 117.33,122.61 116.91,123.04 L3000.4
  L3 w0.102: v2(180.19,92.53) 180.19,92.48 180.03,92.32 179.82,92.32 179.68,92.46 179.68,94.73 179.4,95.01 178.05,95.01 177.41,94.37 173.82,94.37 172.97,93.52 171.85,93.52 170.96,94.41 164.5,94.41 162.77,92.67 158.92,92.67 158.13,93.46 154.13,93.46 153.63,93.96 151.03,93.96 150.07,93 137.04,93 136.12,92.08 122.13,92.08 120.89,93.33 120.89,93.56 120.2,94.24 119.31,94.24 116.58,96.98 116.58,104.51 115.86,105.23 115.86,116.65 119.12,119.92 119.12,121.85 118.36,122.61 118.13,122.61 117.89,122.86 v3(117.89,123.14)
  BOTTOM w0.114: U4555.AP11 179.76,92.94 180.16,92.53 v2(180.19,92.53)
USB_P6_DP: length 102
  TOP w0.114: v3(117.89,121.87) 117.89,122.15 117.65,122.38 117.23,122.38 116.88,122.04 L3000.1
  L3 w0.102: v2(180.2,91.88) 179.98,92.1 179.73,92.1 179.46,92.37 179.46,94.6 179.27,94.79 178.14,94.79 177.5,94.15 173.91,94.15 173.06,93.31 171.75,93.31 170.86,94.19 164.59,94.19 162.86,92.46 158.83,92.46 158.04,93.25 154.04,93.25 153.54,93.74 151.12,93.74 150.16,92.79 137.13,92.79 136.21,91.87 122.04,91.87 120.67,93.24 120.67,93.47 120.11,94.03 119.22,94.03 116.36,96.89 116.36,104.42 115.64,105.14 115.64,116.74 118.91,120.01 118.91,121.76 118.27,122.4 118.14,122.4 117.89,122.15 v3(117.89,121.87)
  BOTTOM w0.114: U4555.AN11 179.76,92.29 180.16,91.88 v2(180.2,91.88)
USB_P6_L_DN: length 3.2
  TOP w0.114: L3000.3 114.9,123.04 114.5,122.64 114.28,122.64 114,122.92 v3(114,123.18)
  BOTTOM w0.114: CN3000.7 112.97,122.75 113.14,122.75 113.27,122.61 113.87,122.61 114,122.74 v3(114,123.18)
USB_P6_L_DP: length 3.1
  TOP w0.114: L3000.2 114.9,122.04 114.53,122.41 114.26,122.41 114,122.16 v3(114,121.91)
  BOTTOM w0.114: CN3000.8 112.97,122.25 113.14,122.25 113.27,122.38 113.87,122.38 114,122.26 v3(114,121.91)
USB_P7_DN: length 92.6
  TOP w0.114: v3(110.15,97.51) 110.15,97.71 109.95,97.92 109.69,97.92 109.29,97.52 109.29,95.74 104.91,91.36 104.91,90.52 105.05,90.38 CN200.12
  L3 w0.102: v2(122.59,92.59) 122.59,92.59 122.49,92.7 122.49,92.97 122.6,93.09 136.44,93.09 136.84,93.49 143.24,93.49 144.99,95.24 150.6,95.24 150.98,94.85 158,94.85 159.23,93.62 162.35,93.62 165.98,97.25 173.75,97.25 175,96 178.98,96 179.67,95.31 180.55,95.31 180.8,95.05 180.8,93.38 181.17,93.02 181.17,92.63 181.11,92.57 180.9,92.57 180.7,92.77 v2(180.7,92.88)
  L6 w0.114: v2(122.59,92.59) 122.28,92.59 122.01,92.31 119.6,92.31 118.21,93.71 116.16,93.71 112.85,97.03 111.58,97.03 110.73,97.88 110.23,97.88 110.15,97.8 v3(110.15,97.51)
  BOTTOM w0.114: v2(180.7,92.88) 180.92,92.88 181.11,93.08 U4555.AR13
USB_P7_DP: length 92.8
  TOP w0.114: CN200.11 104.55,90.38 104.68,90.51 104.68,91.45 109.06,95.83 109.06,97.61 109.59,98.15 109.93,98.15 v2(110.15,98.37)
  L3 w0.102: v2(180.69,92.23) 180.82,92.35 181.2,92.35 181.38,92.54 181.38,93.11 181.02,93.47 181.02,95.14 180.64,95.52 179.76,95.52 179.07,96.22 175.09,96.22 173.84,97.47 165.89,97.47 162.26,93.84 159.32,93.84 158.09,95.07 151.07,95.07 150.69,95.45 144.9,95.45 143.15,93.7 136.75,93.7 136.35,93.3 122.51,93.3 122.16,92.95 v3(122.04,92.95)
  L6 w0.114: v2(110.15,98.37) 110.4,98.12 110.83,98.12 111.68,97.27 112.95,97.27 116.26,93.95 118.31,93.95 119.7,92.56 121.91,92.56 122.04,92.69 v3(122.04,92.95)
  BOTTOM w0.114: U4555.AP13 181.11,92.61 180.73,92.23 v2(180.69,92.23)
USB_P7_SM_DN: length 13.7
  TOP w0.114: U9000.8 73.76,110.7 73.84,110.78 73.84,111.43 v2(73.71,111.56) ; v2(77.02,105.78) 76.87,105.94 76.87,107.3 77,107.43 CN9000.12
  L3 w0.102: v2(73.71,111.56) 73.81,111.47 73.81,110.34 74.12,110.02 74.12,105.48 74.71,104.89 76.53,104.89 76.91,105.27 76.91,105.67 v2(77.02,105.78)
USB_P7_SM_DP: length 13.6
  TOP w0.114: CN9000.11 76.5,107.38 76.64,107.24 76.64,106.04 v2(76.38,105.78) ; U9000.9 74.41,110.74 74.07,111.08 74.07,111.31 74.34,111.58 v2(74.41,111.58)
  L3 w0.102: v2(76.38,105.78) 76.44,105.78 76.7,105.51 76.7,105.36 76.44,105.1 74.8,105.1 74.33,105.57 74.33,110.11 74.02,110.42 74.02,111.29 74.31,111.58 v2(74.41,111.58)
USB_PORT_EN: length 171.5
  TOP w0.102: v2(159.59,95.11) 159.59,95.03 158.83,94.26 R4917.2
  L3 w0.076: v2(175.16,90.43) 174.02,89.3 174.02,88.5 174.53,88 175.37,88 175.55,87.82 178.39,87.82 178.72,87.49 178.72,86.73 179.33,86.12 182.87,86.12 183.2,85.78 183.2,85.04 184.06,84.19 185.42,84.19 186.25,83.35 186.25,80.94 188.98,78.22 206.03,78.22 v2(207.04,79.23)
  L3 w0.102: v2(276.99,79.06) 276.82,79.06 274.03,81.84 271.35,81.84 269.38,83.81 265.21,83.81 262.92,81.52 258.22,81.52 256.95,80.25 254.03,80.25 v2(253.85,80.43)
  L5 w0.102: v2(276.99,79.06) 276.31,79.74 275.62,79.74 274.48,78.6 274.48,76.59 275.81,75.26 276.36,75.26 277.62,74 278.61,74 279.97,72.65 279.97,69.73 276.85,66.61 275.55,66.61 274.84,65.9 v2(274.83,65.9) ; v2(207.04,79.23) 207.32,78.95 208.32,78.95 208.57,79.2 208.57,79.39 209.71,80.53 211.97,80.53 212.71,79.79 215.12,79.79 215.37,80.05 218.53,80.05 219.95,78.62 221.77,78.62 222.54,79.39 222.54,81.6 226.02,85.08 230.7,85.08 233.11,82.66 233.85,82.66 234.32,83.13 238.96,83.13 240.21,81.87 240.21,81.19 240.72,80.68 253.6,80.68 v2(253.85,80.43)
  L6 w0.102: v2(159.59,95.11) 159.69,95.21 164.95,95.21 165.98,94.18 169.54,94.18 170.09,93.63 170.09,93.48 170.62,92.95 172.39,92.95 174.42,90.92 174.68,90.92 v2(175.16,90.43)
  BOTTOM w0.076: U4555.AL4 175.49,90.89 175.15,90.55 175.15,90.43 v2(175.16,90.43)
  BOTTOM w0.102: U2403.1 274.72,64.64 275.23,65.15 275.23,65.5 v2(274.83,65.9) 275.72,65.9 275.8,65.82 275.82,65.82 275.88,65.75 276.04,65.59 276.23,65.59 277.03,64.8 U2402.1
V_3.9K: length 321.8
  TOP w0.102: R6917.1 57.14,86.14 Q6903.2 57.5,87.19 Q6902.3 59.48,87.76 60.87,89.14 63.87,89.14 R6915.1 64.68,88.97 R6916.1 C6902.1 65.56,88.97 v2(65.56,88.61)
  TOP w0.254: v2(282.48,135.37) 281.34,134.22 v1(281.34,132.45) 281.34,130.16 281.72,129.78 R6049.1
  L6 w0.102: v2(282.48,135.37) 282.48,136.05 274.54,143.98 265.92,143.98 262.99,146.92 255.67,146.92 253.79,148.8 246.93,148.8 245.68,150.05 245.68,158.95 243.07,161.55 233.52,161.55 231.76,159.8 219.28,159.8 217.53,161.55 189.92,161.55 184.31,155.94 174.88,155.94 168.56,162.27 116.29,162.27 114.16,160.13 105.57,151.54 105.57,133.64 109.13,130.09 109.13,126.32 105.26,122.46 105.26,109.04 103.22,107 103.22,102.98 96.61,96.36 95.62,95.38 92.55,95.38 89.53,92.36 89.04,92.36 88.42,91.74 88.42,90.9 87.35,89.82 82.35,89.82 80.4,87.88 66.29,87.88 v2(65.56,88.61)
VADPBL: length 18.1
  TOP w0.254: Q6012.4 289.17,143.33 289.69,143.85 295.84,143.85 v1(296.2,143.5) ; R6028.1 298.53,145.19 298.29,144.95 D6017.1 D6017.2 297.47,143.05 297.02,143.5 v1(296.2,143.5) ; 294.04,139.23 294.04,139.05 293.4,138.42 R6931.1 ; 296.2,142.1 v1(296.2,143.5)
VBIAS: length 330
  TOP w0.102: R6902.2 300.01,134.1 v2(299.88,133.97) 299.2,133.97 R6903.1 ; Q6902.1 59.02,88.95 v2(58.71,88.63)
  L6 w0.102: v2(299.88,133.97) 299.82,133.97 298.9,133.06 286.98,133.06 283.9,136.13 282.69,136.13 274.63,144.19 266.01,144.19 263.07,147.12 255.76,147.12 253.88,149 247.01,149 245.88,150.13 245.88,159.03 243.15,161.76 233.43,161.76 231.68,160.01 219.36,160.01 217.61,161.76 189.84,161.76 184.23,156.15 175.21,156.15 168.89,162.47 116.13,162.47 105.37,151.71 105.37,133.56 108.92,130 108.92,126.58 105.02,122.68 105.02,109.08 103.02,107.08 103.02,103.07 96.4,96.45 95.54,95.58 92.63,95.58 92.46,95.58 89.48,92.6 88.81,92.6 88.04,91.83 88.04,90.87 87.2,90.03 81.21,90.03 79.3,88.12 73.18,88.12 66.71,88.12 65.78,89.05 59.12,89.05 v2(58.71,88.63)
