# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ<53>: length 97.7
  L3 w0.076: v2(185.68,93.1) 185.29,93.5 185.29,93.97 184.96,94.31 184.55,94.31 184.35,94.51 184.11,94.51 184.03,94.58
  L3 w0.102: 184.03,94.58 182.95,95.67 182.95,97.35 181.78,98.51 178.67,98.51 174.77,102.41 172.89,102.41 172.12,103.18 169.31,103.18 166.03,106.45 157.21,106.45 156.22,107.44 153.84,107.44 152.84,108.45 140.5,108.45 126.62,122.33 126.62,126.06 126.52,126.17 126.14,126.17 126.03,126.27 126.03,126.42 126.14,126.52 126.52,126.52 126.62,126.63 126.62,126.77 126.52,126.88 126.13,126.88 126.02,126.98 126.02,127.13 126.13,127.23 126.52,127.23 126.62,127.34 126.62,127.69 126.52,127.8 126.07,127.8 125.97,127.9 125.97,128.05 126.07,128.15 126.52,128.15 126.62,128.26 126.62,128.4 126.52,128.51 126.05,128.51 125.95,128.61 125.95,128.76 126.05,128.86 126.52,128.86 126.62,128.97 126.62,129.12 126.52,129.22 126.1,129.22 126,129.32 126,129.47 126.1,129.58 126.52,129.58 126.62,129.68 126.62,129.83 126.52,129.93 126.13,129.93 126.02,130.04 126.02,130.18 126.13,130.29 126.52,130.29 126.62,130.39 126.62,130.54 126.52,130.64 126.13,130.64 126.02,130.75 126.02,130.89 126.13,131 126.52,131 126.62,131.1 126.62,131.25 126.52,131.35 126.13,131.35 126.02,131.46 126.02,131.6 126.13,131.71 126.52,131.71 126.62,131.81 126.62,131.96 126.52,132.06 126.13,132.06 126.03,132.17 126.03,132.32 126.13,132.42 126.52,132.42 126.62,132.52 126.62,132.87 126,133.49 126,135.66 v3(125.66,136)
  BOTTOM w0.076: U4555.AP21 185.29,92.75 185.64,93.1 v2(185.68,93.1)
  BOTTOM w0.114: v3(125.66,136) 126,135.66 CN4125.193
M_B_DQ<54>: length 100.2
  L3 w0.076: v2(185.71,90.41) 185.3,90.83 184.62,90.83 184.3,91.15 184.3,93.78 183.94,94.13 183.68,94.13 183.63,94.13 182.59,95.17 182.59,96.5 182.19,96.9 181.19,96.9 180.88,97.21
  L3 w0.102: 180.88,97.21 180.88,97.68 180.68,97.88 178.17,97.88 174.33,101.72 172.51,101.72 171.79,102.43 168.74,102.43 165.52,105.65 156.93,105.65 155.85,106.73 155.62,106.73 155.51,106.63 155.51,106.36 155.41,106.25 155.26,106.25 155.16,106.36 155.16,106.63 155.05,106.73 154.91,106.73 154.8,106.63 154.8,106.37 154.7,106.27 154.55,106.27 154.45,106.37 154.45,106.63 154.34,106.73 154.2,106.73 154.09,106.63 154.09,106.34 153.99,106.24 153.84,106.24 153.74,106.34 153.74,106.54 152.54,107.74 140.21,107.74 125.81,122.14 125.81,122.69 124.67,123.84 124.67,139 125.24,139.57 v3(125.69,139.57)
  BOTTOM w0.076: v2(185.71,90.41) 185.55,90.41 185.29,90.15 185.29,90.15 U4555.AK21
  BOTTOM w0.114: v3(125.69,139.57) 126.3,140.18 CN4125.192
M_B_DQ<55>: length 100.6
  L3 w0.076: v2(186.63,90.48) 187.03,90.87 187.03,91.3 188.02,92.29 188.02,94.81 184.77,98.07 184.77,103.3 183.61,104.45 177.3,104.45 176.99,104.76 176.94,104.76
  L3 w0.102: 176.94,104.76 176.54,104.76 175.83,105.46 171.2,110.09 170.91,110.09 170.8,110.2 170.8,110.41 170.7,110.51 170.55,110.51 170.45,110.41 170.45,110.2 170.34,110.09 170.19,110.09 170.09,110.2 170.09,110.42 169.99,110.53 169.84,110.53 169.73,110.42 169.73,110.2 169.63,110.09 169.48,110.09 169.38,110.2 169.38,110.35 169.28,110.45 169.12,110.45 169.02,110.35 169.02,110.2 168.92,110.09 168.77,110.09 168.67,110.2 168.67,110.37 168.57,110.47 168.41,110.47 168.31,110.37 168.31,110.2 168.21,110.09 168.06,110.09 167.96,110.2 167.96,110.37 167.85,110.47 167.7,110.47 167.6,110.37 167.6,110.2 167.5,110.09 167.35,110.09 167.25,110.2 167.25,110.38 167.14,110.49 166.99,110.49 166.89,110.38 166.89,110.2 166.79,110.09 158.4,110.09 157.83,110.67 155.44,110.67 155.01,111.1 141.66,111.1 129.8,122.97 129.8,137.46 129.5,137.76 v3(129.27,137.76)
  BOTTOM w0.076: v2(186.63,90.48) 186.52,90.48 U4555.AK22
  BOTTOM w0.114: v3(129.27,137.76) 129.81,137.22 129.81,135.94 129.6,135.73 CN4125.181
M_B_DQ<56>: length 62.9
  L6 w0.076: 177.14,104.29 177.25,104.19 180.89,104.19 181.8,103.28 181.8,102.47 182.43,101.84 182.43,98.4 183.5,97.33 183.5,95.9 185.11,94.3 185.11,92.81 v2(184.73,92.43)
  L6 w0.102: 177.14,104.29 173.94,107.5 173.94,107.68 174.16,107.9 174.16,108.05 174,108.21 173.86,108.21 173.62,107.97 173.47,107.97 173.36,108.07 173.36,108.23 173.67,108.54 173.67,108.68 173.55,108.8 173.41,108.8 173.1,108.49 172.95,108.49 171.32,110.12 171.32,110.37 171.21,110.47 170.98,110.47 170.87,110.57 170.87,110.58 170.86,110.6 170.86,110.78 170.96,110.88 171.39,110.88 171.49,110.98 171.49,111.16 171.39,111.27 170.96,111.27 170.86,111.37 170.86,111.6 169.71,112.75 169.71,131.29 169.01,131.98 169.01,132.91 168.4,133.52 168.4,137.79 168.24,137.95 v3(167.94,137.95)
  BOTTOM w0.076: U4555.AN20 184.34,92.1 184.66,92.43 v2(184.73,92.43)
  BOTTOM w0.114: v3(167.94,137.95) 169.2,136.69 CN4125.57
M_B_DQ<57>: length 61.7
  L6 w0.076: 176.82,104.11 176.91,104.02 180.82,104.02 181.63,103.21 181.63,102.4 182.27,101.77 182.27,98.33 183.34,97.26 183.34,95.61 184.73,94.22 v2(184.73,93.71)
  L6 w0.102: v3(167.9,136.58) 167.9,132.6 169.35,131.15 169.35,112.6 170.51,111.45 170.51,110.43 170.88,110.05 170.88,109.89 170.53,109.54 170.53,109.39 170.64,109.28 170.79,109.28 171.14,109.63 171.3,109.63 171.41,109.53 171.41,109.37 171.05,109.02 171.05,108.87 171.16,108.76 171.32,108.76 171.67,109.11 171.82,109.11 171.93,109.01 171.93,108.85 171.58,108.5 171.58,108.35 171.68,108.24 171.84,108.24 172.15,108.56 172.29,108.56 172.41,108.44 172.41,108.29 172.1,107.98 172.1,107.83 172.2,107.72 172.36,107.72 172.65,108.02 172.8,108.02 172.91,107.9 172.91,107.76 172.64,107.48 172.64,107.33 172.75,107.22 172.9,107.22 173.19,107.51 173.33,107.51 173.45,107.39 173.45,107.25 173.18,106.98 173.18,106.84 173.3,106.72 173.44,106.72 173.75,107.03 173.9,107.03 176.82,104.11
  BOTTOM w0.076: U4555.AR20 184.65,93.71 v2(184.73,93.71)
  BOTTOM w0.114: CN4125.59 168.6,135.88 v3(167.9,136.58)
M_B_DQ<58>: length 63.8
  L6 w0.076: v2(183.85,90.52) 183.72,90.52 182.95,91.28 182.95,94.02 182.46,94.51 181.94,94.51 181.35,94.51 178.85,97.01 178.85,97.57 178.31,98.11 177.14,98.11 176.93,98.31
  L6 w0.102: v3(165.76,137.97) 165.65,137.97 165.28,137.59 165.28,130.34 166.27,129.35 166.27,122.37 167,121.63 167,121.39 166.9,121.28 166.59,121.28 166.48,121.17 166.48,121.02 166.59,120.91 166.9,120.91 167,120.8 167,120.65 166.9,120.54 166.59,120.54 166.48,120.43 166.48,120.28 166.59,120.17 166.9,120.17 167,120.06 167,119.91 166.9,119.8 166.55,119.8 166.45,119.7 166.45,119.54 166.55,119.44 166.9,119.44 167,119.33 167,108.83 168.33,107.5 170.92,104.91 170.92,104.32 171.42,103.82 174.86,100.39 174.86,100.38 176.93,98.31
  BOTTOM w0.076: v2(183.85,90.52) 183.75,90.52 U4555.AK18
  BOTTOM w0.114: v3(165.76,137.97) 165.78,137.97 166.2,137.55 CN4125.67
M_B_DQ<59>: length 63.7
  L6 w0.076: v2(183.84,91.09) 183.63,91.09 183.12,91.6 183.12,94.48 182.37,95.24 182.37,96.16 181.94,96.58 181.06,96.58 180.83,96.81 179.46,96.81 179.05,97.22 179.05,97.6 178.34,98.31 177.44,98.31 177.28,98.47
  L6 w0.102: v3(165.76,136.64) 165.76,130.37 166.66,129.47 166.66,128.2 167.36,127.49 167.36,127.08 167.25,126.98 166.81,126.98 166.71,126.87 166.71,126.72 166.81,126.61 167.25,126.61 167.36,126.5 167.36,126.35 167.25,126.24 166.81,126.24 166.71,126.13 166.71,125.98 166.81,125.87 167.25,125.87 167.36,125.76 167.36,125.61 167.25,125.5 166.81,125.5 166.71,125.39 166.71,125.24 166.81,125.13 167.25,125.13 167.36,125.03 167.36,124.87 167.25,124.77 166.88,124.77 166.78,124.66 166.78,124.5 166.88,124.4 167.25,124.4 167.36,124.29 167.36,124.14 167.25,124.03 166.87,124.03 166.77,123.93 166.77,123.76 166.87,123.66 167.25,123.66 167.36,123.55 167.36,123.36 167.25,123.25 167.02,123.25 166.91,123.15 166.91,122.99 167.02,122.88 167.25,122.88 167.36,122.78 167.36,108.98 171.28,105.06 171.28,104.47 171.71,104.03 172.96,102.79 177.28,98.47
  BOTTOM w0.076: v2(183.84,91.09) 183.67,91.09 U4555.AL18
  BOTTOM w0.114: v3(165.76,136.64) 165.75,136.64 165.6,136.49 CN4125.69
M_B_DQ<60>: length 64.4
  L6 w0.076: v2(184.82,90.45) 185.16,90.79 185.16,91.8 185.45,92.08 185.93,92.08 186.1,92.26 186.1,97.05 185.3,97.85 183.45,97.85 182.76,98.54 182.76,101.97 182.13,102.61 182.13,103.49 180.98,104.63 177.83,104.63 176.64,105.83 176.64,105.88
  L6 w0.102: 176.64,105.88 176.64,106.82 173.79,109.67 173.78,109.67 173.26,110.19 173.26,110.33 173.38,110.45 173.38,110.59 173.26,110.71 173.12,110.71 173.01,110.6 172.92,110.6 172.23,111.3 172.23,111.81 170.46,113.57 170.46,113.58 170.46,114.1 170.46,132.71 169.25,133.92 v3(169.25,139.38)
  BOTTOM w0.076: v2(184.82,90.45) 184.63,90.45 U4555.AK20
  BOTTOM w0.114: CN4125.56 169.5,141.33 169.76,141.08 169.76,139.89 v3(169.25,139.38)
M_B_DQ<61>: length 63.6
  L6 w0.076: v2(184.73,91.78) 185.11,92.16 185.11,92.58 185.27,92.74 185.27,94.47 184.77,94.98 184.77,97.19 184.27,97.69 183.38,97.69 182.6,98.47 182.6,101.9 181.96,102.54 181.96,103.35 180.95,104.35 177.58,104.35 177.49,104.45
  L6 w0.102: 177.49,104.45 174.58,107.35 174.58,108.36 172.92,110.03 172.76,110.03 172.44,109.7 172.29,109.7 172.18,109.82 172.18,109.96 172.5,110.29 172.5,110.44 172.4,110.55 172.24,110.55 171.93,110.24 171.79,110.24 171.67,110.36 171.67,110.5 171.98,110.81 171.98,110.97 171.87,111.08 171.87,111.31 170.11,113.07 170.11,131.4 169.37,132.13 169.37,133.05 168.75,133.67 168.75,140.29 v3(169.32,140.86)
  BOTTOM w0.076: U4555.AM20 184.66,91.78 v2(184.73,91.78)
  BOTTOM w0.114: v3(169.32,140.86) 168.9,141.28 CN4125.58
M_B_DQ<62>: length 60
  L6 w0.076: 177.91,98.84 178.01,98.74 178.38,98.74 179.28,97.84 180.51,97.84 180.83,97.52 180.83,97.27 181.19,96.91 182.15,96.91 182.7,96.37 182.7,95.37 183.78,94.29 v2(183.78,93.7)
  L6 w0.102: 177.91,98.84 176.16,100.6 176.16,100.6 171.99,104.77 171.99,105.35 168.07,109.27 168.07,130.61 167.89,130.79 167.74,130.79 167.59,130.64 167.44,130.64 167.33,130.76 167.33,130.9 167.48,131.05 167.48,131.21 167.37,131.32 167.21,131.32 167.05,131.15 166.89,131.15 166.78,131.25 166.78,131.41 166.95,131.58 166.95,131.73 166.61,132.07 166.61,140.96 166.35,141.22 v3(165.9,141.22)
  BOTTOM w0.076: v2(183.78,93.7) 183.68,93.7 U4555.AR18
  BOTTOM w0.114: CN4125.68 v3(165.9,141.22)
M_B_DQ<63>: length 61.5
  L6 w0.076: v2(183.78,93.08) 183.32,93.53 183.32,94.51 182.53,95.3 182.53,96.23 182.01,96.75 181.12,96.75 180.66,97.21 180.66,97.45 180.44,97.67 179.21,97.67 178.4,98.49 177.76,98.49 177.53,98.72
  L6 w0.102: 177.53,98.72 175.89,100.36 175.89,100.36 171.63,104.62 171.63,105.21 167.71,109.12 167.71,128.5 167.61,128.61 167.27,128.61 167.16,128.72 167.16,128.87 167.27,128.98 167.61,128.98 167.71,129.09 167.71,129.64 167.45,129.9 167.29,129.9 167.17,129.78 167.03,129.78 166.91,129.9 166.91,130.04 167.03,130.16 167.03,130.32 166.93,130.42 166.77,130.42 166.64,130.29 166.5,130.29 166.38,130.41 166.38,130.55 166.51,130.68 166.51,130.84 166.25,131.1 166.25,139.7 166.15,139.8 v3(165.82,139.8)
  BOTTOM w0.076: v2(183.78,93.08) 183.71,93.08 U4555.AP18
  BOTTOM w0.114: v3(165.82,139.8) 165.3,140.32 CN4125.70
M_B_DQS0_DN: length 88.6
  L3 w0.076: v2(192.16,98.37) 192.15,98.37 191.95,98.56 191.43,98.56 191.06,98.94 191.06,104.58 191.05,104.59 191.05,104.82 190.82,105.05 190.71,105.05 189.83,105.93 189.81,105.93
  L3 w0.102: v3(142.89,138.24) 142.89,138 142.74,137.84 142.45,137.84 142.17,137.56 142.17,133.43 142.63,132.96 142.63,124.15 145.78,121 176.58,121 189.19,108.39 189.19,106.54 189.21,106.51 189.21,106.34 189.62,105.93 189.81,105.93
  BOTTOM w0.076: U4555.AW30 191.85,95.76 191.85,95.97 191.88,96.02 191.92,96.11 191.93,96.13 191.93,96.26 191.9,96.31 191.88,96.37 191.88,96.37 191.85,96.41 191.85,97.09 192.16,97.39 192.29,97.39 192.5,97.39 192.65,97.55 192.65,98.47 192.55,98.58 192.35,98.58 192.16,98.38 v2(192.16,98.37)
  BOTTOM w0.114: v3(142.89,138.24) 142.89,138.17 143.18,137.88 143.47,137.88 143.81,137.54 143.81,136.54 143.21,135.94 143.21,135.45 143.4,135.26 CN4125.135
M_B_DQS0_DP: length 88.7
  L3 w0.076: v3(192.16,99.03) 192.16,98.97 191.92,98.73 191.5,98.73 191.23,99 191.23,104.65 191.22,104.66 191.22,104.89 190.89,105.21 190.78,105.21 189.99,106 189.88,106.11 189.83,106.11 189.82,106.12 189.81,106.12
  L3 w0.102: v2(142.95,137.33) 142.95,137.48 142.8,137.63 142.54,137.63 142.39,137.48 142.39,133.52 142.85,133.05 142.85,124.24 145.87,121.22 176.67,121.22 189.4,108.48 189.4,106.42 189.7,106.12 189.81,106.12
  BOTTOM w0.076: U4555.AV30 191.64,94.89 191.64,95.12 192.02,95.51 192.02,95.93 192.09,96.09 192.09,96.29 192.07,96.35 192.07,96.35 192.02,96.45 192.02,97.02 192.1,97.1 192.23,97.22 192.56,97.22 192.82,97.48 192.82,98.54 192.61,98.74 192.45,98.74 v3(192.16,99.03)
  BOTTOM w0.114: CN4125.137 142.8,135.27 142.98,135.45 142.98,136.04 143.58,136.64 143.58,137.44 143.37,137.66 143.08,137.66 142.95,137.52 v2(142.95,137.33)
M_B_DQS1_DN: length 54.9
  L6 w0.076: 188.57,106.23 188.57,106.08 189.89,104.77 189.89,101.32 189.71,101.15 189.71,100.64 189.56,100.49 189.4,100.49 189.34,100.55 189.22,100.67 v2(189.22,100.71)
  L6 w0.102: 188.57,106.23 188.57,110.31 182.03,116.85 182.03,131.23 183.08,132.27 183.08,139.71 182.79,140 182.37,140 v3(182.14,139.77)
  BOTTOM w0.076: v2(189.22,100.71) 189.4,100.53 189.61,100.53 189.83,100.31 189.83,97.49 189.83,97.35 189.59,97.1 189.59,97.1 189.59,96.45 189.66,96.29 189.66,96.09 189.59,95.93 189.59,95.49 189.21,95.1 189.21,94.89 U4555.AV26
  BOTTOM w0.114: CN4125.10 183.22,142.65 183.22,140.22 182.98,139.98 182.35,139.98 v3(182.14,139.77)
M_B_DQS1_DP: length 55
  L6 w0.076: v3(189.22,100.05) 189.22,100.27 189.28,100.33 189.63,100.33 189.88,100.57 189.88,101.08 190.05,101.26 190.05,104.84 188.79,106.1 188.79,106.32
  L6 w0.102: v2(182.08,140.56) 182.08,140.52 182.38,140.22 182.88,140.22 183.29,139.8 183.29,132.18 182.25,131.14 182.25,116.94 188.79,110.4 188.79,106.32
  BOTTOM w0.076: U4555.AW26 189.42,95.76 189.42,95.97 189.47,96.06 189.5,96.12 189.5,96.26 189.45,96.36 189.42,96.41 189.42,96.99 189.42,96.99 189.42,97.17 189.67,97.42 189.67,100.24 189.54,100.37 189.41,100.37 189.22,100.18 v3(189.22,100.05)
  BOTTOM w0.114: CN4125.12 182.7,141.51 182.8,141.41 182.89,141.41 183,141.3 183,140.32 182.89,140.21 182.21,140.21 182.08,140.34 v2(182.08,140.56)
M_B_DQS2_DN: length 95
  L3 w0.076: 184.21,107.78 184.65,107.34 185.26,107.34 186.14,106.46 186.14,106.46 188.27,104.33 188.3,104.3 188.3,101.55 188.45,101.4 188.45,97.81 188.51,97.75 188.51,96.16 190.14,94.54 190.49,94.54 190.74,94.29 190.74,92.61 190.65,92.52 190.41,92.52 v2(190.39,92.54)
  L3 w0.102: v3(138.36,140.21) 138.36,140.02 138.1,139.77 137.39,139.77 137.11,139.49 137.11,131.86 137.33,131.64 137.33,123.85 144.13,117.05 174.94,117.05 184.21,107.78
  BOTTOM w0.114: U4555.AN28 189.95,92.1 190.18,92.1 190.39,92.32 v2(190.39,92.54) ; v3(138.36,140.21) 138.36,139.78 138.21,139.63 137.91,139.63 137.69,139.85 137.61,139.93 137.61,140.35 138.1,140.85 138.1,141.53 138.3,141.73 CN4125.152
M_B_DQS2_DP: length 95
  L3 w0.076: v3(190.47,91.83) 190.47,92.08 190.91,92.51 190.91,94.35 190.56,94.7 190.2,94.7 188.68,96.23 188.68,97.82 188.62,97.88 188.62,101.47 188.6,101.49 188.46,101.62 188.46,103.29 188.46,103.29 188.46,103.43 188.46,104.37 188.34,104.49 188.34,104.49 186.3,106.53 186.3,106.53 185.33,107.5 184.79,107.5 184.4,107.9
  L3 w0.102: v2(138.44,139.24) 138.13,139.55 137.48,139.55 137.33,139.4 137.33,131.95 137.55,131.73 137.55,123.94 144.22,117.27 175.03,117.27 184.4,107.9
  BOTTOM w0.114: CN4125.154 137.7,141.77 137.87,141.59 137.87,140.94 137.38,140.44 137.38,139.84 137.52,139.69 137.6,139.62 137.82,139.4 138.28,139.4 v2(138.44,139.24) ; U4555.AM28 189.94,91.45 190.32,91.83 v3(190.47,91.83)
M_B_DQS3_DN: length 58.1
  L6 w0.076: v2(188.43,92.45) 188.43,92.27 188.52,92.18 188.71,92.18 188.82,92.3 188.82,93.96 187.31,95.48 187.31,97.81 187.64,98.14 187.64,103.94 185.36,106.22 185.11,106.22 184.63,106.7 184.63,106.79
  L6 w0.102: 184.63,106.79 184.63,108.69 176.99,116.33 176.99,123.47 177.49,123.96 177.49,133.6 176.95,134.13 176.95,137.59 177.28,137.92 177.64,137.92 v3(177.83,138.11)
  BOTTOM w0.114: v2(188.43,92.45) 188.43,92.45 188.39,92.45 188.04,92.1 U4555.AN25 ; CN4125.27 178.2,135.37 178.11,135.45 178.11,135.97 178.77,136.62 178.77,137.58 178.43,137.92 178.02,137.92 v3(177.83,138.11)
M_B_DQS3_DP: length 58.1
  L6 w0.076: 184.85,106.79 184.85,106.72 185.18,106.38 185.43,106.38 187.8,104.01 187.8,98.07 187.47,97.74 187.47,95.55 188.99,94.03 188.99,92.23 188.78,92.02 188.6,92.02 188.43,91.85 v3(188.43,91.78)
  L6 w0.102: 184.85,106.79 184.85,108.78 177.21,116.42 177.21,123.38 177.7,123.87 177.7,133.69 177.17,134.22 177.17,137.5 177.37,137.7 177.58,137.7 177.83,137.45 v2(177.83,137.23)
  BOTTOM w0.114: U4555.AM25 188.04,91.45 188.37,91.78 v3(188.43,91.78) ; v2(177.83,137.23) 177.83,137.49 178.03,137.69 178.34,137.69 178.54,137.49 178.54,136.72 177.88,136.06 177.88,135.6 177.6,135.32 CN4125.29
M_B_DQS4_DN: length 92.8
  L3 w0.076: 180.57,106.07 181.08,105.56 184.48,105.56 184.57,105.47 186.09,103.94 186.09,103.21 186.26,103.04 186.26,102.67 186.42,102.51 186.42,100.46 186.58,100.3 187.04,100.3 187.24,100.1 v2(187.24,99.98)
  L3 w0.102: v3(132.97,137.9) 132.97,137.83 132.74,137.6 132.49,137.6 132.28,137.4 132.28,135.79 132.02,135.53 132.02,134.99 132.24,134.77 132.63,134.77 132.75,134.66 132.75,134.36 132.64,134.26 132.31,134.26 132.02,133.97 132.02,132.1 132.52,131.61 132.52,123.19 142.53,113.18 155.87,113.18 156.26,112.79 172.68,112.79 178.64,106.83 179.81,106.83 180.57,106.07
  BOTTOM w0.076: v2(187.24,99.98) 187.24,100.15 187.38,100.29 187.53,100.29 187.63,100.2 187.63,99.16 187.34,98.88 187.34,98.62 186.96,98.24 186.96,98.24 186.75,98.03 186.75,97.14 186.72,97.12 186.72,96.41 186.75,96.36 186.79,96.26 186.79,96.13 186.76,96.04 186.72,95.97 186.72,95.76 U4555.AW22
  BOTTOM w0.114: v3(132.97,137.9) 133.17,137.7 133.42,137.7 133.7,137.42 133.7,135.98 133.2,135.48 CN4125.169
M_B_DQS4_DP: length 92.8
  L3 w0.076: v3(187.24,100.67) 187.14,100.57 187.13,100.57 187.04,100.47 186.65,100.47 186.59,100.53 186.59,102.58 186.42,102.74 186.42,103.11 186.26,103.28 186.26,104.01 185.37,104.9 184.64,105.63 184.63,105.63 184.54,105.73 181.18,105.73 180.7,106.21
  L3 w0.102: v2(132.98,137.19) 132.78,137.38 132.57,137.38 132.5,137.31 132.5,135.7 132.24,135.44 132.24,135.08 132.33,134.99 132.72,134.99 132.96,134.75 132.96,134.27 132.73,134.04 132.4,134.04 132.24,133.88 132.24,132.19 132.74,131.69 132.74,123.28 142.62,113.4 155.96,113.4 156.35,113.01 172.77,113.01 178.28,107.5 178.73,107.05 179.86,107.05 180.7,106.21
  BOTTOM w0.076: v3(187.24,100.67) 187.46,100.45 187.6,100.45 187.79,100.27 187.79,99.09 187.51,98.81 187.51,98.55 187.03,98.07 187.03,98.07 186.91,97.96 186.91,97.07 186.89,97.05 186.89,96.45 186.9,96.43 186.94,96.35 186.96,96.29 186.96,96.09 186.89,95.93 186.89,95.48 186.5,95.09 U4555.AV22
  BOTTOM w0.114: CN4125.171 132.6,135.43 132.78,135.62 133.02,135.62 133.47,136.07 133.47,137.32 133.33,137.47 133.12,137.47 132.98,137.32 v2(132.98,137.19)
M_B_DQS5_DN: length 55.6
  L6 w0.076: 179.72,107.81 179.73,107.81 180.51,107.03 180.51,106.79 183.96,103.34 183.96,103.18 183.86,103.09 183.57,103.09 v2(183.55,103.11)
  L6 w0.102: v3(172.66,138.41) 172.52,138.27 171.96,138.27 171.66,137.97 171.66,134.49 172.26,133.89 172.57,133.58 172.57,115.61 172.57,115.61 172.57,114.97 172.57,114.97 179.72,107.81
  BOTTOM w0.076: v2(183.55,103.11) 183.57,103.08 184.19,103.08 184.64,102.63 184.64,102.25 184.64,99.76 184.58,99.7 184.58,99.15 184.61,99.12 184.61,97.37 184.6,97.36 184.6,97.01 184.6,97.01 184.46,96.86 184.46,96.45 184.53,96.29 184.53,96.09 184.46,95.93 184.46,95.48 184.07,95.1 U4555.AV18
  BOTTOM w0.114: CN4125.45 172.8,135.55 173.35,136.1 173.35,137.86 173.01,138.2 172.87,138.2 v3(172.66,138.41)
M_B_DQS5_DP: length 55.6
  L6 w0.076: 179.89,107.94 179.89,107.88 180.68,107.1 180.68,106.86 184.12,103.41 184.12,103.12 183.8,102.79 v3(183.8,102.5)
  L6 w0.102: v2(172.61,137.5) 172.61,137.84 172.4,138.05 172.05,138.05 171.88,137.88 171.88,134.58 172.35,134.1 172.79,133.67 172.79,115.52 172.78,115.52 172.78,115.06 172.79,115.06 179.89,107.95 179.89,107.94
  BOTTOM w0.076: v3(183.8,102.5) 183.8,102.82 183.9,102.92 184.12,102.92 184.47,102.56 184.47,102.32 184.47,99.83 184.41,99.77 184.41,99.08 184.44,99.05 184.44,98.58 184.3,98.43 184.3,98.21 184.44,98.06 184.44,97.91 184.3,97.77 184.3,97.58 184.44,97.44 184.44,97.43 184.44,97.27 184.44,97.27 184.44,97.08 184.29,96.93 184.29,96.41 184.31,96.37 184.36,96.26 184.36,96.13 184.35,96.11 184.31,96.02 184.29,95.97 184.29,95.76 U4555.AW18
  BOTTOM w0.114: CN4125.47 172.2,135.28 173.12,136.2 173.12,137.77 172.92,137.97 172.59,137.97 172.48,137.86 172.48,137.63 v2(172.61,137.5)
M_B_DQS6_DN: length 98.4
  L3 w0.076: 185.61,94.34 186.07,93.88 186.07,92.55 186.02,92.5 v2(185.71,92.5)
  L3 w0.102: v3(127.91,139.58) 127.91,139.28 127.73,139.11 127.31,139.11 126.86,138.65 126.86,135.87 127.48,135.25 127.48,122.69 140.86,109.31 153.19,109.31 154.2,108.3 156.58,108.3 157.57,107.32 168.6,107.32 169.54,106.37 170.04,106.37 173.09,103.32 175.05,103.32 175.24,103.5 180.93,103.5 182.89,101.55 182.89,98.12 183.43,97.58 183.43,96.4 184.64,95.19 184.64,95.15 185,94.79 185.16,94.79 185.61,94.34
  BOTTOM w0.114: v2(185.71,92.5) 185.71,92.23 185.59,92.1 U4555.AN21 ; CN4125.186 128.1,141.75 127.88,141.53 127.18,140.83 127.18,139.44 127.41,139.2 127.6,139.2 127.91,139.51 v3(127.91,139.58)
M_B_DQS6_DP: length 98.4
  L3 w0.076: 185.8,94.45 186.23,94.02 186.23,92.48 185.75,92 v3(185.75,91.68)
  L3 w0.102: v2(127.88,138.64) 127.64,138.89 127.4,138.89 127.08,138.56 127.08,135.96 127.7,135.34 127.7,122.78 140.95,109.53 153.28,109.53 154.29,108.52 156.67,108.52 157.66,107.53 168.69,107.53 169.63,106.59 170.13,106.59 173.18,103.54 174.96,103.54 175.15,103.72 181.02,103.72 183.11,101.64 183.11,98.21 183.65,97.67 183.65,96.49 184.86,95.28 184.86,95.23 185.09,95 185.25,95 185.8,94.45
  BOTTOM w0.114: v2(127.88,138.64) 127.88,138.68 127.59,138.97 127.32,138.97 126.95,139.34 126.95,140.92 127.5,141.47 CN4125.188 ; U4555.AM21 185.52,91.68 v3(185.75,91.68)
M_B_DQS7_DN: length 62.2
  L6 w0.076: 181.53,98.16 181.77,97.92 182.12,97.92 182.92,97.12 182.92,95.47 184.18,94.21 184.18,92.3 184.08,92.2 183.88,92.2 183.78,92.3 v2(183.78,92.43)
  L6 w0.102: v3(168.02,140.25) 168.02,140.01 167.89,139.88 167.43,139.88 167.14,139.59 167.14,132.28 168.59,130.83 168.59,112.07 169.74,110.91 169.74,109.07 172.9,105.91 172.9,105.45 176.78,101.56 176.78,100.77 179.14,98.41 181.28,98.41 181.53,98.16
  BOTTOM w0.114: CN4125.62 167.7,141.75 167.52,141.56 167.52,140.76 167.35,140.6 167.35,140.01 167.53,139.83 167.84,139.83 168.02,140.01 v3(168.02,140.25) ; v2(183.78,92.43) 183.71,92.43 U4555.AN18
M_B_DQS7_DP: length 62.1
  L6 w0.076: v3(183.89,91.75) 183.89,91.92 184.01,92.04 184.15,92.04 184.35,92.24 184.35,94.28 183.09,95.54 183.09,97.18 182.18,98.09 181.91,98.09 181.68,98.32
  L6 w0.102: v2(168,139.32) 168,139.47 167.8,139.67 167.52,139.67 167.35,139.5 167.35,132.37 168.81,130.92 168.81,112.16 169.96,111 169.96,109.16 173.11,106 173.11,105.54 177,101.65 177,100.86 179.23,98.62 181.37,98.62 181.68,98.32
  BOTTOM w0.114: U4555.AM18 183.68,91.75 v3(183.89,91.75) ; v2(168,139.32) 167.72,139.6 167.44,139.6 167.12,139.92 167.12,140.69 167.29,140.86 167.29,141.54 167.1,141.73 CN4125.64
M_B_RAS#: length 98.8
  L3 w0.076: v2(194.66,91.78) 194.26,92.17 194.26,94.18 194.4,94.32 194.4,101.32 194.4,101.32 194.4,101.87 194.52,101.99
  L3 w0.165: 194.52,101.99 194.81,102.27 194.81,110.48 179.05,126.24 152.7,126.24 149.63,129.31 149.63,130.32 148.95,131.01 148.95,137.46 149.18,137.7 149.18,139.82 149.06,139.94 149.06,140.76 149.62,141.31 149.62,142.51 149.46,142.67 149.05,142.67 148.9,142.82 148.9,143.06 149.05,143.22 149.46,143.22 149.62,143.38 149.62,143.75 149.77,143.9 150.09,143.9 150.24,143.75 150.24,142.53 150.39,142.37 150.65,142.37 150.8,142.53 150.8,143.75 150.95,143.9 151.34,143.9 151.49,143.75 151.49,142.26 v3(150.22,140.99)
  BOTTOM w0.076: v2(194.66,91.78) 194.59,91.78 194.26,91.45 U4555.AM35
  BOTTOM w0.178: v3(150.22,140.99) 150.33,140.99 150.9,141.56 CN4125.110
M_B_WE#: length 98.4
  L3 w0.076: v3(194.68,90.48) 194.1,91.06 194.1,93.98 193.5,94.57 193.5,101.68 193.64,101.81
  L3 w0.165: v2(147.84,138.51) 147.95,138.63 147.95,139.78 147.75,139.98 147.75,142.58 147.9,142.73 148.23,142.73 148.38,142.58 148.38,140.87 148.53,140.72 148.53,139.72 148.65,139.6 148.65,137.92 148.41,137.68 148.41,133.29 147.98,132.86 147.98,130.2 152.48,125.7 178.82,125.7 194.13,110.4 194.13,102.3 193.64,101.81
  BOTTOM w0.076: v3(194.68,90.48) 194.59,90.48 194.26,90.15 U4555.AK35
  BOTTOM w0.178: CN4125.113 150,135.9 149.97,135.93 149.07,136.83 149.07,137.23 147.84,138.46 v2(147.84,138.51)
M_CKE0: length 74.6
  L6 w0.076: v2(200.26,94.86) 199.51,95.61 199.51,99.68 201.46,101.63 201.79,101.63 202.49,102.33 202.49,102.56 202.72,102.79
  L6 w0.165: 202.72,102.79 205.88,105.95 205.99,105.95 206.38,106.35 206.38,106.39 206.35,106.42 206.35,108.27 212.69,114.61 215.01,114.61 219.46,119.05 230.61,119.05 240.73,129.17 240.73,136.86 239.44,138.14 v3(239.32,138.14)
  BOTTOM w0.076: v2(200.26,94.86) 200.11,94.86 199.81,94.57 U4555.AU43
  BOTTOM w0.178: CN4100.73 239,135.56 239.98,136.53 239.98,137.49 v3(239.32,138.14)
M_CKE1: length 73.5
  L6 w0.165: v3(239.34,139.46) 241.24,137.57 241.24,128.96 230.82,118.55 219.67,118.55 215.22,114.1 212.9,114.1 206.86,108.06 206.86,106.4 206.84,106.38 206.84,106.32 201.91,101.38 201.53,101.38 200.09,99.93 200.09,99.61 200.41,99.29 200.41,97.15 200.26,97 v2(200.26,96.17)
  BOTTOM w0.178: v3(239.34,139.46) 238.7,140.11 CN4100.74 ; v2(200.26,96.17) 200.16,96.17 199.86,95.87 U4555.AW43
M_CKE2: length 86.3
  L3 w0.076: v2(202.88,97.38) 202.44,97.82 202.44,101.7 202.96,102.22 202.96,103.01 205.7,105.75 205.7,105.89
  L3 w0.165: v3(162.17,138.75) 162.17,139.25 165.77,142.85 185.51,142.85 189.19,139.17 189.19,137 189.19,135.56 196.33,128.42 196.33,124.36 205.7,114.99 205.7,105.89
  BOTTOM w0.076: U4555.AY49 203.01,96.52 203.01,97.25 v2(202.88,97.38)
  BOTTOM w0.178: CN4125.73 162,136.05 162.28,136.33 162.28,138.63 v3(162.17,138.75)
M_CKE3: length 86.3
  L3 w0.076: v2(202.83,99.13) 202.83,101.86 203.12,102.15 203.12,102.9 206.24,106.01 206.24,106.14
  L3 w0.165: v3(162.47,140.95) 163.12,140.95 165.64,143.47 166.16,143.47 166.17,143.47 166.7,143.47 186.39,143.47 189.73,140.13 189.73,136.78 189.73,136.78 189.73,135.78 196.87,128.64 196.87,124.58 206.24,115.21 206.24,106.14
  BOTTOM w0.076: U4555.AU50 203.93,94.57 204.15,94.78 204.15,96.83 203.8,97.19 203.8,98.31 202.98,99.13 v2(202.83,99.13)
  BOTTOM w0.178: v3(162.47,140.95) 161.7,141.72 CN4125.74
M_CLK_DDR0_DN: length 75.7
  L6 w0.076: 197.33,103.49 197.33,103.24 195.14,101.04 195.14,100.34 195.19,100.29 v2(195.37,100.29)
  L6 w0.102: 197.33,103.49 197.33,111.82 213.36,127.84 226.29,127.84 229.96,131.52 229.96,134.16 230.41,134.6 230.41,138.85 230.63,139.07 231.38,139.07 231.6,138.85 231.6,137.57 231.34,137.31 231.16,137.31 230.99,137.49 v3(230.99,137.58)
  BOTTOM w0.076: v2(195.37,100.29) 195.37,100.07 195.48,99.97 196.05,99.97 196.42,99.6 196.42,95.44 196.25,95.27 196.25,95.09 196.01,94.85 196.01,94.57 U4555.AU37
  BOTTOM w0.114: CN4100.103 230,135.24 230.21,135.45 230.21,136.03 229.8,136.44 229.8,136.92 230.08,137.19 230.83,137.19 230.83,137.2 230.85,137.2 230.99,137.34 v3(230.99,137.58)
M_CLK_DDR0_DP: length 75.7
  L6 w0.076: v3(195.37,99.6) 195.37,99.75 194.97,100.15 194.97,101.11 197.12,103.25 197.12,103.36
  L6 w0.102: 197.12,103.36 197.12,111.91 213.27,128.06 226.2,128.06 229.75,131.61 229.75,134.25 230.19,134.69 230.19,138.94 230.54,139.28 231.47,139.28 231.81,138.94 231.81,137.48 231.43,137.09 231.2,137.09 230.97,136.86 v2(230.97,136.73)
  BOTTOM w0.076: U4555.AV37 196.25,95.51 196.25,99.53 195.98,99.8 195.58,99.8 195.42,99.64 v3(195.37,99.6)
  BOTTOM w0.114: CN4100.101 230.6,135.32 230.44,135.47 230.44,136.12 230.03,136.54 230.03,136.82 230.17,136.97 230.73,136.97 v2(230.97,136.73)
M_CLK_DDR1_DN: length 74.9
  L6 w0.076: v2(195.53,96.19) 195.53,96.33 195.38,96.48 194.87,96.48 194.58,96.76 194.58,101.39 196.35,103.16 196.35,103.36 196.35,103.36
  L6 w0.102: 196.35,103.36 196.35,112.22 212.95,128.82 225.88,128.82 227.75,130.69 227.75,130.85 227.64,130.95 227.34,131.25 227.34,131.62 227.69,131.96 228.05,131.96 228.46,131.56 228.55,131.56 228.62,131.56 228.99,131.93 228.99,132.56 228.87,132.68 228.36,132.68 228.07,132.97 228.07,133.39 228.36,133.68 228.87,133.68 228.99,133.8 228.99,134.56 229.43,135 229.43,138.05 228.8,138.68 228.8,139.76 229.04,140 229.43,140 v3(229.65,140.21)
  BOTTOM w0.114: CN4100.104 229.7,141.74 230.55,140.89 230.55,140.18 230.32,139.95 229.91,139.95 v3(229.65,140.21) ; U4555.AW36 195.13,95.87 195.46,96.19 v2(195.53,96.19)
M_CLK_DDR1_DP: length 74.9
  L6 w0.076: 196.57,103.29 196.57,103.15 196.52,103.09 194.75,101.32 194.75,96.83 194.93,96.64 195.39,96.64 195.53,96.78 v3(195.53,97.02)
  L6 w0.102: v2(229.68,139.5) 229.68,139.61 229.51,139.78 229.13,139.78 229.02,139.67 229.02,138.77 229.65,138.14 229.65,134.91 229.2,134.47 229.2,133.71 228.96,133.47 228.45,133.47 228.29,133.3 228.29,133.06 228.45,132.89 228.96,132.89 229.2,132.65 229.2,131.84 228.71,131.34 228.64,131.34 228.37,131.34 227.96,131.75 227.78,131.75 227.56,131.53 227.56,131.34 227.96,130.94 227.96,130.6 225.97,128.61 213.04,128.61 196.57,112.13 196.57,103.29
  BOTTOM w0.114: U4555.AY36 195.13,96.52 195.53,96.91 v3(195.53,97.02) ; CN4100.102 230.22,142.65 230.22,141.54 230.78,140.99 230.78,140.09 230.41,139.72 229.9,139.72 v2(229.68,139.5)
M_CLK_DDR2_DN: length 93.7
  L3 w0.076: v3(196.56,91.77) 196.76,91.97 197.07,91.97 197.28,92.19 197.28,93.87 197.01,94.15 196.71,94.15 196.08,94.78 196.08,101.25 197.27,102.44 197.27,102.77
  L3 w0.102: v2(152.8,136.88) 152.8,137.12 152.52,137.4 152.52,138.98 151.88,139.62 151.67,139.62 151.48,139.44 151.48,139.23 151.95,138.76 151.95,136.12 152.37,135.7 152.71,135.7 153.13,135.28 153.13,133.94 152.86,133.67 152.43,133.67 152.17,133.93 152.17,134.45 152.08,134.54 151.82,134.54 151.73,134.45 151.73,133.53 152.23,133.03 152.23,132.52 152.58,132.17 154.5,132.17 157.97,128.69 180.06,128.69 197.27,111.49 197.27,102.77
  BOTTOM w0.114: v3(196.56,91.77) 196.24,91.45 U4555.AM38 ; CN4125.103 153,135.27 153.18,135.46 153.18,136.28 153.47,136.56 153.47,136.94 153.29,137.12 152.92,137.12 152.8,137.01 v2(152.8,136.88)
M_CLK_DDR2_DP: length 93.7
  L3 w0.076: 197.05,102.8 197.05,102.46 195.91,101.32 195.91,94.71 196.64,93.99 196.94,93.99 197.12,93.8 197.12,92.26 197,92.14 196.77,92.14 196.56,92.34 v2(196.56,92.44)
  L3 w0.102: 197.05,102.8 197.05,111.4 179.97,128.48 157.88,128.48 154.41,131.95 152.49,131.95 152.01,132.43 152.01,132.94 151.52,133.44 151.52,134.54 151.73,134.76 152.17,134.76 152.38,134.54 152.38,134.02 152.52,133.88 152.77,133.88 152.92,134.03 152.92,135.19 152.62,135.49 152.28,135.49 151.73,136.03 151.73,138.67 151.27,139.14 151.27,139.53 151.58,139.84 151.97,139.84 152.74,139.07 152.74,137.79 v3(152.95,137.58)
  BOTTOM w0.114: v2(196.56,92.44) 196.23,92.1 U4555.AN38 ; CN4125.101 153.6,135.27 153.41,135.46 153.41,136.18 153.69,136.47 153.69,137.04 153.38,137.35 153.18,137.35 v3(152.95,137.58)
M_CLK_DDR3_DN: length 94.7
  L3 w0.076: 197.99,102.78 197.99,102.77 197.99,102.54 196.67,101.22 196.67,94.78 196.91,94.54 197.22,94.54 197.68,94.09 197.68,90.77 197.36,90.45 196.63,90.45 v3(196.59,90.41)
  L3 w0.102: 197.99,102.78 197.99,111.79 180.36,129.42 158.27,129.42 154.63,133.06 154.63,133.77 154.01,134.4 154.01,135.7 153.7,136.01 153.7,137.85 153.8,137.95 153.86,138.01 153.86,139.21 154.27,139.62 154.27,142.96 153.99,143.24 153.53,143.24 153.25,142.96 153.25,140.43 153.1,140.29 152.87,140.29 v2(152.74,140.42)
  BOTTOM w0.114: v3(196.59,90.41) 196.33,90.15 U4555.AK38 ; CN4125.104 152.7,141.75 153.62,140.83 153.62,140.52 153.36,140.26 152.86,140.26 152.74,140.39 v2(152.74,140.42)
M_CLK_DDR3_DP: length 94.7
  L3 w0.076: 197.77,102.8 197.77,102.56 196.5,101.29 196.5,94.71 196.84,94.38 197.15,94.38 197.51,94.02 197.51,90.84 197.29,90.62 196.95,90.62 196.59,90.98 v2(196.59,91.08)
  L3 w0.102: v3(152.84,139.71) 152.84,139.95 152.96,140.07 153.19,140.07 153.46,140.34 153.46,142.87 153.62,143.02 153.9,143.02 154.06,142.87 154.06,139.71 153.65,139.3 153.65,138.1 153.49,137.94 153.49,135.92 153.79,135.61 153.79,134.31 154.42,133.68 154.42,132.97 158.18,129.2 180.27,129.2 197.77,111.7 197.77,102.8
  BOTTOM w0.114: v3(152.84,139.71) 152.84,139.9 152.97,140.04 153.46,140.04 153.85,140.42 153.85,140.93 153.3,141.47 CN4125.102 ; v2(196.59,91.08) 196.31,90.8 U4555.AL38
M_CS#0: length 75.9
  L6 w0.076: 191.81,106.28 191.81,106.17 192.72,105.26 192.72,99.14 192.81,99.05 192.89,98.97 192.89,95.16 192.89,95.16 192.89,94.77 193.23,94.43 193.23,93.49 v2(193.7,93.02)
  L6 w0.165: v3(226.55,139.51) 226.42,139.63 225.02,139.63 224.62,139.23 224.62,137.61 224.06,137.05 224.06,135.9 222.14,133.98 209.61,133.98 207.3,131.66 207.29,131.66 205.17,129.55 205.17,129.54 204.95,129.32 204.95,129.05 205.13,128.87 205.13,128.65 204.92,128.43 204.79,128.43 204.56,128.66 204.33,128.66 204.16,128.49 204.16,128.26 204.39,128.03 204.39,127.9 204.13,127.64 204,127.64 203.77,127.87 203.54,127.87 203.43,127.76 203.43,126.94 191.81,115.33 191.81,106.28
  BOTTOM w0.076: U4555.AP33 193.52,93.02 v2(193.7,93.02)
  BOTTOM w0.178: v3(226.55,139.51) 226.76,139.72 226.78,139.72 227.04,139.98 227.04,140.35 226.7,140.69 CN4100.114
M_CS#1: length 76.3
  L6 w0.076: v2(192.76,93.7) 192.71,93.75 192.71,98.92 192.64,98.99 192.56,99.07 192.56,104.87 191.34,106.08 191.34,106.33
  L6 w0.165: v3(223.64,137.7) 223.71,137.7 224.08,138.08 224.08,139.87 223.93,140.03 223,140.03 222.86,139.89 222.86,136.85 222.95,136.76 223.41,136.76 223.55,136.62 223.55,136.35 223.41,136.21 222.95,136.21 222.78,136.04 222.78,135.43 221.84,134.49 209.4,134.49 207.09,132.17 207.08,132.17 204.66,129.76 204.66,129.75 202.89,127.98 202.89,127.16 191.34,115.6 191.34,115.57 191.3,115.54 191.3,106.37 191.34,106.33
  BOTTOM w0.076: v2(192.76,93.7) 192.66,93.7 U4555.AR32
  BOTTOM w0.178: v3(223.64,137.7) 223.64,137.7 224.54,136.79 224.54,134.33 CN4100.121
M_CS#2: length 92.8
  L3 w0.076: v2(192.75,91.78) 192.37,92.16 192.37,94.1 192.99,94.72 192.99,105.55 192.39,106.16
  L3 w0.165: v3(147.28,139.48) 147.28,139.5 146.7,140.08 146.49,140.08 146.29,139.88 146.29,139.67 146.68,139.28 146.68,138.61 146.52,138.44 146.52,137.12 146.1,136.7 146.1,124.99 147.13,123.96 178.1,123.96 192.39,109.68 192.39,106.16
  BOTTOM w0.076: v2(192.75,91.78) 192.69,91.78 192.36,91.45 U4555.AM32
  BOTTOM w0.178: v3(147.28,139.48) 147.69,139.48 149.7,141.49 CN4125.114
M_CS#3: length 92.4
  L3 w0.076: 191.85,106.33 192.83,105.36 192.83,94.99 192.19,94.36 192.19,91.06 v2(192.77,90.48)
  L3 w0.165: 191.85,106.33 191.85,109.35 177.77,123.43 146.91,123.43 145.57,124.77 145.57,136.56 145.45,136.68 145.45,138.38 145.79,138.71 v3(145.99,138.71)
  BOTTOM w0.076: U4555.AK32 192.36,90.15 192.69,90.48 v2(192.77,90.48)
  BOTTOM w0.178: CN4125.121 147.5,134.37 147.5,135.52 146.5,136.52 146.5,138.2 v3(145.99,138.71)
M_ODT0: length 4.4
  TOP w0.178: v3(226.07,141.19) 226.07,141.66 R4117.2
  BOTTOM w0.178: v3(226.07,141.19) 226.1,141.22 CN4100.116
M_ODT1: length 3.1
  TOP w0.178: R4118.2 224.69,142.15 v3(224.69,141.19)
  BOTTOM w0.178: v3(224.69,141.19) 224.9,141.4 CN4100.120
M_ODT2: length 4.3
  BOTTOM w0.178: R4119.2 v1(149.38,146.04) 149.38,144.23 149.1,143.94 CN4125.116
M_ODT3: length 4.2
  BOTTOM w0.178: R4120.2 v1(147.73,146.04) 147.73,144.12 147.9,143.96 CN4125.120
M_PWROK: length 192.3
  TOP w0.102: v2(246.53,103.82) 246.79,103.56 v1(246.79,103.15) R7415.1 ; v2(255.81,102.35) 255.81,102.22 256.65,101.38 256.65,99.71 257.66,98.69 260.28,98.69 260.51,98.93 U300.122 ; U2950.4 250.92,112.57 251.79,113.44 R2953.2 R2954.2 253.1,113.44 253.65,112.89 v2(253.65,112.75) 255.29,112.75 256.33,113.79 256.59,113.79 R2952.1 ; v2(155.59,87.44) 155.89,87.14 155.89,84.28 157.77,82.4 R4723.1
  L3 w0.102: v2(253.65,112.75) 253.94,113.05 253.94,122.6 v2(251.8,124.75)
  L6 w0.102: v2(246.53,103.82) 246.53,103.82 246.53,104.14 253.65,111.25 v2(253.65,112.75)
  BOTTOM w0.102: v2(246.53,103.82) 247.35,104.63 253.65,104.63 255.81,102.47 v2(255.81,102.35) ; v2(251.8,124.75) 251.8,124.75 251.64,124.91 241.1,124.91 239.7,123.5 232.99,123.5 232.99,123.51 230.02,123.51 230.02,123.5 226.05,123.5 226.05,123.51 208.34,123.51 208.01,123.17 206.87,122.03 166.13,122.03 157.09,113 153.83,113 150.02,109.19 150.02,104.66 150.02,101.1 150.02,100.81 150.02,100.81 150.02,97.52 150.51,97.03 150.51,93.47 155.59,88.4 v2(155.59,87.44)
MAIN_BAT_DET#: length 180.3
  TOP w0.102: v3(260.74,111.64) 261.57,112.48 264.83,112.48 265.12,112.19 265.12,111.62 265.28,111.46 U300.92 ; v2(159.93,60.31) 160.35,60.73 R6058.2 R6057.1 ; v2(169.32,60.13) 169.32,62.96 166.92,65.36 166.92,66.95 v2(165.56,68.31)
  L5 w0.102: v2(165.56,68.31) 165.98,67.9 169.38,67.9 169.68,68.2 170.71,68.2 171.62,67.3 177.66,67.3 178.96,68.59 181.23,68.59 182.96,66.86 185.9,66.86 186.05,67.02 191.62,67.02 192.13,67.52 197.75,67.52 199.37,65.9 199.37,62.44 200.06,61.75 212.51,61.75 213.39,62.62 220.03,62.62 220.78,63.37 227.53,63.37 227.66,63.5 245.88,63.5 247.98,65.59 247.98,66.26 248.28,66.56 249.92,66.56 251.19,67.83 252.69,67.83 255.18,70.32 259,70.32 261.88,73.19 261.88,74.36 262.69,75.17 262.69,78.16 263.94,79.42 263.94,92.37 264.24,92.67 264.24,101.18 265.84,102.78 265.84,105.65 264.95,106.54 263.56,106.54 260.76,109.33 260,109.33 259.62,109.71 259.62,110.53 v3(260.74,111.64) ; v2(169.32,60.13) 168.91,60.55 160.16,60.55 v2(159.93,60.31)
MIC_BIAS: length 5.2
  TOP w0.254: R602.2 305.34,53.54 305.34,55.2 304.05,56.5 303.31,56.5 303.2,56.6 U501.23
MIC_VREF: length 113.9
  TOP w0.076: v2(305.47,59.55) 305.09,59.55 304.78,59.86 U501.30
  TOP w0.102: v3(269.22,89.01) 269.91,88.33 R383.2 ; v2(277.53,90.26) 278.04,90.76 Q320.5 278.04,91.28 278.54,91.79 278.54,92.31 R334.1
  L3 w0.102: v2(258.2,55.18) 259.98,53.4 265.51,53.4 267.21,55.1 275.62,55.1 276.59,54.14 278.11,54.14 279.35,55.38 283.14,55.38 284.08,56.32 285.35,56.32 286.93,57.9 286.93,60.44 288.58,62.09 289.47,62.09 291.12,63.74 297.59,63.74 298.23,64.37 300.13,64.37 301.53,62.98 303.56,62.98 304.45,62.09 304.45,59.78 304.81,59.42 305.34,59.42 v2(305.47,59.55)
  L5 w0.102: v2(258.22,62.65) 259.14,63.56 260.19,63.56 263.84,67.22 264.59,67.22 269.35,71.97 269.35,76.26 271.18,78.09 271.18,87.06 v3(269.22,89.01)
  L6 w0.102: v2(277.53,90.26) 277.1,89.82 270.04,89.82 v3(269.22,89.01)
  BOTTOM w0.102: v2(258.2,55.18) 258.76,55.74 258.76,57.49 258.22,58.02 v2(258.22,62.65)
MPHY_PRW_EN: length 31.8
  TOP w0.102: v3(163.94,70.32) 163.94,70.55 162.66,71.83 162.66,77.07 163.98,78.4 163.98,78.47 163.98,83.06 165.2,84.27 v4(165.2,84.72)
  BOTTOM w0.076: 169.22,84.65 169.35,84.65 169.62,84.92 169.94,84.92 170.16,84.69 170.16,84.25 170.28,84.14 171.36,84.14 171.78,84.56 173.21,84.56 173.21,84.56 173.66,84.56 173.66,84.56 173.73,84.56 173.73,84.56 173.89,84.56 174.19,84.85 U4555.Y2
  BOTTOM w0.102: v3(163.94,70.32) 164.24,70.32 164.7,70.77 164.7,72.04 164.17,72.58 163.76,72.58 163.56,72.78 Q4942.5 ; R4753.2 165.04,84.88 v4(165.2,84.72) 165.27,84.65 169.22,84.65
MSATA_DET#: length 184.1
  TOP w0.102: Q1950.3 295.94,98.07 R1953.1 295.69,98.16 295.38,97.85 v2(295.38,97.65) ; v2(168.6,109.33) v1(167.42,109.33) 165.89,109.33 165.13,108.57 165.13,105.78 166.07,104.84 166.07,104.83 167.19,103.71 167.19,100.46 166.05,99.33 166.05,87.61 165.81,87.36 164.75,87.36 164.4,87.72 v2(164.4,87.87)
  L5 w0.102: v2(295.38,97.65) 295.1,97.93 288.98,97.93 288.2,97.14 286.54,97.14 284,99.68 284,100.57 282.99,101.59 280.12,101.59 279.56,101.02 278.01,101.02 276.92,102.12 274.01,102.12 272.4,103.73 272.31,103.73 272.28,103.75 270.27,103.75 263.69,110.34 263.68,110.34 262.8,111.23 262.6,111.42 262.6,112.07 261.7,112.97 v2(261.7,115.02)
  BOTTOM w0.076: U4555.AC1 173.54,86.35 172.19,86.35 172.09,86.25 171.75,86.25 171.74,86.26 171.71,86.26
  BOTTOM w0.102: v2(168.6,109.33) 173.2,113.93 211.95,113.93 212.57,114.56 243.57,114.56 244.76,115.74 257.65,115.74 258.38,115.02 v2(261.7,115.02) ; R4820.1 164.27,88.58 R4824.1 164.32,87.94 v2(164.4,87.87) 165.22,87.04 v1(165.26,87.04) 168.88,87.04 169.66,86.26 170.31,86.26 170.33,86.25 170.65,86.25 170.66,86.26 171.71,86.26
MSR_ENABLE_N: length 3.6
  TOP w0.102: CN4920.60 230.65,90.53 230.52,90.66 229.27,90.66 v1(229.14,90.54) 228.91,90.3 228.32,90.3 R4939.1
MUX_SELECT#: length 21.9
  BOTTOM w0.076: U4555.L1 172.45,80.36 171.6,79.51 171.48,79.51
  BOTTOM w0.102: R4924.2 154.51,75.17 155.51,75.17 155.68,74.99 158.17,74.99 v1(158.45,74.71) 158.81,74.71 160.36,76.26 160.97,76.26 161.12,76.41 165.8,76.41 168.48,79.09 v1(168.69,79.09) 169.82,79.09 170.24,79.51 171.48,79.51
Net_3963: length 1.2
  BOTTOM w0.102: 266.41,69.04 266.41,67.99 v1(266.27,67.86)
NFC_3S_CLK_DB: length 56.1
  TOP w0.102: v3(86.9,113.02) 88.5,111.42 CN9000.35 ; v2(81.65,158.1) CN9002.8
  L3 w0.102: v3(86.9,113.02) 87.79,113.9 87.79,142.86 81.44,149.21 81.44,157.89 v2(81.65,158.1)
NFC_3S_DATA_DB: length 56
  TOP w0.102: v2(82.15,157.21) CN9002.9 ; v3(86.9,111.75) 88,110.64 CN9000.34
  L3 w0.102: v3(86.9,111.75) 88.3,113.14 88.3,143.11 82.15,149.26 v2(82.15,157.21)
NFC_3S_SMCLK: length 41.5
  TOP w0.114: v2(116.49,88.99) 116.55,89.05 CN200.35
  L3 w0.102: v3(151.57,88.17) 151.57,87.97 148.88,85.28 146.25,85.28 145.93,84.97 140.48,84.97 138.15,87.29 127.34,87.29 126.14,88.48 117.14,88.48 116.49,89.13 v2(116.49,88.99)
  BOTTOM w0.114: R4776.1 153.16,88.39 Q4759.1 151.8,88.39 v3(151.57,88.17)
NFC_3S_SMDATA: length 43.3
  TOP w0.114: CN200.34 116.05,89.21 v2(115.86,89.01)
  L3 w0.102: v3(152.06,86.13) 151.96,86.24 150.47,86.24 148.52,84.29 146.11,84.29 145.79,84.61 140.32,84.61 138.04,86.9 127.23,86.9 126,88.13 116.74,88.13 v2(115.86,89.01)
  BOTTOM w0.114: v3(152.06,86.13) 152.05,86.13 151.09,87.09 Q4759.4 149.41,87.09 R4783.1
NFC_DWL_REQ: length 117.2
  TOP w0.102: v2(126.55,80.53) 126.55,80.86 126.02,81.39 125.51,81.39 123.3,79.18 113.01,79.18 112.63,79.56 112.63,80.68 110.86,82.45 110.86,83.87 114.55,87.55 CN200.31 ; v3(149.73,72.76) 149.73,71.7 150.98,70.44 152.2,70.44 155.73,66.91 157.13,66.91 157.51,67.3 157.51,67.3 157.72,67.5 157.72,68.26 158.27,68.82 160.05,68.82 160.81,68.06 160.81,67.3 167.16,60.95 167.16,60.31 168.18,59.29 170.34,59.29 171.23,60.18 171.23,62.98 169.86,64.35 169.86,66 169.12,66.74 169.12,67.75 168.69,68.18 168.69,69.24 168.9,69.45 169.37,69.45 169.69,69.14 v2(169.69,68.99) ; v2(170.34,65.11) 170.34,64.63 171.82,63.15 R4771.2
  L3 w0.102: v2(169.69,68.99) 169.69,68.78 170.72,67.75 170.72,65.49 v2(170.34,65.11) ; v3(149.73,72.76) 147.95,74.53 140.08,74.53 137.01,77.61 135.05,77.61 131.41,81.24 127.26,81.24 v2(126.55,80.53)
  BOTTOM w0.076: 173.54,74.45 173.91,74.81 174.32,74.81 174.4,74.9 175.39,74.9 U4555.C4
  BOTTOM w0.102: v2(169.69,68.99) 170.38,68.99 170.75,69.35 170.75,70.23 R4769.2 173.54,74.01 173.54,74.45
NFC_DWL_REQ_DB: length 55.6
  TOP w0.102: v3(86.9,109.21) 86.5,108.8 CN9000.31 ; v2(80.15,157.97) CN9002.5
  L3 w0.102: v2(80.15,157.97) 79.79,157.61 79.79,149.59 86.01,143.37 86.01,110.09 v3(86.9,109.21)
NFC_INT: length 67.4
  TOP w0.102: CN200.33 115.55,90.71 v3(117.18,92.34)
  L3 w0.102: v3(117.18,92.34) 120.2,92.34 121.56,90.99 136.54,90.99 137.4,91.84 143.25,91.84 143.8,91.3 157.95,91.3 158.41,90.83 162.94,90.83 164.66,92.56 166.69,92.56 166.77,92.48 v2(166.82,92.48)
  BOTTOM w0.076: 169.22,92.84 169.42,92.64 174.58,92.64 174.84,92.39 U4555.AN3
  BOTTOM w0.102: 169.22,92.84 169.13,92.93 167.26,92.93 v2(166.82,92.48) 166.63,92.48 164.69,94.42 163.56,94.42 R4724.2
NFC_INT_DB: length 55.8
  TOP w0.102: v2(83.1,158.23) 83.15,158.28 CN9002.11 ; v3(86.9,110.48) 87.5,109.88 CN9000.33
  L3 w0.102: v2(83.1,158.23) 83.1,149.07 88.81,143.37 88.81,112.38 v3(86.9,110.48)
NFC_RST#: length 76.3
  TOP w0.102: CN200.36 117.05,87.18 v2(116.95,87.08) ; v2(160.17,86.35) 158.89,85.08 v1(158.76,85.08) 158.81,85.02 R4725.2
  L3 w0.102: v2(160.17,86.35) 159.2,85.38 154.68,85.38 152.85,83.54 152.23,83.54 149.34,80.66 146.18,80.66 145.83,81.01 143.92,81.01 143.16,81.77 143.16,82.66 142.66,83.16 137.85,83.16 135.03,85.98 126.51,85.98 125.89,86.6 117.43,86.6 v2(116.95,87.08)
  L6 w0.076: 175.12,87.08 175.23,86.97 176.75,86.97 v2(177.3,86.42)
  L6 w0.102: 175.12,87.08 172.36,87.08 172.17,87.27 171.67,87.27 170.65,86.25 169.92,86.25 169.54,86.63 169.54,86.72 169.22,87.04 163.85,87.04 162.82,88.07 159.95,88.07 159.42,87.54 159.42,87.15 160.17,86.4 v2(160.17,86.35)
  BOTTOM w0.076: U4555.AD7 177.3,86.71 v2(177.3,86.42)
NFC_RST#_DB: length 55.8
  TOP w0.102: v3(86.9,114.29) 89,112.18 CN9000.36 ; v2(80.65,157.21) CN9002.6
  L3 w0.102: v2(80.65,157.21) 80.65,149.36 86.9,143.11 v3(86.9,114.29)
NFC_SWP: length 1.9
  TOP w0.356: CN200.32 115.05,91 v1(115.73,91.68)
NIC_XTAL_IN: length 9
  TOP w0.102: X400.3 295.82,100.7 295.82,103.45 R400.2 296.03,103.66 C400.2 295.94,104.59 295.94,104.61 295.13,105.43 294.82,105.43 294.57,105.67 294.57,106.05 294.17,106.45 U400.10
NIC_XTAL_OUT: length 6.6
  TOP w0.102: U400.9 293.83,107.41 293.83,106.28 294.21,105.9 294.21,105.53 294.67,105.07 294.98,105.07 295.22,104.83 C404.2 295.22,103.71 R400.1 295.18,103.62 295.46,103.34 295.46,102.55 X400.1
NMI_SMI_DBG#: length 68.4
  TOP w0.102: v2(142.02,89.14) 142.02,89.65 141.76,89.9 v1(141.76,93.71) 141.76,96.56 Q302.2
  L3 w0.102: v2(151.06,80.33) 152.63,81.9 160.66,81.9 v2(161.3,82.54)
  L5 w0.102: v2(145.51,82.25) 145.66,82.4 149.43,82.4 149.75,82.07 150.86,82.07 151.5,81.43 151.5,80.77 v2(151.06,80.33)
  L6 w0.076: v2(176.65,83.54) 176.26,83.15 175.67,83.15
  L6 w0.102: v2(161.3,82.54) 162.99,82.54 163.72,81.8 166.31,81.8 166.86,82.34 170.1,82.34 170.25,82.19 171.18,82.19 171.65,82.66 171.65,82.73 172.28,83.36 175.46,83.36 175.67,83.15 ; v2(142.02,89.14) 143.04,88.12 143.04,86.09 145.07,84.06 145.07,82.69 v2(145.51,82.25)
  BOTTOM w0.076: v2(176.65,83.54) 176.65,83.86 U4555.V6
  BOTTOM w0.102: v2(145.51,82.25) 145.19,81.93 145.19,78.47 144.37,77.65 144.37,73.59 144.13,73.34 143.34,73.34 142.38,74.3 CN375.7 ; v2(161.3,82.54) 161.04,82.28 159.75,82.28 158.89,83.14 R4765.1
NUM_LOCK_LED#: length 179.5
  TOP w0.102: v2(270.36,105.32) 268.88,106.8 U300.83 268.88,111.63 268.26,112.26 R320.1 ; R394.1 265.39,88.97 v3(265.39,88.96)
  L3 w0.102: v3(265.39,88.96) 265.62,89.2 265.62,95.24 270.36,99.97 v2(270.36,105.32)
  L5 w0.102: v2(142.33,69.57) 143.84,68.05 147.1,68.05 148.23,66.92 163.77,66.92 164.46,67.61 169.5,67.61 169.88,67.99 170.63,67.99 171.59,67.04 177.74,67.04 179.09,68.39 181.14,68.39 182.87,66.66 186.07,66.66 186.2,66.78 191.72,66.78 192.18,67.24 197.69,67.24 199.09,65.85 199.09,62.33 199.93,61.49 212.69,61.49 213.54,62.34 220.13,62.34 220.91,63.12 227.83,63.12 228.01,63.3 242.93,63.3 242.93,63.3 243.27,63.3 243.27,63.3 245.97,63.3 247.79,65.12 250.42,65.12 255.39,70.09 259.16,70.09 262.08,73.01 262.08,74.28 263.51,75.71 263.51,78.12 264.17,78.78 264.17,83.96 265.39,85.18 v3(265.39,88.96)
  BOTTOM w0.102: v2(142.33,69.57) 142.33,69.62 141.65,70.3 CN375.15
OCP_A_IN: length 291.9
  TOP w0.102: R315.1 282.74,100.06 v2(282.93,100.26) ; v2(54.9,88.76) 54.9,85.97 D6901.1 55.14,85.85 55.7,85.29 R6917.2 R6936.2
  L5 w0.102: v2(261.02,127.49) 262.16,126.35 262.16,119.87 260.75,118.46 260.75,113.11 261.91,111.96 261.91,111.33 263.45,109.78 270.04,103.2 272.05,103.2 272.08,103.17 272.17,103.17 275.08,100.26 v2(282.93,100.26)
  L6 w0.102: v2(54.9,88.76) 55.63,89.49 72.53,89.49 73.28,88.75 79.35,88.75 81.04,90.43 82.66,90.43 83.41,91.18 86.54,91.18 88.43,93.08 89.38,93.08 92.3,95.99 92.46,95.99 92.46,95.99 92.8,95.99 95.37,95.99 102.61,103.23 102.61,107.25 104.48,109.11 104.48,123.03 105.89,124.44 105.89,129.18 106.53,129.82 v2(107.51,129.82)
  BOTTOM w0.102: v2(107.51,129.82) 107.56,129.82 108.28,130.54 v1(109.81,130.54) 110.1,130.83 163.06,130.83 163.35,131.12 190.28,131.12 191.73,129.67 191.94,129.46 193.78,129.46 195.41,131.1 202.67,131.1 206.28,127.49 237.27,127.49 239.48,129.7 244.71,129.7 245.65,128.76 259.75,128.76 v2(261.02,127.49)
OCP_OC#: length 22.1
  TOP w0.102: v2(169.1,68.99) 169.53,68.57 169.88,68.57 170.74,69.42 v1(170.74,70.11) 170.74,71.5 171.75,72.51 171.75,76.76 v2(171.44,77.06)
  L6 w0.076: v2(171.44,77.06) 171.49,77.06 171.49,77.05 172.03,77.05 172.69,77.71 172.69,78.09 174.17,79.57 175.24,79.57 175.89,80.23 v2(175.89,80.69)
  BOTTOM w0.076: v2(175.89,80.69) 175.89,80.9 176.17,81.17 U4555.N5
  BOTTOM w0.102: Q4700.3 166.15,69.45 166.66,69.96 169.15,69.96 R4780.1 169.1,69.41 v2(169.1,68.99)
OCP_PWM_OUT: length 157.3
  TOP w0.102: U300.59 274.25,106.93 273.3,105.98 273.3,105.25 270.17,102.11 270.17,97.26 v2(270.09,97.19)
  L5 w0.102: v2(270.09,97.19) 269.27,96.37 269.27,93.71 267.85,92.29 267.85,89.72 270.95,86.62 270.95,79.46 269.86,78.37 269.86,77.23 269.02,76.39 269.02,72.02 264.42,67.42 263.76,67.42 260.28,63.94 257.85,63.94 254.27,60.37 251.43,60.37 250.95,59.89 229.99,59.89 229.54,59.44 229.53,59.44 222.7,59.44 221.16,57.9 198.21,57.9 198.19,57.92 198.15,57.92 196.86,59.21 186.54,59.21 185.37,60.38 176.49,60.38 174.63,62.24 174.63,63.06 173.62,64.06 172.65,64.06 171.2,65.52 166.5,65.52 v3(165.97,66.05)
  BOTTOM w0.102: Q4700.1 166.8,66.88 v3(165.97,66.05)
OCS_N2: length 57.2
  TOP w0.102: U2550.47 269.71,64.75 269.45,65.01 268.28,65.01 268,65.29 268,65.98 C2584.1 267.24,66.74 267.24,68.77 R2562.1 268.38,68.39 v2(268.38,67.88) ; v2(300.72,78.6) 300.83,78.71 301.8,78.71 303.03,79.94 305.77,79.94 306.14,79.57 U2400.5
  L6 w0.102: v2(300.72,78.6) 298.96,76.84 298.96,76.54 298.08,75.66 294.09,75.66 292.92,74.48 292.02,74.48 286.19,68.65 276.68,68.65 272.29,73.04 271.69,73.04 271.69,73.04 270.98,73.04 270.77,72.83 270.62,72.83 269.96,72.17 269.96,71.74 268.38,70.17 v2(268.38,67.88)
OCS_N3: length 88.6
  TOP w0.102: U2550.44 271.21,64.86 270.94,65.12 v2(270.94,65.67) 271.34,66.08 271.34,70.2 270.82,70.72 269.78,70.72 269.53,70.98 269.53,71.53 C2582.1 R2563.1
  L5 w0.102: v2(318.29,38.85) 316.64,40.5 316.64,52.26 312.78,56.12 309.3,56.12 308.13,54.95 307.96,54.95 306.89,54.95 306.4,54.47 302.56,54.47 301.95,53.86 284.45,53.86 284.1,53.51 v2(284.1,52.4)
  BOTTOM w0.102: v2(270.94,65.67) 270.94,66.42 271.88,67.37 275.8,67.37 278.06,65.11 278.74,65.11 279.11,64.74 280.06,64.74 280.94,63.85 280.94,63.11 282.71,61.34 282.71,58.35 v1(282.2,57.85) 281.97,57.62 281.97,53.76 282.4,53.33 282.91,53.33 283.83,52.4 v2(284.1,52.4) ; v2(318.29,38.85) 318.29,39.32 318.09,39.52 U2401.5
