# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P3V3M: length 117.6
  TOP w0.249: U400.4 291.77,106.74 v2(291.86,106.64) 292.17,106.95 U400.5
  TOP w0.254: v2(248.34,99.2) 248.32,99.2 248.32,101.97 249.46,103.11 249.46,104.46 248.98,104.94 248.98,106.39 248.19,107.17 247.26,107.17 246.03,108.4 R2959.1 ; Q485.2 310.8,105.73 R485.1 310.08,105.65 300.9,105.65 298.1,108.44 297.21,108.44 296.88,108.78 v2(296.37,108.78) 296.32,108.78 296.15,108.95 U400.15 ; v3(285.68,104.23) 285.79,104.33 C402.1 R407.1 ; U400.19 v2(296.37,110.55) ; R489.1 293.83,116.45 293.83,114.69 293.78,114.64 293.78,114.57 293.37,114.15 v2(293.37,114.04) U400.29
  TOP w0.381: R2972.1 293.28,121.31
  L3 w0.381: v2(291.86,106.64) 292.52,107.3 293.4,107.3 294.46,108.35 294.46,112.95 v2(293.37,114.04)
  L5 w0.254: v2(291.86,106.64) 290.44,108.06 289.56,108.06 289.4,107.91 288.5,107.91 287.36,106.77 287.36,105.11 286.47,104.23 v3(285.68,104.23)
  L5 w0.762: v2(296.37,110.55) 296.37,110.56 293.37,113.56 v2(293.37,114.04) 293.37,116.19 293.61,116.43 293.61,119.32 v5(295.05,120.76)
  L6 w0.254: v2(248.34,99.2) 249.36,99.2 251.11,100.95 255.83,100.95 257.35,99.43 260.89,99.43 263.38,101.92 269.09,101.92 272.22,98.79 274.73,98.79 276.13,97.39 280.12,97.39 282.23,99.5 282.23,101.59 284.87,104.23 v3(285.68,104.23)
  BOTTOM w0.457: v2(296.37,110.55) 296.98,109.94 296.98,109.08 296.67,108.78 v2(296.37,108.78)
P3V3M_R_RSVD: length 4.1
  TOP w0.254: R407.2 288.29,105.18 v1(288.32,105.22) 288.4,105.22 290.57,107.39 U400.1
P3V3S: length 690.5
  TOP w0.254: v2(280.7,93.46) 281.17,93.46 R385.2 ; v2(154.79,84.77) 153.4,83.38 R4712.1 152.18,81.95 152.18,79.11 152.94,78.34 R4728.1 153.4,78.34 ; v2(151.04,81.01) 151.04,82.92 151.47,83.35 v2(151.47,84.43) 151.21,84.68 150.79,84.68 150.46,85.01 150.46,88.77 150.7,89.01 v2(150.7,90.43) ; v2(316.52,26.66) 314.99,28.18 314.99,37.02 ; R4922.1 227.64,89.02 227.33,88.71 226.48,88.71 226.17,88.4 v2(226.17,88.15) ; U501.9 297.94,59.06 297.29,58.41 v2(297.01,58.41) ; R4573.1 R4711.1 157.96,79.7 157.19,79.7 156.72,80.17 156.72,80.18 v2(156.72,80.2) ; 161.82,84.68 161.56,84.42 161.56,83.92 161.53,83.89 161.53,83.22 162.21,82.54 162.21,81.15 v4(161.77,80.71) ; 161.82,84.68 161.82,84.84 161.86,84.88 161.86,86.33 v2(161.85,86.34) 162.09,86.58 162.09,88.9 v2(162.03,88.96) ; 161.82,84.68 v2(161.82,84.67) ; 153.4,78.34 R4754.2 R4785.2 R4738.2 R4745.2 ; 153.4,78.34 R4764.2 153.32,79.32 153.32,80.04 R4701.2 ; v2(284.13,109.08) 284.64,109.59 284.64,110.6 284.26,110.98 R387.2 R388.2 284.13,111.87 284.64,112.38 284.64,113.27 283.75,114.16 283.75,114.67 283.37,115.05 282.73,115.05 282.29,115.49 Q114.3 281.55,117.03 R127.1 ; R1955.1 295.56,93.5 291.03,93.5 290.86,93.33 289.76,93.33 289.59,93.5 C7593.1 288.37,93.5 287.31,92.44 v2(286.8,92.44) ; v2(167.82,68.36) 167.82,66.18 v2(167.72,66.08) ; U800.27 295.78,70.76 295.97,70.57 297.11,70.57 297.76,71.22 297.85,71.22 298.14,71.52 298.14,72.34 297.94,72.55 R802.2 ; C4730.2 172.84,86.43 172.2,85.79 v4(172.2,85.51) 171.27,84.59 R4767.1 R4726.1 ; v2(163.89,77.05) 163.82,76.98 R4770.1 R4781.1 R4571.1 ; C4935.1 186.46,83.47 186.08,83.84 185.41,83.84 182.99,81.43 C4717.1 181.46,81.26 v2(181.46,80.63) ; U501.3 297.84,61.46 297.47,61.83 C505.1 ; v2(247.56,100.82) 247.51,100.87 R7425.1 ; C7584.1 156.62,76.06 v4(157.06,75.63) 158.32,75.63 159.08,74.87 R4749.2 159.12,74.36 R4907.1 ; v2(276.1,68.59) 276.1,69.3 276.59,69.79 R5313.1 ; R1008.1 230.28,108.36 232.02,110.09 237.3,110.09 239.88,112.68 R7404.1 241.47,112.69 241.47,113.51 242.86,114.9 v2(244.77,114.9) ; R386.2 275.9,90.77 v2(275.9,90.31)
  TOP w0.356: CN200.23 110.55,90.89 v2(110.42,91.02) 110.45,91.04 110.8,91.04 111.05,90.8 CN200.24 ; 192.8,57.77 CN202.1
  TOP w0.381: C505.1 297.21,62.5 v4(296.98,62.72) ; C3311.1 314.99,37.45 ; v2(240.44,64.8) 240.44,64.8 239.93,64.29 C7585.1 ; R2202.2 281.98,52.56 282.23,52.56 282.61,52.18 283.12,52.18 283.5,52.56 ; C2255.1 113.48,119.7 v4(114.11,120.33) ; v2(128.81,117.21) 128.81,126.73 126.05,129.49 C7485.1 C4130.1 C4129.1 124.92,131.99 124.22,132.69 v2(124.09,132.69) 124.26,132.86 R4126.1 124.26,136.21 123.35,137.12 123.35,139.6 R4200.1 ; C3506.1 121.7,146.88 v2(121.7,144.38) ; 192.8,57.77 192.44,57.41 v2(192.44,54.57) ; 300.08,80.43 295,80.43 294.16,81.27 ; 300.08,80.43 300.08,76.87 298.56,75.35 298.02,75.35 297.25,74.57 C807.1 297.25,74.06 296.91,73.73 C803.1 296.91,73.18 297.47,72.63 R802.2 ; 300.08,80.43 300.56,80.91 306.1,80.91 306.58,81.39 310.04,81.39 312.83,78.6 312.83,72.38 312.33,71.87 R570.2 ; R517.1 287.39,62.42 287.31,62.34 ; C7583.1 133.21,113.4 v2(133.46,113.14) ; v2(201.2,136.03) 201.23,136.03 201.66,135.6 R4103.1 C4104.1 C4105.1 C4211.1 D4204.1 C4210.1 201.66,132.29 v2(201.78,132.4) ; C7628.1 314.99,38.47 ; R3501.1 C3504.1 125.25,147.99 v2(125.25,149.59) 125.25,150.36 125.75,150.86 v1(126.23,150.86) ; v1(126.23,150.86) v2(126.23,153.67) ; v1(126.23,150.86) 127.91,150.86 128.43,150.34 R3511.2 ; 102.53,110.08 101.63,110.98 101.63,114.01 102.8,115.17 105.9,115.17 v2(106.81,114.26) ; 101.59,108.82 C3006.1
  TOP w0.508: v4(101.62,108.12) 101.59,108.15 101.59,109.36 102.32,110.08 U3000.5 ; 287.81,60.46 288.22,60.06 289.34,60.06 v2(289.72,60.44) ; 283.5,52.56 283.5,52.69 284.26,53.45 286.87,53.45 288.98,51.34 289.26,51.34
  TOP w1.016: v5(286.72,65.92) 287.31,65.34 287.31,60.97 287.81,60.46 287.81,57.19 290.2,54.8 290.2,51.6
  L3 w0.254: v2(244.77,114.9) 246.29,113.39 246.29,105.27 245.96,104.95 245.96,102.85 247.56,101.25 v2(247.56,100.82) ; v4(172.2,85.51) 173.74,83.97 175.2,83.97 175.27,84.04 177.3,84.04 177.81,84.54 v2(177.81,84.58) 178.38,84.01 180.42,84.01 180.83,83.6 180.83,82.59 181.46,81.95 v2(181.46,80.63) ; v2(280.7,93.46) 279.69,92.44 279.31,92.44 278.92,92.06 278.92,90.28 278.16,89.52 276.26,89.52 275.9,89.88 v2(275.9,90.31)
  L3 w0.381: v2(264.07,131.08) 264.88,130.26 264.88,115.61 264.24,114.97 v2(264.24,113.6) ; v2(114.46,162.09) 118.22,162.09 126.23,154.07 v2(126.23,153.67)
  L3 w0.508: v4(101.62,108.12) 101.62,105.65 106.02,101.25 109.71,101.25 111.03,99.93 111.03,94.96 v2(111.77,94.22)
  L5 w0.254: v2(177.81,84.58) 178.55,84.58 179.09,84.04 181.26,84.04 181.77,84.55 181.77,86.98 181.26,87.49 181.26,88.28 182.04,89.06 v2(182.04,89.06) ; v2(226.17,88.15) 226.17,88.45 226.9,89.19 234.04,89.19 234.09,89.14 234.27,88.96 237.78,88.96 239.05,90.23 242.58,90.23 243.08,89.72 243.08,89.11 v2(242.6,88.63) ; v2(280.7,93.46) 281.46,94.22 285.02,94.22 v2(286.8,92.44)
  L5 w0.508: v4(296.98,62.72) 297.21,62.72 298.23,61.71 298.23,59.62 v2(297.01,58.41)
  L6 w0.381: v2(124.09,132.69) 124.09,133.1 122.59,134.61 122.59,143.11 121.7,144 v2(121.7,144.38) 121.7,146.04 v2(125.25,149.59)
  L6 w0.508: v4(296.98,62.72) 296.09,61.83 295.54,61.83 294.01,60.31 292.23,60.31 291.57,60.97 290.25,60.97 v2(289.72,60.44)
  BOTTOM w0.254: R4755.2 157.66,72.76 157.28,72.38 v2(157.28,72.22) 157.64,71.87 R4906.2 ; C5310.1 281.07,66.96 281.69,67.59 281.69,67.95 282.26,68.51 U5301.57 ; C5310.1 280.75,66.96 280.4,66.61 280.4,66.51 280,66.11 R5310.1 R5309.1 R5311.1 ; C5310.1 v2(280.85,67.54) ; U4555.AH14 181.63,89.36 181.93,89.06 v2(182.04,89.06) ; R5423.2 269.78,81.14 269.15,81.77 v2(269.15,81.9) 268.26,81.01 R5416.1 ; v2(167.82,68.36) 168.14,68.05 R4788.2 ; R5318.1 276.64,78.34 v2(276.51,78.47) ; v2(263.85,65.58) 263.86,65.58 263.86,66.03 R5409.1 R5410.1 ; v2(161.82,84.67) 162.03,84.88 R4753.1 ; R4780.2 170.26,69.77 169.4,70.62 R4769.1 ; R4709.1 162.05,85.81 161.85,86.01 v2(161.85,86.34) ; v4(157.06,75.63) 157.11,75.68 R4929.1 ; R118.2 125.09,83.75 124.83,84 ; R5418.1 260.59,75.38 261.44,76.23 261.44,76.56 R4782.2 261.44,76.74 262.54,77.84 v2(263.11,77.84) ; R4729.1 R4880.1 158.04,86.02 R4708.2 R4727.2 158.04,84.17 158.04,83.25 R4765.2 R4912.2 158.04,82.33 R4715.1 R4751.1 R4577.1 ; R5317.2 288.03,79.01 R5316.2 288.25,79.92 288.58,80.25 v5(288.58,82.15) ; CN4125.199 124.2,132.8 v2(124.09,132.69) ; R4825.2 162.55,99.12 v2(162.47,99.2) ; R4730.2 157.33,76.72 156.8,77.25 156.8,78.09 157.51,78.8 157.51,78.95 158.04,79.47 R4577.1 ; R4577.1 157.89,79.49 157.68,79.7 157.19,79.7 156.91,79.98 156.91,79.99 156.72,80.17 v2(156.72,80.2) ; R4735.2 R4859.2 R4752.2 166.36,70.89 166.88,70.37 v2(167.29,70.37) 169.05,70.37 R4769.1 ; U4555.W9 178.49,84.58 v2(177.81,84.58) 177.81,84.35 U4555.V8 ; R4776.2 154.25,88.45 153.55,87.74 Q4759.2 152.15,87.66 151.2,87.66 151.11,87.74 ; R5424.2 269.23,78.43 v2(269.02,78.22) ; R113.2 127.37,85.96 125.21,85.96 ; U4700.5 142.08,95.42 142.4,95.11 142.4,92.82 v1(141.38,91.81) 141.26,91.68 v2(141.26,90.92) ; 271.81,74.93 271.87,74.87 R5419.2 ; 271.81,74.93 v2(271.82,74.93) ; 271.81,74.93 271.88,75 R5421.2 ; R5410.1 264.94,66.22 264.94,65.28 266.14,64.08 R5403.2 ; R5410.1 265.04,66.23 265.44,66.63 265.44,66.71 265.79,67.07 265.87,67.07 265.89,67.09 C5410.1 265.89,67.37 265.59,67.68 265.59,68.06 266.01,68.48 U5401.57 ; R4769.1 169.4,71.61 R4750.2 ; v2(150.7,90.43) 151.01,90.13 151.01,87.85 151.11,87.74 ; R4757.2 153.19,72.76 152.81,73.14 v2(152.81,73.26) ; R4757.2 R4760.2 R4761.2 153.4,74.79 R4924.1 R4705.1 153.4,76.57 R4813.2 R4809.2 R4814.2 R4806.2 R4810.2 152.92,81.24 151.27,81.24 v2(151.04,81.01) ; R4757.2 R4762.2 R4763.2 ; R4787.2 171.01,66.48 170.29,66.48 169.96,66.15 167.8,66.15 v2(167.72,66.08) ; R4798.1 162.24,89.46 162.03,89.25 v2(162.03,88.96) 162.42,88.58 R4820.2 ; R4817.2 162.59,81.16 R4816.1 R4706.1 R4818.1 ; R4817.2 162.59,81.16 162.59,80.33 R4707.1 ; R4817.2 162.22,81.16 v4(161.77,80.71) ; v2(161.96,79.09) 162.11,79.23 R4575.1 ; 151.11,87.74 Q4759.5 149.15,87.74 148.45,87.04 R4783.2 147.82,87.62 Q5314.2 147.23,87.62 146.89,87.95 146.01,87.95 145.68,87.62 Q5314.5 ; U5000.1 111.08,91.7 110.65,92.13 110.65,93.86 111.27,94.49 C5009.1 R5039.1 112.16,94.62 v2(111.77,94.22) ; v2(280.45,80.22) 280.6,80.08 C5313.1 281.08,79.8 280.55,79.27 280.55,78.67 281.06,78.16 U5301.21 ; v2(269.2,65.42) 269.2,65.8 R5407.2 ; U5401.21 264.8,78.06 264.32,78.55 264.32,79.7 C5413.1 264.7,80.07 264.85,79.92 264.85,79.49 264.83,79.46 v2(264.83,79.44) ; R4789.2 R4786.2 174.74,69.66 v2(175.17,70.09) ; U4555.K16 U4555.K14 181.38,80.54 v2(181.46,80.63) ; C503.1 296.75,58.66 v2(297.01,58.41) ; v2(316.52,26.66) 317.28,25.89 R3301.1 ; v4(114.11,120.33) 114.11,120.19 113.68,119.75 CN3000.13 111.29,119.75 106.84,115.3 106.84,114.29 v2(106.81,114.26) ; v2(154.79,84.77) 154.36,85.2 R4913.1 154.26,85.08 153.85,84.67 153.08,84.67 153.02,84.73 Q4752.2 151.85,84.73 151.55,84.43 v2(151.47,84.43) 151.17,84.73 Q4752.5 149.49,84.73 R4828.1
  BOTTOM w0.356: 111.84,115.25 CN3000.22
  BOTTOM w0.381: v2(119.54,91.3) 119.28,91.56 R5044.1 ; v2(201.78,132.4) 203.09,132.4 206.6,128.89 232.72,128.89 234.22,130.39 238.1,130.39 238.78,131.08 245.49,131.08 246.51,130.06 260.64,130.06 261.65,131.08 v2(264.07,131.08) ; v2(121.7,144.38) 121.85,144.54 U3500.10 ; U3500.19 121.85,151.62 121.85,150.58 122.21,150.23 124.62,150.23 v2(125.25,149.59) ; 111.84,115.25 108.61,115.25 107.63,114.26 v2(106.81,114.26) ; v2(177.32,59.8) 177.32,55.61 179.61,53.33 191.75,53.33 192.44,54.01 v2(192.44,54.57) ; R4303.2 117.55,159.94 116.21,161.28 R4301.2 115.52,161.56 114.99,162.09 v2(114.46,162.09) ; CN4100.199 v2(201.2,136.03) ; R5301.2 282.86,63.06 R5303.2 R5305.2 R5307.2 286.63,63.06 287.05,63.49 287.05,65.59 v5(286.72,65.92) ; R7050.1 118.86,90.73 R5044.1 ; R5044.1 R5032.1 R5043.1 ; L3065.1 94.91,90.41 v2(95.29,90.03) ; U3500.24 125.1,152.76 125.64,153.29 C3502.1 125.93,154.37 126.23,154.07 v2(126.23,153.67)
  vias: v5(121.06,85.08) v5(121.95,85.08) v5(122.84,85.08) v5(123.73,85.08) v5(124.62,85.08) v5(288.07,83.17) v5(289.08,83.17)
P3V3S_AVDD33: length 7.4
  TOP w0.356: U3065.1 87.65,89.64 88.17,90.16 88.17,90.66 v1(88.68,91.17) 88.71,91.14 89.8,91.14 90.29,91.63 v2(90.29,92.15)
  TOP w0.381: C3089.1 90.72,92.59 v2(90.29,92.15)
  BOTTOM w0.381: L3067.2 90.3,92.15 v2(90.29,92.15) 90.16,92.29 C3088.1
P3V3S_CAM: length 59.9
  L3 w0.381: v4(238.9,46.47) 238.84,46.53 237.82,46.53 236.87,45.58 199.04,45.58 v4(198.79,45.83)
  L6 w0.381: v4(242.33,46.67) 241.64,47.36 239.66,47.36 238.9,46.59 v4(238.9,46.47)
  BOTTOM w0.254: MIC600.1 195.46,45.07 195.97,44.56 ; C653.1 241.55,47.61 R641.2 243.05,47.55 243.9,46.7 C652.1 244.09,46.4 244.93,46.4 245.41,45.93 MIC601.1
  BOTTOM w0.381: C604.1 L603.2 237.61,47 238.14,46.47 v4(238.9,46.47) ; C653.1 242.24,46.67 v4(242.33,46.67) ; 195.97,44.56 196.03,44.5 196.44,44.5 197.14,43.8 C650.1 197.58,44.64 C651.1 197.41,45.09 197.9,45.58 198.53,45.58 v4(198.79,45.83)
P3V3S_DP: length 4.8
  TOP w0.381: R3305.1 317.58,40.58 318.29,39.86 319.35,39.86 U3300.1 ; C3308.1 316.94,23.93
  vias: v1(322.36,40.63)
P3V3S_DVDD33: length 45.8
  TOP w0.254: U3065.21 82.63,83.6 82.2,83.17 C3093.1
  TOP w0.381: v2(81.92,83.88) 81.92,83.91 81.36,83.35 C3093.1 ; R3078.2 76.98,86.74 76.44,87.28 R3093.2 ; R3078.2 77.14,87.66 R3064.1 ; R3078.2 R3067.2 77.14,85.57 77.5,85.2 78.65,85.2 v2(79.41,85.96)
  L3 w0.381: v2(88.81,84.36) 88.68,84.49 87.84,84.49 86.59,83.24 82.57,83.24 v2(81.92,83.88)
  L5 w0.381: v2(81.92,83.88) 80.35,85.46 79.92,85.46 v2(79.41,85.96)
  BOTTOM w0.381: C3066.1 C3065.1 93.71,90.87 L3065.2 93.71,90.07 94.31,89.47 R3077.1 95.16,89.14 96.04,88.25 v1(96.04,87.67) 96.04,86.81 93.5,84.27 93.5,82.65 92.88,82.03 89.88,82.03 89.48,82.42 L3066.2 89.48,83.93 89.06,84.36 v2(88.81,84.36) ; C3066.1 L3067.1 90.47,91.3 89.14,89.97 R3074.1 88.21,89.38 R3063.1 ; C3066.1 91.89,90.66 R3075.1
P3V3S_ISCT: length 330.5
  TOP w0.254: CN200.7 102.55,91.52 v2(102.78,91.74) ; v2(109.76,93.71) 110.52,93.71 112.3,95.49 112.3,111.75 115.37,114.82 115.37,116.65 114.89,117.13 113.52,117.13 112.17,118.48 v2(111.41,118.48) ; v2(110.52,134.48) 110.52,130.8 111.91,129.41 111.91,125.83 v2(111.28,125.21) ; R127.2 281.08,118.22 281.59,118.73 283.24,118.73 ; v2(307.67,143.45) 307.67,143.45 R130.1 307.67,144.13 R126.2 ; 283.24,118.73 284,119.49 v1(284,119.87) v2(285.15,121.02) ; 283.24,118.73 Q114.2 ; v2(310.55,149.97) 310.72,150.14 R115.2
  L3 w0.254: v2(230.41,145.91) 229.39,146.92 197.39,146.92 191.14,153.17 181.38,153.17 178.56,150.35 165.88,150.35 165.81,150.28 119.99,150.28 112.17,142.46 112.17,136.13 v2(110.52,134.48) ; v2(102.78,91.74) 105.89,91.74 107.86,93.71 v2(109.76,93.71) ; v2(310.55,149.97) 311.11,149.97 311.94,149.13 311.94,147.79 307.67,143.51 v2(307.67,143.45) 308.94,143.45 312.33,140.07 312.33,134.48 308.56,130.71 300.43,130.71 296.78,127.06 293.27,127.06 288.97,122.77 286.9,122.77 v2(285.15,121.02)
  L5 w0.254: v2(111.28,125.21) 110.52,125.21 109.85,124.53 109.85,118.9 110.27,118.48 v2(111.41,118.48)
  L6 w0.254: v2(285.15,121.02) 285.15,123.81 283.37,125.59 283.37,129.01 283.82,129.46 283.82,130.68 283.17,131.32 281.91,131.32 278.34,134.9 277.81,135.43 276.48,136.76 276.48,137.95 272.58,141.85 272.25,142.18 264.71,142.18 263.8,143.09 236.62,143.09 235.96,143.75 230.79,143.75 230.41,144.13 v2(230.41,145.91)
P3V3S_ISCT_SM: length 73.6
  TOP w0.254: R9038.2 R9033.2 74.2,140.83 75.34,139.69 80.55,139.69 81.57,138.67 81.57,120.51 v2(81.44,120.38) ; R9034.2 76.02,122.58 v3(75.47,122.03)
  TOP w0.356: v2(74.96,106.79) 74.71,106.79 74.5,107 CN9000.7
  BOTTOM w0.381: v3(75.47,122.03) 77.12,120.38 v2(81.44,120.38) 88.55,120.38 90.84,118.1 90.84,111.24 87.41,107.81 75.98,107.81 v2(74.96,106.79)
P3V3S_LCDVDD: length 21.1
  TOP w0.381: R3001.2 103.47,112.87 103.47,110.79 104.18,110.08 U3000.1
  TOP w0.508: U3000.1 105.28,109.94 C3003.1 105.28,107.94 v3(105.41,107.81)
  BOTTOM w0.305: CN3000.23 111.37,114.75 111.18,114.56 111.18,114.61 111.54,114.25 CN3000.24
  BOTTOM w0.508: v3(105.41,107.81) 106.14,108.54 106.14,111.76 108.95,114.56 111.18,114.56
P3V3S_SM: length 80.1
  TOP w0.356: CN9000.23 82.5,108.74 82.71,108.95 83,108.66 CN9000.24
  TOP w0.381: R9036.1 R9035.1 76.49,125.72 v2(76.61,125.84) ; R9040.2 v2(72.8,142.61) ; R9046.2 72.04,156.7 74.07,154.67 77.5,154.67 78.52,153.66 82.96,149.21 v2(82.96,140.96) v2(82.96,125.84) 82.96,113.14 83.09,113.02 v1(83.09,109.71) 83.09,109.33 82.71,108.95
  BOTTOM w0.381: v2(82.96,125.84) v2(76.61,125.84) ; v2(72.8,142.61) 72.8,140.07 73.57,139.3 81.31,139.3 v2(82.96,140.96)
P3V3S_SM_AB: length 31.6
  TOP w0.381: U9000.10 75.06,111.21 78.01,114.16 C9005.1 79.23,114.37 79.79,114.92 80.93,114.92 ; 80.93,114.92 81.31,114.54 v1(81.31,113.9) 81.31,112.37 80.69,111.75 79.53,111.75 79.23,111.45 C9001.1 C9000.1 77.85,110.22 U9000.14 ; 80.93,114.92 80.94,114.92 81.44,115.42 81.44,117.84 79.58,119.7 C9010.1 ; U9000.18 75.72,117.28 C9010.1 ; R9002.1 74.03,120.55 74.88,119.7 C9010.1
P3V3S_SSD: length 15.9
  TOP w0.254: C1956.1 v1(292.01,90.54)
  TOP w0.381: R1956.2 293.91,91.55 v5(293.66,91.81)
  L6 w0.508: 293.38,99.55 v4(293.68,99.55)
  L6 w0.762: v5(293.66,90.92) v5(293.66,91.81) 294.16,92.31 294.16,95.49 293.02,96.63 293.02,99.2 293.38,99.55
  BOTTOM w0.356: CN1951.2 295.26,84.3 ; CN1951.4 294.82,84.8
  vias: v5(293.66,90.03)
P3V3S_VCC_READER: length 35.6
  TOP w0.254: U800.12 290.81,71.56 290.56,71.31 290.43,71.31 289.08,69.96 288.45,69.96 287.64,69.15 285.99,69.15 284.89,68.06 284.89,67.3 283.85,66.25 283.85,64.81 v1(284.13,64.53) 284.39,64.27 v2(285.48,64.27)
  TOP w0.381: v2(292.74,62.49) 292.74,63.21 293.02,63.49 294.39,63.49 295.48,64.58 295.48,66.41 296.5,67.42 C808.1
  L5 w0.254: v2(285.48,64.27) 288.96,64.27 291.14,62.09 292.34,62.09 v2(292.74,62.49)
  BOTTOM w0.381: v2(292.74,62.49) 294.14,62.49 294.42,62.22 C810.1 294.68,62.47 295.05,62.85 295.31,62.85 296.53,64.07 CN820.4
P3VA_D_L: length 54.9
  TOP w0.254: U2550.63 267.92,56.55 267.77,56.41 267.77,55.8 268.08,55.49 268.08,54.65 267.93,54.49 C2554.1 ; 279.31,59.8 v2(279.31,59.5) ; U2550.52 267.44,62.05 v2(267,62.5) ; v2(277.27,55.38) 277.19,55.3 U2550.16
  TOP w0.356: 276.21,65.21 U2550.34
  TOP w0.381: v2(267,62.5) 267,62.48 266.73,62.22 C2556.1 ; C2555.1 277.99,66.36 C2552.1 ; C2555.1 276.26,66.36 v2(276.05,66.15) ; C2555.1 277.02,66.03 276.21,65.21 ; C2554.1 267.67,53.24 267.24,52.82 267.24,51.92 267.65,51.5 269.74,51.5 270.18,51.94 v2(270.18,52.68)
  TOP w0.508: 279.31,59.8 279.31,60.18 279.68,60.56 L2550.2 279.68,62.09 281.18,63.59 281.18,64.25 280.19,65.24 280.19,65.64 279.52,66.31 C2552.1
  L5 w0.254: v2(277.27,55.38) 277.27,56.6 278.16,57.49 278.16,58.35 v2(279.31,59.5)
  BOTTOM w0.254: v2(267,62.5) 267,62.22 267.28,61.94 268.87,61.94 271.56,64.62 271.56,65.89 272.48,66.81 v1(274.23,66.81) 275.39,66.81 v2(276.05,66.15) ; v2(270.18,52.68) 270.93,51.93 276.13,51.93 277.06,52.86 C2553.1 277.06,55.17 v2(277.27,55.38)
P5V0A: length 274.3
  TOP w0.254: v3(239.97,108.76) 239.94,108.79 C7400.1 240.23,109.54 240.57,109.21 240.57,108.28 240.36,108.06 U7400.8 ; v2(250.17,113.91) 250.17,113.56 U2950.5 246.82,112.41 245.9,111.49 v2(245.02,111.49) ; R4114.1 178.21,148.32 179.48,149.59 v2(179.48,149.72)
  TOP w0.381: C7592.1 316.59,22.51 v2(316.52,22.59) ; v5(308.01,85.58) 308.26,85.84 C2412.1 ; v5(309.91,115.56) 309.91,115.89 R7355.2 ; C7614.1 308.39,115.17 ; v2(316.39,73.39) 316.22,73.56 C7613.1
  L3 w0.254: v5(309.91,114.67) 304.32,114.67 301.66,117.33 299.88,117.33 297.72,115.17 v2(297.72,114.79) ; v2(229.9,91.33) 229.9,92.06 230.28,92.44 230.28,103.11 236.63,109.46 239.55,109.46 239.97,109.05 v3(239.97,108.76) 241.53,108.76 244.27,111.51 245,111.51 v2(245.02,111.49) ; v2(250.17,113.91) 247.17,116.91 247.17,125.33 256.95,135.11 256.95,141.46 255.33,143.09 243.9,143.09 243.24,143.75 217.58,143.75 217.01,144.32 217.01,144.57 216.57,145.02 205.77,145.02 204.63,146.16 196.9,146.16 195.88,147.18 189.01,147.18 185.2,150.99 180.75,150.99 v2(179.48,149.72)
  L5 w0.254: v3(234.86,64.98) 235.41,65.52 238.49,65.52 239.48,66.51 239.48,70.55 v2(238.28,71.74)
  L6 w0.254: v2(234.47,90.41) 230.54,90.41 229.9,91.04 v2(229.9,91.33)
  BOTTOM w0.254: R6665.2 228.12,89.55 229.91,91.33 v2(229.9,91.33) ; U6610.2 235.22,66.2 235.04,66.02 235.04,65.53 235.41,65.16 235.41,64.38 C6616.1 235.15,64.25 234.86,64.54 v3(234.86,64.98) ; v2(250.17,113.91) 250.33,114.07 250.73,114.47 255.5,114.47 255.99,113.98 262.17,113.98 262.29,113.85 263.18,112.96 265.78,112.96 266.03,112.71 266.03,112.71 266.24,112.51 266.3,112.51 266.3,112.51 269.53,112.51 270.24,111.79 286.97,111.79 288.32,113.14 295.94,113.14 297.59,114.79 v2(297.72,114.79) ; v2(234.47,90.41) 234.47,90.79 234.73,91.04 235.36,91.04 237.01,89.39 237.01,81.65 237.9,80.76 237.9,79.81 237.76,79.66 237.76,77.09 238.28,76.57 v2(238.28,71.74)
  BOTTOM w0.381: C2413.1 323.87,38.97 323.63,38.97 323.25,38.59 C2414.1
  vias: v2(324.39,40.42) v2(325.03,40.42) v5(306.86,85.33) v5(310.8,115.56) v5(310.8,114.67) v5(325.79,39.99)
P5V0A_USB2: length 2.6
  TOP w0.381: v2(316.52,64.49) 316.48,64.46 C2402.1
  vias: v1(314.36,71.61) v5(307.37,80.38) v5(308.26,80.38) v5(316.39,70.98) v5(316.39,69.96)
P5V0A_USB3: length 0.6
  BOTTOM w0.381: C2408.1 315.75,38.34
  vias: v1(314.87,38.47)
P5V0A_USB_CHARGE: length 0.8
  BOTTOM w0.254: v3(40.5,52.08) 40.68,52.26 C2503.1
  vias: v5(38.01,82.28) v5(38.01,81.14) v5(38.01,80) v5(38.39,62.98) v5(38.39,61.83) v5(39.02,81.77) v5(39.66,62.98) v5(39.66,61.83)
P5V0DS: length 110
  TOP w0.254: 113.55,90.84 111.84,90.84 111.06,91.63 v2(110.4,91.63) ; 113.55,90.84 CN200.29 ; 113.55,90.84 113.93,90.84 114.05,90.72 CN200.30
  TOP w0.381: v2(283.37,135.37) 283.92,135.37 D7600.2 ; C7623.1 v2(101.55,104.8) ; R7350.1 208.44,147.73 v2(208.44,148.19) ; v2(297.59,134.1) 297.78,134.28 U6903.5 ; v5(47.4,82.92) 47.4,83.3 48.8,84.69 49.18,84.69 49.82,85.33 R4412.1 ; v5(186.17,161.02) 186.17,161.53 C7625.1 ; C7617.1 57.15,80.76 v2(57.1,80.8)
  L3 w0.381: v5(286.54,98.03) 285.53,97.01 285.53,89.63 283.33,87.43 283.33,86.35 280.17,83.2 271.91,83.2 269.78,85.33 264.34,85.33 262.82,83.81 256.44,83.81 255.18,82.54 255.18,82.54 254.79,82.15 v5(252.76,82.15) ; v3(110.17,99.65) 109.63,99.65 109.25,99.27 109.25,95.02 110.4,93.88 v2(110.4,91.63)
  L5 w0.381: v5(286.54,98.03) 288.91,100.39 288.91,105.15 290.4,106.64 290.99,106.64 292.39,105.24 295.08,105.24 297.45,107.62 297.45,107.82 299.04,109.4 299.04,113.86 v5(298.99,113.9) 298.93,113.85
  BOTTOM w0.356: C2514.1 42.88,78.14 43.23,78.49 U2511.5
  BOTTOM w0.381: v5(186.17,161.02) 186.17,161.02 186.17,159.88 D7602.2 ; C2513.1 46.47,82.58 v5(46.13,82.92) ; D7601.2 v2(112.94,162.04) ; C2514.1 43.69,77.84 44.83,78.98 46.94,78.98 47.32,79.36 R2515.2 49.59,79.61 v2(50.07,80.1)
  vias: v5(44.86,82.92) v5(226.6,160.89) v5(227.62,160.89) v5(228.63,160.89) v5(229.65,160.89) v5(230.66,160.89) v5(298.99,115.05) v5(300.13,116.19) v5(300.13,115.05) v5(300.13,113.9) v5(301.28,116.19) v5(301.28,115.05) v5(301.28,113.9)
P5V0DS_SM: length 44.5
  TOP w0.356: CN9000.30 86,108.66 85.71,108.95 85.5,108.74 CN9000.29
  TOP w0.381: 85.71,108.95 85.83,109.08 85.83,137.98 v1(90.2,142.35) 91.22,143.37 91.22,146.16 90.12,147.26 R9049.1
P5V0S: length 420.6
  TOP w0.254: v2(291.69,134.24) 292.26,133.68 R6029.1 ; v2(290.61,97.14) R351.2 291.71,96.42 292.1,96.03 Q300.3 ; v2(247.5,103.87) v1(247.5,104.76) 247.5,105.42 R7405.1 ; R4899.2 151.8,109.84 149,107.05 144.37,107.05 v2(143.54,106.22) ; v2(297.34,65.17) 297.39,65.22 C515.1 298.36,64.88 298.99,64.25 299.68,64.25 300,63.92 U501.46 ; R7100.1 v1(300.72,108.32) ; v2(288.07,112.13) 288.07,111.87 285.4,109.21 285.4,105.52 284.74,104.86 284.74,103.36 v2(284.39,103.01) ; v2(303.94,65.81) 303.9,65.85 C509.1 302.93,64.76 302,63.84 U501.41
  TOP w0.356: CN200.28 113.05,88.8 112.88,88.63 112.55,88.63 CN200.27
  TOP w0.381: C2256.1 C2250.1 110.57,121.48 C2251.1 110.4,120.49 v2(110.38,120.47) ; C7607.1 170.44,54.25 v2(170.24,54.46) ; v2(173.09,54.22) 173.09,54.65 173.09,54.66 C7494.2 ; v2(237.75,64.97) 237.75,58.79 ; 112.55,88.63 v2(111,88.63) ; 300.21,72.33 C532.1 ; 302.87,110.17 C7589.1
  TOP w0.508: v2(111,88.63) 110.14,87.77 v2(110.14,81.77) ; v5(48.7,83.22) 50.12,83.22 51.76,84.86 51.76,86.51 50.91,87.36 45.12,87.36 43.82,86.07 41.76,86.07 41.13,85.43 41.13,83.04 40.29,82.2 40.29,77.84 39.78,77.33 v2(39.4,77.33)
  TOP w1.016: v5(239.55,52.23) 241.64,52.23 242.35,52.94 242.35,57.9 241.46,58.79 232.82,58.79 230.16,56.12 v5(230.16,52.18)
  L3 w0.508: v2(110.65,153.66) 105.49,148.5 105.49,121.06 v2(106.05,120.51)
  L5 w0.254: 301.82,110.39 301.82,110.62 302.95,111.75 302.95,117.75 302.67,118.04 302.67,122.62 298.86,126.43 298.86,130.66 296.94,132.59 293.35,132.59 v2(291.69,134.24)
  L5 w0.508: v2(111,88.63) 109.2,90.43 108.34,90.43 106.79,91.98 106.79,95.11 107.63,95.95 107.63,109.9 106.05,111.48 v2(106.05,120.51)
  L5 w0.762: v5(98.84,81.8) 87.96,81.8 86.72,83.04 80.5,83.04 77.67,85.87 51.35,85.87 v5(48.7,83.22)
  L6 w0.254: v2(143.54,106.22) 142.94,106.82 127.21,106.82 126.01,108.01 117.84,108.01 114.21,104.38 113.01,104.38 112.68,104.71 112.68,114.33 112.99,114.64 112.99,120.6 112.45,121.14 111.05,121.14 v2(110.38,120.47) ; v2(241.71,81.87) 242.04,81.87 242.6,81.32 242.6,73.68 240.58,71.65 240.58,65.63 239.39,64.45 238.18,64.45 237.75,64.88 v2(237.75,64.97)
  BOTTOM w0.254: v2(288.7,58.91) 289.55,58.91 R803.1 ; v2(290.61,97.14) 290.74,97.14 292.26,98.66 292.26,99.81 291.75,100.32 285.27,100.32 284.39,101.2 v2(284.39,103.01) ; v2(247.5,103.87) 247.5,101.53 246.54,100.57 246.54,90.45 242.81,86.72 242.81,82.97 v2(241.71,81.87) ; v2(288.07,112.13) 288.45,112.51 296.7,112.51 297.34,111.87 300.13,111.87 300.64,111.36 v5(300.64,110.6) ; U3051.3 38.19,67.67 C3357.1 38.64,67.55 38.84,67.75 U3051.2
  BOTTOM w0.356: CN3000.10 112.17,121.25
  BOTTOM w0.381: v2(106.05,120.51) 107.07,119.49 109.4,119.49 v2(110.38,120.47) 111.15,121.25 112.17,121.25 ; C7608.1 110.75,88.89 v2(111,88.63) ; 39.28,67.21 C3357.1
  BOTTOM w0.508: CN4300.1 110.68,153.62 v2(110.65,153.66) ; 39.28,67.21 40.34,67.21 41.05,67.93 41.05,75.68 v2(39.4,77.33)
  vias: v2(300.26,74.36) v2(300.84,74.36) v2(301.43,74.36) v5(99.98,81.77) v5(101,81.77) v5(300.64,109.59) v5(301.78,109.59)
P5V0S_AUDIO_AVDD: length 50.7
  TOP w0.254: R603.1 293.45,52.48 v2(293.4,52.44) ; C507.1 305.34,65.23 304.57,64.47 304.57,64.42 304.57,64.3 304.56,64.29 304.56,64.27 304.52,64.24 304.52,64.22 304.02,63.71 303.43,63.71 303.2,63.49 U501.38
  TOP w0.279: C511.1 305.87,57.39 305.34,57.92 305.34,58.41 305.09,58.66 U501.27
  TOP w0.356: U551.12 314.22,60.32 314.41,60.13 314.41,59.5 313.82,58.91 313.82,57.98 C566.1 ; C563.1 310.69,64.22 U551.20 ; U550.20 304.89,72.77 C551.1 ; C555.1 308.63,76.64 U550.12
  TOP w0.381: C550.1 305.54,71.87 305.59,71.82 ; C511.1 305.93,57.16 306.14,56.96 C512.1 305.9,56.37 305.39,56.88 v2(305.34,56.88) ; v2(306.36,65.48) 306.22,65.34 C507.1 ; R559.2 R558.2 309.23,57.85 v2(309.49,58.11) ; C563.1 C562.1 v2(309.91,63.61) ; v2(310.95,54.87) 310.96,54.87 311.47,55.38 311.47,55.5 311.84,55.87 312.2,55.87 312.5,56.16 C567.1 312.5,56.5 313.23,57.24 C566.1 ; v2(311.26,74.43) 311.66,74.43 312.11,73.98 R551.2 R550.2 ; v2(309.71,76.19) 309.71,76.72 C554.1 C555.1 ; C529.1 302.42,69.71
  L3 w0.508: v2(293.4,52.44) 293.4,52.56
  L3 w0.762: 293.4,52.56 293.4,53.07 294.04,53.71 302.17,53.71 v2(305.34,56.88)
  BOTTOM w0.381: R618.2 294.61,54.15 v1(294.62,54.14) 295,53.76 295,52.69 294.62,52.31 293.53,52.31 v2(293.4,52.44) 293.4,52.51 292.95,52.96 C615.1 292.62,53.14 292.47,52.98 U610.8
  vias: v2(303.51,68.74) v2(303.92,68.26) v2(304.3,68.74) v2(306.1,71.61)
P5V0S_CRTVDD: length 11.8
  BOTTOM w0.381: R3059.1 37.24,67.21 37.16,67.3 ; 36.92,76.01 R3060.1 ; C3058.1 38.71,76.01
  BOTTOM w0.508: 36.23,72 CN3050.9 ; 36.23,72 36.23,74.28 36.35,74.41 ; 36.23,72 36.23,68.06 36.99,67.3 37.16,67.3
  vias: v1(39.78,75.3)
P5V0S_HDD: length 1.8
  BOTTOM w0.381: C1701.1 v1(97.57,85.46) ; C1700.1 98.58,86.22
P5V0S_KBL: length 25.1
  TOP w0.356: v1(301.31,87.2) 301.88,87.2 302.1,86.98 CN301.1 ; v1(301.31,87.2) 301.31,87.03 301.6,86.74 CN301.2 ; v1(301.31,87.2) 301.3,87.2 299.1,87.2 ; 299.1,87.2 299.1,88.24 v2(299.06,88.27) ; 299.1,87.2 298.94,87.2 298.6,86.86 CN301.8 ; 299.1,87.2 CN301.7
  TOP w0.381: Q300.2 293.28,94.31 v2(293.28,94.98)
  L5 w0.356: v2(293.28,94.98) 292.51,94.22 292.51,89.01 293.66,87.87 298.66,87.87 v2(299.06,88.27)
P5V0S_SM: length 76.8
  TOP w0.356: CN9000.28 85,108.66 84.71,108.95 84.5,108.74 CN9000.27
  TOP w0.381: U9000.4 71.16,111.49 70.27,112.38 C9006.1 67.39,111.79 v2(67.22,111.62) ; R9048.2 88.3,147.05 89.06,146.29 89.57,146.29 90.05,145.81 90.05,143.85 v1(87.79,141.59) 84.71,138.51 v2(84.71,114.03) 84.71,108.95 ; v2(78.39,113.27) C9003.1 C9002.1 79.11,112.25 78.01,112.25 77.01,111.25 U9000.13
  BOTTOM w0.381: v2(67.22,111.62) 67.72,111.62 69.25,110.09 76.74,110.09 78.39,111.75 v2(78.39,113.27) 78.81,113.69 84.37,113.69 v2(84.71,114.03)
P15V0A: length 215.6
  TOP w0.254: v4(219.74,151.12) 218.85,150.23 205.98,150.23 R7354.2
  L3 w0.254: v2(217.58,155.94) 219.74,153.78 v4(219.74,151.12)
  L6 w0.254: v2(217.58,155.94) 217.58,157.7 215.15,160.13 189.64,160.13 184.31,154.8 174.78,154.8 169.7,159.88 169.7,159.89 169.33,160.26 169.32,160.26 167.8,161.78 116.93,161.78 108.67,153.52 108.67,131.5 109.78,130.39 109.78,125.54 109.13,124.89 109.13,104.54 112.46,101.2 v2(113.82,101.2)
  BOTTOM w0.254: R7101.1 R7151.1 121.24,89.65 121.22,89.65 121.19,89.67 121.19,90.82 120.86,91.15 120.86,91.15 120.8,91.21 120.39,91.21 119.41,92.19 119.41,93.83 v1(118.02,95.23) 113.82,99.42 v2(113.82,101.2) ; v4(219.74,151.12) 220.43,150.43 D6151.1 221.34,150.02 C6159.1
PVBAT: length 116.4
  TOP w0.254: v2(288.22,120.64) 288.73,121.14 290.94,121.14 R6027.1
  TOP w0.381: C7467.2 256.53,145.61 256.57,145.65 ; C7601.1 270.33,116.14 ; C7468.2 143.08,159.79 ; C7456.2 117.69,125.46 ; 244.89,83.42 245.1,83.42 245.14,83.47 C7594.1 ; C7455.2 117.3,126.92 ; v5(211.69,157.39) 211.4,157.1 R7114.2 ; 124.56,113.78 C7603.1 ; C7641.1 251.56,105.35 251.72,105.19
  TOP w0.508: v1(119.29,104.13) v5(119.29,103.24)
  TOP w0.635: 255.81,146.04 255.56,145.78 D7607.2
  TOP w2.54: 259.8,115.17 259.8,114.52 257.49,112.21 257.07,112.21 254.03,109.17 254.03,107.5 251.72,105.19 251.72,102.83 250.48,101.59 250.48,94.53 248.07,92.12 247.49,92.12 244.63,89.27 244.63,88.89
  L5 w0.508: v5(240.35,78.85) 240.16,78.85 237.12,81.9 233,81.9 230.52,84.38 228.07,84.38 226.33,82.65 226.33,78.94 225.79,78.39 225.79,78.02 225.78,78.01 225.78,77.97 225.39,77.58 v4(225.06,77.58)
  L6 w0.254: v2(278.16,136.64) 278.16,135.81 282.3,131.68 283.34,131.68 284.21,130.81 284.21,129.35 283.8,128.94 283.8,125.79 285.78,123.81 285.78,121.78 286.92,120.64 v2(288.22,120.64)
  BOTTOM w0.305: CN3000.1 112.98,125.75 113.82,125.75 ; 113.95,124.75 112.98,124.75 CN3000.3 ; 113.95,125.25 112.98,125.25 CN3000.2
  BOTTOM w0.356: 113.82,125.75 114.36,125.75 115.85,127.24 v2(116.24,127.24) ; 113.95,124.75 117.85,124.75 118.19,124.75 v2(118.51,125.06) ; 113.95,125.25 117.47,125.25 117.8,125.25 v2(118.02,125.46)
  BOTTOM w0.381: v4(225.06,77.58) 225.57,77.07 R6657.1 ; C7599.1 248.4,147.01 v5(248.44,147.05) ; v5(240.35,78.85) 240.31,78.9 C7495.2 239.55,78.9 C7642.1 ; C7602.1 210.05,157.47 v5(210.14,157.37) ; C7473.2 119.54,100.57 ; 249.54,148.64 C7491.2 ; 145.75,159.71 C7595.1 ; C7490.2 212.84,157.38 ; C7472.2 118.65,100.19
  BOTTOM w0.635: D7608.2 v2(210.09,158.86) ; D7606.2 v2(146.46,157.08)
  vias: v1(263.43,145.91) v5(119.29,101.97) v5(120.56,103.24) v5(120.56,101.97) v5(146.72,158.74) v5(147.86,158.74) v5(241.27,78.85) v5(249.46,147.05) v5(268.38,118.48) v5(268.38,117.33) v5(269.27,117.97) v5(269.27,116.83)
PVBAT_CHG: length 5.3
  TOP w0.254: v5(272.32,117.97) 272.32,118.83 v1(272.33,118.83)
  TOP w0.381: C7457.2 273.08,118.48 ; C7458.2 273.08,117.59
  BOTTOM w0.254: v5(272.32,117.97) 272.42,118.07 C6010.1
  BOTTOM w0.381: C7650.1 274.71,115.17 274.2,115.68 273.46,115.68
PVBAT_CPU: length 0.4
  BOTTOM w0.381: 238.71,70.02 C7643.1
  vias: v1(241.08,70.98)
PVCCIO_OUT: length 5.2
  BOTTOM w0.254: R7012.2 232.32,87.9 232.09,88.12 v1(231.82,88.12) 231.68,88.12 231.43,87.87 R6640.1 231.22,87.28 230.36,86.43 C6641.1 230.23,86.43 229.37,87.28 R6641.1
PVCCIO_OUT_R: length 15.5
  TOP w0.254: R4568.1 v1(216.31,71.81) 213.59,71.81 212.94,71.16 v4(212.94,70.91)
  BOTTOM w0.254: v4(212.94,70.91) 212.21,71.63 211.26,71.63 209.44,73.45 U4555.A59
VCC1_POR#_3: length 191.2
  TOP w0.102: R325.1 270.2,114.33 R342.1 271.28,113.25 v1(271.28,112.68) 271.28,112.68 U300.77 271.28,108.54 271.56,108.27 271.56,105.65 268.64,102.73 268.64,101.22 267.86,100.44 v2(267.24,100.44)
  L5 w0.102: v2(267.24,100.44) 266.35,100.44 265.72,99.81 265.72,91.81 266.35,91.17 266.35,86.9 267.6,85.66 267.6,80.93 268.51,80.02 268.51,78.98 267.77,78.24 267.44,78.24 265.54,76.34 265.54,70.22 263.85,68.53 263.64,68.53 263.64,68.53 263.34,68.53 263.32,68.51 263.31,68.51 261.89,67.09 260.41,67.09 259.64,66.32 259.43,66.11 258.13,66.11 253.73,61.71 251.23,61.71 250.58,61.07 250.5,60.98 229.42,60.98 228.99,60.55 228.69,60.55 222.05,60.55 220.89,59.4 198.36,59.4 197.45,60.3 187.34,60.3 186.08,61.57 175.81,61.57 174.98,62.39 174.98,63.27 173.68,64.58 172.64,64.58 171.35,65.87 168.71,65.87 167.85,66.74 165.13,66.74 164.26,65.86 142.69,65.86 139.29,69.26 v2(136.9,69.26)
  BOTTOM w0.102: CN375.16 136.56,70.3 136.9,69.96 v2(136.9,69.26)
VCCIOA_OUT: length 7.2
  BOTTOM w0.178: U4555.E20 184.71,76.5 185.08,76.13 185.45,76.13 185.87,75.71 185.87,75.51 186.15,75.23 186.15,75.02 186.51,74.67 186.51,74.38 186.34,74.22 186.34,73.85
  BOTTOM w0.254: 186.34,73.85 186.34,73.14 187.1,72.38 v1(187.1,71.61) 187.1,71.15 R4544.1
VCCSENSE: length 22.4
  TOP w0.076: v2(212.87,76.21) 212.29,76.21 v1(211.5,75.42) 211.49,75.41 R4521.2
  L6 w0.102: v2(212.87,76.21) 212.66,76.43 212.66,77.84 213.32,78.5 222.76,78.5 225.43,81.16 227.02,81.16 v2(227.48,81.63)
  BOTTOM w0.102: v2(227.48,81.63) 227.5,81.65 U6600.24 ; U4555.E63 212.55,76.53 v2(212.87,76.21)
VCCST_PWRGD: length 50.3
  TOP w0.102: v2(241.31,86.8) 240.98,86.8 240.74,86.56 R4923.2 240.74,86.47 R4926.1 240.23,85.08 240.06,85.08 239.67,84.68 Q4926.6
  L3 w0.102: v2(241.31,86.8) 241.17,86.94 238.27,86.94 235.97,84.64 235.35,84.64 234.85,84.15 234.01,84.15 233.89,84.27 231.97,84.27 230.87,83.17 228.89,83.17 228.02,82.31 228.02,80.76 226.8,79.54 224.94,79.54 224.82,79.42 223.1,79.42 220.61,76.92 v3(220.61,76.19)
  BOTTOM w0.076: 209.28,73.04 209.11,73.21 209.11,74.2 209.44,74.53 U4555.B59
  BOTTOM w0.254: v3(220.61,76.19) 220.61,71.36 218.95,69.71 211.84,69.71 209.28,72.27 209.28,73.04
VCCST_PWRGD_XDP: length 2.5
  TOP w0.102: R4926.2 239.83,85.52 CN4920.39
VSSSENSE: length 24
  TOP w0.076: v2(213.52,76.21) 213.07,75.76 212.47,75.76 212,75.28 212,74.03 212.29,73.73 R4522.1 212.5,72.92 v1(212.49,72.9)
  L6 w0.102: v2(227.49,81.02) 227.23,80.76 225.53,80.76 222.92,78.14 216.06,78.14 214.12,76.21 v2(213.52,76.21)
  BOTTOM w0.102: U6600.23 227.72,81.25 v2(227.49,81.02) ; U4555.E62 211.82,76.87 212.56,76.87 212.81,76.63 213.1,76.63 v2(213.52,76.21)
8051_RX_CAPS_LED#: length 183.5
  TOP w0.102: R324.1 259.42,102.18 259.58,102.34 260.55,102.34 v2(260.71,102.18) 260.76,102.13 U300.114 ; U302.3 263.06,85.47 262.9,85.3 262.13,85.3 v2(261.53,84.69) 260.59,84.69 R360.1
  L5 w0.102: v2(260.71,102.18) 261.78,101.11 261.78,98.79 263.4,97.17 263.4,93.13 261.65,91.37 261.65,86.73 261.93,86.45 261.93,85.1 v2(261.53,84.69) 261.53,84.06 262.69,82.89 262.69,80.05 261.67,79.02 261.67,78.65 261.67,75.59 260.59,74.51 260.59,73.59 258.53,71.54 254.13,71.54 252.1,69.5 248.74,69.5 247.66,68.42 247.66,67.59 246,65.93 245.39,65.93 244.62,65.16 241.86,65.16 240.98,66.04 240.98,71.62 239.49,73.11 234.13,73.11 232.64,71.61 225.77,71.61 222.87,68.71 222.7,68.71 213.75,68.71 212.69,67.65 203.51,67.65 202.92,68.24 198.65,68.24 197.82,69.07 191.83,69.07 191,68.24 184.86,68.24 184.59,67.98 183.28,67.98 181.46,69.8 181.46,70.76 181.13,71.09 179.89,71.09 178.12,69.33 176.54,69.33 176.3,69.1 174.33,69.1 173.59,69.84 168.01,69.84 167.51,69.33 164.83,69.33 163.33,67.84 161.64,67.84 160.75,68.73 148.72,68.73 147.97,69.48 145.2,69.48 143.62,71.06 137.05,71.06 v3(136.94,71.18)
  BOTTOM w0.102: v3(136.94,71.18) 136.82,71.3 CN375.14
8051_TX_LED_PWRSTBY#: length 179.3
  TOP w0.102: v2(261.53,85.33) 261.51,85.35 261.76,85.6 U302.1 261.38,86.92 261.38,89.38 R361.1 ; U300.115 v3(259.99,101.73) 259.56,101.29 R322.1
  L5 w0.102: v2(143.8,72.86) 143.8,71.93 145.97,69.76 148.1,69.76 148.88,68.98 164.18,68.98 164.75,69.56 167.34,69.56 167.82,70.04 173.67,70.04 174.33,69.39 176.24,69.39 176.41,69.56 178.04,69.56 179.77,71.28 181.21,71.28 181.65,70.84 181.65,69.89 181.99,69.55 182,69.55 183.29,68.26 184.54,68.26 184.76,68.48 190.79,68.48 191.76,69.45 197.9,69.45 198.63,68.72 202.8,68.72 203.66,67.86 212.61,67.86 213.67,68.92 222.79,68.92 225.69,71.82 232.55,71.82 234.05,73.31 239.57,73.31 241.18,71.71 241.18,66.13 241.94,65.36 244.54,65.36 245.31,66.13 245.87,66.13 247.44,67.7 247.44,68.48 248.73,69.78 252,69.78 254.04,71.82 258.48,71.82 260.38,73.72 260.38,74.59 261.47,75.68 261.47,77.89 261.47,79.15 262.44,80.12 262.44,82.82 261.12,84.14 261.12,84.93 v2(261.53,85.33) 261.27,85.59 261.27,91.28 263.2,93.21 263.2,96.86 261.4,98.66 261.4,100.82 260.49,101.73 v3(259.99,101.73)
  BOTTOM w0.102: v2(143.8,72.86) 142.24,71.3 CN375.13
A_3S_ICHSPKR: length 177.5
  TOP w0.102: v2(291.24,60.31) 292.52,59.03 R513.1 ; v2(169.75,84.51) 169.34,84.11 169.34,79.27 170.24,78.37 170.24,77.06 171.09,76.21 171.09,73.41 168.23,70.55 168.23,67.95 168.59,67.59 168.59,64.98 169.93,63.64 170.58,62.99 v1(170.58,61.09) v2(170.58,60.12)
  L5 w0.102: v2(170.58,60.12) 170.58,59.26 176.21,53.63 222.69,53.63 222.9,53.84 224.08,55.02 231.59,55.02 232.41,55.84 238.85,55.84 241.49,53.21 261.19,53.21 261.33,53.34 265.41,53.34 265.42,53.35 265.7,53.35 267.47,55.11 275.74,55.11 276.89,53.96 278.04,53.96 278.62,54.54 279.36,54.54 280.3,55.48 281.46,55.48 282.33,56.35 282.33,57.5 284.73,59.9 286.26,59.9 286.67,60.31 288.96,60.31 289.52,60.87 290.68,60.87 v2(291.24,60.31)
  BOTTOM w0.076: U4555.V2 174.19,84.11 173.9,84.39 173.66,84.39 173.66,84.4 173.21,84.4 173.21,84.39 171.85,84.39 171.42,83.96 169.91,83.96 169.75,84.12 v2(169.75,84.51) 169.53,84.29 169.22,84.29
  BOTTOM w0.102: R4880.2 159.02,85.89 160.09,85.89 161.03,84.94 161.03,84.77 161.62,84.19 162.02,84.19 162.24,84.41 163.7,84.41 163.82,84.29 169.22,84.29
A_LINEINL: length 3.5
  TOP w0.254: C514.1 299.63,55.61 300.39,56.37 301.4,56.37 301.6,56.57 U501.19
A_LINEINL_DOCK: length 77.6
  TOP w0.254: R505.2 v2(300.64,55.87)
  L5 w0.102: CN3601.17 322.74,114.7
  L5 w0.254: 322.74,114.7 321.37,114.7 320.43,113.76 320.43,108.8 320,108.37 319.31,108.37 318.32,107.38 318.32,107.05 313.36,102.09 313.36,84.48 311.31,82.43 311.31,76.76 313.52,74.55 313.52,65.74 310,62.22 308.6,62.22 306.74,60.35 306.74,56.75 305.87,55.89 302.07,55.89 301.54,55.36 301.02,55.36 300.64,55.74 v2(300.64,55.87)
A_LINEINR: length 2.3
  TOP w0.254: C526.1 302.55,55.46 v1(301.96,56.04) 302,56.08 U501.20
A_LINEINR_DOCK: length 75.6
  TOP w0.254: R504.2 301.28,55.53 v2(301.28,55.87)
  L5 w0.254: v2(301.28,55.87) 301.81,56.4 305.66,56.4 305.98,56.71 305.98,60.31 308.39,62.72 309.79,62.72 312.85,65.79 312.85,74.5 310.8,76.55 310.8,82.64 312.85,84.69 312.85,102.3 317.61,107.05 317.61,108.22 319.44,110.05 319.44,114.16 319.95,114.67 320.2,114.67 320.83,115.3 322.89,115.3 322.99,115.2 CN3601.18
A_MIC: length 30.1
  TOP w0.254: R532.2 308.39,55.74 307.88,55.23 v2(307.88,53.07)
  L3 w0.254: v2(291.24,52.39) 291.83,51.8 306.23,51.8 307.5,53.07 v2(307.88,53.07)
  BOTTOM w0.254: 285.23,52.82 285.23,53.7 C612.1 ; 285.23,52.82 R612.1 ; 285.23,52.82 285.23,52.73 v1(286.29,51.67) 286.37,51.67 286.71,52.02 286.71,52.73 286.97,52.98 U610.1 287.67,52.98 288.73,51.93 290.78,51.93 v2(291.24,52.39)
A_SD#: length 153.3
  TOP w0.102: U300.91 265.68,108.95 265.23,108.5 v2(265.23,105.65) ; v2(292.11,62.57) 291.96,62.42 R533.1 ; v2(292.11,62.57) 292.11,62.29 292.78,61.62 D501.1 292.19,60.72 290.46,60.72 290.02,61.15 290.02,62.14 290.31,62.42 R509.1 ; v2(292.11,62.57) 292.11,63.26 289.98,65.38 D500.1 ; v2(239.3,108.7) 239.17,108.57 R1006.1
  L3 w0.102: v2(239.3,108.7) 239.3,98.41 236.76,95.87 v2(236.76,95.11)
  L5 w0.102: v2(289.85,97.14) 291.62,95.36 291.62,85.33 294.45,82.5 296.48,82.5 299.9,79.08 299.9,76.77 297.87,74.74 296.2,74.74 294.47,73.01 294.47,65.52 292.11,63.15 v2(292.11,62.57)
  L6 w0.102: v2(236.76,95.11) 237.17,94.7 237.95,94.7 238.4,95.16 241.3,95.16 242.24,94.22 244.06,94.22 244.27,94.43 244.47,94.63 245.56,94.63 246.92,95.98 246.92,99.54 252.98,105.6 255.53,105.6 257.03,104.1 259.57,104.1 260.61,105.14 264.45,105.14 264.95,105.65 v2(265.23,105.65)
  BOTTOM w0.102: v2(265.23,105.65) 266.33,104.55 273.95,104.55 274.25,104.55 274.65,104.95 277.51,104.95 277.85,105.29 283.98,105.29 284.89,104.38 284.89,101.43 285.4,100.92 292.16,100.92 292.77,100.32 292.77,97.9 291.37,96.51 290.48,96.51 v2(289.85,97.14)
ACCEL_INT: length 172.7
  TOP w0.102: R4781.2 165.13,75.63 165.13,76.9 v2(165.26,77.02) ; v2(248.06,95.24) 247.68,94.85 246.67,94.85 v1(245.9,94.09) 245.9,93.65 244.32,92.06 242.6,92.06 242.22,92.44 242.22,94.58 241.29,95.51 236.59,95.51 236.35,95.28 236.35,94.32 235.87,93.84 233.99,93.84 233.36,94.47 232.78,95.06 227.29,95.06 226.07,96.28 226.07,97.9 226.45,98.28 Q1003.3
  L5 w0.102: v2(150.47,80.77) 150.47,80.18 151.26,79.39 154.39,79.39 154.69,79.69 155.45,79.69 155.76,79.39 155.76,79.11 156.19,78.67 159.21,78.67 159.34,78.55 163.58,78.55 164.22,77.91 164.37,77.91 v2(165.26,77.02) 166.22,77.99 169.4,77.99 171.28,76.11 173.21,76.11 175.34,73.98 177.73,73.98 178.73,74.97 183.67,74.97 184.68,73.96 185.46,73.96 185.93,74.44 203.28,74.44 203.85,73.87 206.18,73.87 207.2,72.86 223.56,72.86 224.35,73.65 227.64,73.65 229.47,75.47 235.48,75.47 236.02,74.94 243.67,74.94 244.04,75.31 249.18,75.31 250.12,74.36 v2(250.12,73.79)
  BOTTOM w0.102: v2(150.47,80.77) 150.47,81.38 150.73,81.65 R4866.1 ; v2(250.12,73.79) 250.12,74.13 249.73,74.52 249.73,79.09 248.06,80.76 246.79,80.76 246.35,81.2 246.35,82.22 245.65,82.92 245.65,87.56 246.08,87.99 246.26,87.99 246.26,88 247.24,88 248.06,88.82 v2(248.06,95.24)
ACCEL_INT_D: length 18.8
  TOP w0.102: U1000.11 241.84,96.89 241.46,97.27 240.32,97.27 238.77,95.72 236.51,95.72 236.15,95.36 236.15,94.4 235.79,94.04 234.08,94.04 233.51,94.61 232.86,95.26 230.89,95.26 229.29,96.86 v1(229.22,96.86) 228.74,97.33 Q1003.2
ADP_A_ID: length 10
  TOP w0.102: v1(288.7,101.59) 288.7,101.16 R6909.2 289.17,100.66 R6904.1 289.17,99.63 288.45,98.92 v2(286.42,98.92) ; R300.1 282.79,98.03 v2(282.99,97.83)
  BOTTOM w0.102: v2(282.99,97.83) 285.33,97.83 v2(286.42,98.92)
ADP_DET: length 91.3
  TOP w0.102: U300.31 275.68,96.03 274.19,97.52 v2(272.32,97.52)
  TOP w0.254: U6000.5 289.51,130.24 v3(289.47,130.29) 289.47,130.41 288.7,131.18 R6022.2 288.81,131.26 289.66,132.11 R6024.1
  L3 w0.102: v3(289.47,130.29) 289.07,130.69 284.83,130.69 281.9,133.61 279.79,135.72 271.6,135.72 267.77,131.9 267.77,120.69 266.17,119.09 266.17,114.15 262.85,110.83 262.85,107.45 259.02,103.62 257.88,103.62 257.03,102.77 257.03,102.55 256.27,101.79 256.27,100.91 v2(255.18,99.81)
  L6 w0.102: v2(272.32,97.52) 271.3,98.54 256.95,98.54 255.68,99.81 v2(255.18,99.81)
ADP_EN: length 58.3
  TOP w0.102: U300.63 278.43,108.53 278.7,108.8 278.7,109.46 282,112.76 R317.1 283.2,112.99 v1(282.35,113.83) 281.46,114.72 v2(281.46,115.43) ; Q6009.4 303.77,147.45 v2(305.02,148.69)
  L3 w0.102: v2(281.46,115.43) 282.86,116.83 282.86,120.58 285.96,123.69 288.77,123.69 292.01,126.92 292.01,127.62 301.91,137.53 301.91,145.53 305.02,148.64 v2(305.02,148.69)
ADP_ID_CHK: length 26.5
  TOP w0.102: Q6998.1 288.08,100.85 R6999.1 287.86,101.76 v2(287.94,101.84) ; U300.78 270.88,109.37 270.93,109.33 270.93,106.15 v2(271.05,106.03)
  BOTTOM w0.102: v2(271.05,106.03) 271.3,105.78 277.15,105.78 277.71,106.34 284.97,106.34 287.05,104.25 287.05,102.73 v2(287.94,101.84)
ADP_PRES: length 48.9
  TOP w0.102: v2(272.7,112.38) 272.48,112.16 U300.74 ; v2(297.09,130.92) 295.88,132.13 U6903.4 295.88,135.33 296.45,135.9 298.89,135.9 v1(299.24,136.26) 299.24,136.85 R6933.2 299.88,137.1 R6935.1
  L5 w0.102: v2(272.7,112.38) 273.39,113.07 285.05,113.07 290.65,118.67 292.35,118.67 292.74,119.07 292.74,120.21 297.09,124.55 v2(297.09,130.92)
ADP_PRES_OUT: length 141
  TOP w0.102: v2(173.05,104.28) 173.32,104.01 173.32,101.03 172.82,100.52 172.82,96.55 173.95,95.42 173.95,89 174.38,88.58 175.3,88.58 175.59,88.86 175.8,88.86 176.13,88.86 176.13,88.86 176.29,88.86 176.78,88.86 176.78,88.86 177.33,88.86 177.78,89.32 v2(177.78,89.35) ; U300.99 262.94,108.13 263.1,108.29 263.1,109.56 262.71,109.94 260.46,109.94 v2(260.08,110.32) ; v4(159.93,96.12) 159.08,96.12 R4743.2
  L6 w0.102: v4(159.93,96.12) 160.43,95.62 161.13,95.62 161.59,96.08 164.59,96.08 166.13,94.53 170.39,94.53 171.73,93.2 172.41,93.2 174.44,91.17 174.98,91.17 175.43,90.72 177.22,90.72 177.78,90.15 v2(177.78,89.35)
  BOTTOM w0.076: U4555.AJ8 178.12,89.75 177.78,89.41 v2(177.78,89.35)
  BOTTOM w0.102: v2(173.05,104.28) 173.43,104.65 v1(173.43,104.95) 173.43,106.33 173.69,106.59 173.69,107.73 175.83,109.87 205.76,109.87 210.73,109.87 213.63,109.87 214,110.24 214.08,110.24 214.08,110.24 238.39,110.24 238.6,110.03 240.63,110.03 240.75,109.91 243.41,109.91 244.07,109.91 244.18,110.02 255.08,110.02 255.57,110.5 259.9,110.5 v2(260.08,110.32)
AMP_PD: length 32.3
  TOP w0.102: U501.7 297.76,59.86 297.76,59.85 297.42,59.85 297.42,59.86 296.8,59.86 R501.2 296.63,60.02 v2(296.63,60.61)
  L3 w0.102: v2(296.63,60.61) 296.73,60.72 296.73,61.4 296.42,61.71 294.93,61.71 294.3,61.08 293.92,61.08 293.58,61.43 293.22,61.43 292.97,61.17 292.97,60.21 292.23,59.47 290.72,59.47 286.8,55.56 284.44,55.56 283.55,54.67 281.96,54.67 279.77,52.48 278.55,52.48 v2(278.34,52.69)
  BOTTOM w0.102: Q501.1 281.07,54.86 280.42,55.51 279.2,55.51 278.06,54.37 v1(278.06,53.78) 278.06,52.97 v2(278.34,52.69)
APWROK: length 20.6
  TOP w0.102: R4723.2 158.91,82.5 158.91,83.2 R4722.2 158.81,83.46 160.07,84.71 160.07,85.22 160.04,85.24 v3(160.06,85.24)
  L6 w0.076: 174.86,85.28 175.8,85.28 v2(175.98,85.46)
  L6 w0.102: v3(160.06,85.24) 160.14,85.33 168.46,85.33 168.94,84.85 169.45,84.85 169.53,84.93 171.51,84.93 171.68,84.76 173.4,84.76 173.89,85.26 174.84,85.26 174.86,85.28
  BOTTOM w0.076: v2(175.98,85.46) 175.98,85.75 U4555.AB5
AZ_R3S_BITCLK: length 215.4
  TOP w0.114: v2(161.82,107.97) 160.94,107.08 v1(160.94,106.67) 160.94,106.34 157.37,102.77 157.37,100.87 158.92,99.32 160.43,99.32 160.65,99.32 163.42,96.56 163.42,84.34 163.42,84.12 163.42,83.9 163.09,83.57 163.09,78.84 162.4,78.15 161.76,77.51 161.76,71.3 162.62,70.44 v2(162.62,70.32) ; v2(297.59,60.26) 297.6,60.26 U501.6
  L3 w0.102: v2(297.59,60.26) 297.59,60.14 297.01,59.56 294.64,59.56 293.79,58.71 291.03,58.71 290.01,57.69 290.01,56.55 289.38,55.92 288.24,55.92 286.23,53.91 282.28,53.91 280.07,51.7 244.56,51.7 242.68,51.7 239.77,54.61 232.73,54.61 230.99,52.87 230.57,52.87 230.57,52.87 229.01,52.87 227.83,51.69 178.03,51.69 171.61,58.11 171.61,61.5 168.44,64.66 164.73,64.66 161.32,68.07 161.32,69.02 162.62,70.32 v2(162.62,70.32)
  BOTTOM w0.114: R4910.1 173.78,102.98 172.24,102.98 171.61,102.35 C523.1 171.07,102.8 169.24,102.8 167.16,104.89 166.79,104.89 164.5,107.17 162.62,107.17 v2(161.82,107.97)
AZ_R3S_RST#: length 225.9
  TOP w0.114: R511.1 290.44,61.24 290.63,61.05 291.57,61.05 v2(292.03,61.5) ; U501.11 298.08,58.26 297.47,57.64 296.15,57.64 v2(295.71,58.07) ; v2(161.17,107.95) 160.17,106.94 160.17,105.94 157.11,102.88 157.11,100.76 158.81,99.06 160.54,99.06 163.15,96.45 163.15,84.01 162.87,83.73 162.82,83.68 162.82,83.24 162.82,78.95 162.29,78.42 161.49,77.62 161.49,70.77 v3(161.93,70.33)
  L3 w0.102: v2(295.71,58.07) 295.26,58.07 294.88,58.46 291.14,58.46 290.27,57.58 290.27,56.44 289.49,55.66 288.34,55.66 286.34,53.66 282.39,53.66 280.18,51.45 244.66,51.45 244.66,51.45 242.67,51.45 242.57,51.45 239.66,54.35 232.98,54.35 230.99,52.36 230.99,52 230.43,51.43 177.92,51.43 171.36,58 171.36,61.39 168.34,64.41 164.63,64.41 161.07,67.96 161.07,69.47 v3(161.93,70.33)
  BOTTOM w0.114: v2(295.71,58.07) 295.54,58.07 294.67,58.94 294.67,59.73 293.96,60.44 293.1,60.44 v2(292.03,61.5) ; R4901.1 174.28,101.59 174.28,102.09 173.64,102.73 172.36,102.73 172.11,102.48 172.12,102.47 172.12,101.97 171.74,101.59 171.73,101.59 171.73,101.33 171.36,100.95 170.72,100.95 167.05,104.62 166.68,104.62 164.69,106.61 162.44,106.61 161.17,107.88 v2(161.17,107.95)
AZ_R3S_SDIN0: length 222.5
  TOP w0.114: R514.2 295.47,59.45 294.04,59.45 293.7,59.79 293.7,60.75 293.5,60.95 v2(293.43,60.95) ; v2(161.91,68.31) 161.91,68.44 163.05,69.58 163.05,70.55 162.03,71.57 162.03,77.4 162.51,77.88 163.35,78.73 163.35,83.46 163.68,83.79 163.68,84.23 163.68,84.45 163.68,97.07 162.96,97.79 162.96,99.56 164.98,101.58 164.98,102.88 164,103.86 162.26,103.86 161.55,104.57 161.55,107.07 162.44,107.96 v3(162.55,107.96)
  L3 w0.102: v2(161.91,68.31) 162.41,68.82 162.97,68.82 163.35,68.44 163.35,66.89 163.79,66.46 165.08,65.17 168.65,65.17 172.12,61.71 172.12,58.32 174.3,56.14 178.24,52.19 227.62,52.19 228.8,53.38 230.78,53.38 232.52,55.12 240.08,55.12 242.99,52.21 244.35,52.21 279.86,52.21 282.07,54.42 286.02,54.42 290.82,59.22 292.41,59.22 293.43,60.23 v2(293.43,60.95)
  BOTTOM w0.076: U4555.AY10 179.16,96.52 179.16,96.9 178.8,97.26 178.8,97.56 178.6,97.76 178.55,97.79 178.54,97.79 178.47,97.83 178.37,97.83 178.24,97.83 176.68,99.38 176.59,99.48 176.59,101.97 176.94,102.32 176.94,103.41 v1(176.59,103.77)
  BOTTOM w0.114: v3(162.55,107.96) 162.58,107.93 164.12,107.93 166.8,105.26 167.17,105.26 169.41,103.01 171.9,103.01 172.21,103.32 174.32,103.32 174.74,102.91 175.73,102.91 v1(176.59,103.77)
AZ_R3S_SDOUT: length 198.6
  TOP w0.114: v2(297.21,60.74) 297.24,60.71 298.44,60.71 U501.5 ; v3(162.57,68.3) 163.31,69.04 163.31,70.66 162.29,71.68 162.29,77.29 163.62,78.62 163.62,83.35 163.95,83.68 163.95,84.34 163.95,84.56 163.95,84.56 163.95,97.18 163.23,97.9 163.23,99.45 165.25,101.47 165.25,102.99 164.11,104.13 162.37,104.13 161.93,104.56 161.93,107.02 162.03,107.11 C7478.2 163.61,108.26 R4869.1
  L3 w0.102: v2(297.21,60.74) 297.21,60.51 296.51,59.81 294.53,59.81 293.69,58.96 290.93,58.96 289.76,57.79 289.76,56.65 289.28,56.17 288.13,56.17 286.13,54.16 282.18,54.16 279.97,51.95 244.45,51.95 242.88,51.95 239.97,54.86 232.63,54.86 230.88,53.12 230.67,53.12 228.91,53.12 227.73,51.94 178.14,51.94 171.86,58.21 171.86,61.6 168.55,64.92 164.97,64.92 162.57,67.32 162.57,68.3 v3(162.57,68.3)
AZ_R3S_SYNC: length 217
  TOP w0.114: v2(296.32,58.07) 296.49,57.91 297.34,57.91 298.09,58.66 U501.10 ; v2(160.69,70.34) 160.69,73.29 v1(160.79,73.39) 161.23,73.83 161.23,77.73 162.18,78.68 162.55,79.06 162.55,83.13 162.55,83.79 162.61,83.84 162.88,84.12 162.88,96.34 160.43,98.79 158.7,98.79 157,100.5 156.99,100.5 156.84,100.65 156.84,102.99 159.9,106.05 159.9,107.32 v2(160.57,107.99)
  L3 w0.102: v2(296.32,58.07) 295.89,57.64 295.26,57.64 294.7,58.2 291.24,58.2 290.52,57.48 290.52,56.33 289.59,55.41 288.45,55.41 286.44,53.4 282.49,53.4 280.28,51.19 244.77,51.19 242.46,51.19 239.55,54.1 233.09,54.1 231.25,52.26 231.25,52.11 231.25,51.89 230.53,51.18 177.82,51.18 171.1,57.9 171.1,61.29 168.23,64.15 164.52,64.15 160.7,67.98 160.7,70.33 v2(160.69,70.34)
  BOTTOM w0.114: v2(160.57,107.99) 160.63,107.99 161.72,109.08 163.35,109.08 166.91,105.52 167.28,105.52 169.59,103.21 171.81,103.21 172.13,103.53 173.88,103.53 174.15,103.8 R4903.1
