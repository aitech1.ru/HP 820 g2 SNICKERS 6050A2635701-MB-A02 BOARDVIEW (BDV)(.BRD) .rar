# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CRT_B: length 59.2
  TOP w0.114: U3065.26 85.13,83.05 85,82.92 85,80.63 84.7,80.33 v2(84.7,80.35) ; L3053.1 38.73,70.13 C3053.1 R3053.1 41.23,70.94 v1(41.23,71.02) 41.23,76.67 44.79,80.24 46.32,80.24 48.17,82.08 51.34,82.08 v3(51.52,81.9)
  BOTTOM w0.114: v2(84.7,80.35) 84.5,80.55 83.02,82.03 79.81,82.03 79.48,81.7 77.35,81.7 76.73,82.32 54.12,82.32 51.94,82.32 v3(51.52,81.9)
CRT_DDCCLK: length 66
  TOP w0.114: U3065.20 80.75,84.41 79.83,83.5 v2(78.92,83.5)
  L3 w0.102: v2(78.92,83.5) 78.92,83.2 78.52,82.79 77.58,82.79 77.4,82.61 77.4,82.04 77.31,81.95 76.05,81.95 75.93,82.07 75.93,83.33 75.81,83.45 75.64,83.45 75.52,83.33 75.52,82.25 75.4,82.13 75.23,82.13 75.11,82.25 75.11,83.33 75,83.45 74.83,83.45 74.71,83.33 74.71,82.07 74.59,81.95 74.42,81.95 74.3,82.07 74.3,83.33 74.18,83.45 74.01,83.45 73.9,83.33 73.9,82.07 73.78,81.95 73.61,81.95 73.49,82.07 73.49,83.33 73.37,83.45 73.2,83.45 73.08,83.33 73.08,82.07 72.96,81.95 72.8,81.95 72.68,82.07 72.68,83.33 72.56,83.45 72.39,83.45 72.27,83.33 72.27,82.22 72.15,82.1 71.98,82.1 71.86,82.22 71.86,83.33 71.74,83.45 54.68,83.45 50.19,78.95 40.27,78.95 v3(39.4,78.09)
  BOTTOM w0.114: v3(39.4,78.09) 38.6,78.09 R3060.2 36.43,76.86 CN3050.15
CRT_DDCDATA: length 69.8
  TOP w0.114: U3065.22 83.13,83.27 82.53,82.66 80.95,82.66 80.72,82.44 79.28,82.44 v2(78.29,83.42)
  L3 w0.102: v4(37.75,64.63) 37.75,77.43 39.63,79.31 50.04,79.31 54.69,83.96 77.76,83.96 v2(78.29,83.42)
  BOTTOM w0.114: CN3050.12 35,68.01 36.1,66.91 36.1,65.14 36.61,64.63 v4(37.75,64.63) R3059.2
CRT_G: length 64.2
  TOP w0.114: L3052.1 38.73,67.72 C3052.1 R3052.1 v1(41.61,67.72) 41.95,68.07 41.95,76.52 45.05,79.61 47.01,79.61 48.68,81.29 50.12,81.29 v2(50.43,80.99) ; U3065.28 86.13,82.92 86.39,82.66 86.39,81.52 86.01,81.14 86.01,80.65 v2(85.71,80.35)
  BOTTOM w0.114: v2(85.71,80.35) 85.71,80.35 85.58,80.35 83.28,82.65 79.56,82.65 79.24,82.33 77.71,82.33 77.09,82.94 51.42,82.94 50.43,81.95 v2(50.43,80.99)
CRT_HSYNC: length 1.7
  TOP w0.114: U3065.25 84.64,83.22 84.5,83.08 84.5,83.08 84.46,83.04 84.46,82.1 R3066.2
CRT_HSYNC_R: length 60.4
  TOP w0.102: R3066.1 C3059.1 83.66,80.86 v2(83.25,80.44)
  L3 w0.102: CN3050.13 36.79,72.63 36.79,76.97 39.48,79.66 47.58,79.66 52.25,84.34 78.94,84.34 79.41,83.87 79.41,82.79 81.22,80.98 82.72,80.98 v2(83.25,80.44)
CRT_R: length 64.9
  TOP w0.114: v2(88.05,83.87) 88.05,84.25 87.89,84.41 U3065.31 ; L3051.1 39.48,65.39 C3051.1 R3051.1 v1(41.56,65.44) 42.58,66.45 42.58,76.26 45.31,78.99 47.39,78.99 48.72,80.33 v3(49.05,80.33)
  BOTTOM w0.114: v2(88.05,83.87) 87.61,84.31 85.02,84.31 83.98,83.27 79.3,83.27 78.99,82.97 77.98,82.97 77.39,83.56 51.15,83.56 49.05,81.47 v3(49.05,80.33)
CRT_VSYNC: length 2.2
  TOP w0.114: U3065.24 84.13,83.23 83.61,82.71 83.46,82.71 82.84,82.1 R3069.2
CRT_VSYNC_R: length 56.5
  TOP w0.102: R3069.1 C3060.1 81.6,81.18 v3(81.19,81.6)
  L3 w0.102: v3(81.19,81.6) 79.61,83.17 79.61,83.95 78.94,84.62 52.15,84.62 47.47,79.93 39.21,79.93 36.31,77.03 36.31,73.6 35.84,73.14 CN3050.14
CURRENT_ADC: length 45.1
  TOP w0.102: R316.1 v2(283.02,99.05)
  TOP w0.254: R6913.2 283.12,131.26 C6900.1 282.23,131.26 R6990.2 282.1,131.13 v1(282.1,130.41) 282.76,130.41 v2(282.94,130.59)
  L3 w0.102: v2(283.02,99.05) 282.48,99.58 282.48,106.26 285.14,108.93 285.14,110.38 288.44,113.67 288.44,115.36 289.21,116.13 289.21,118.1 291.56,120.44 v2(291.75,120.44)
  L5 w0.102: v2(291.75,120.44) 289.05,123.14 286.96,123.14 282.94,127.16 v2(282.94,130.59)
D_DN: length 51.4
  TOP w0.089: 309.79,89.9 310.04,89.9 310.53,90.4 310.76,90.4 310.99,90.17 v2(310.99,90.03)
  L3 w0.089: v2(319.69,107.81) 319.89,107.6 320.35,107.6 320.63,107.33 320.63,106.74 320.16,106.27 319.22,106.27 314.65,101.71 314.65,92.91 316.23,91.34 316.83,91.34 317,91.51 317,91.97 JACK485.8
  BOTTOM w0.089: v2(310.99,90.03) 310.99,90.04 310.76,90.27 310.5,90.27 310.2,90.56 310.2,91.22 310.2,93.32 310.74,93.85 311.53,93.85 311.94,94.26 311.94,104.8 314.23,107.08 317.2,107.08 317.84,107.72 319.6,107.72 v2(319.69,107.81) 319.92,107.58 320.33,107.58 320.45,107.7 CN3601.49
D_DP: length 51.4
  TOP w0.089: U470.14 310.04,91.17 310.57,90.64 310.75,90.64 310.98,90.87 v2(310.98,90.99)
  L3 w0.089: v3(319.69,107.1) 319.69,107.22 319.78,107.31 320.23,107.31 320.34,107.2 320.34,106.86 320.04,106.56 319.1,106.56 314.36,101.83 314.36,92.79 316.11,91.04 316.95,91.04 317.16,91.25 JACK485.7
  BOTTOM w0.089: v2(310.98,90.99) 311.11,90.99 311.18,90.91 311.18,90.61 311.08,90.51 310.62,90.51 310.44,90.69 310.44,93.22 310.84,93.61 311.63,93.61 312.19,94.16 312.19,104.7 314.33,106.84 317.3,106.84 317.94,107.48 319.18,107.48 319.56,107.1 v3(319.69,107.1) 319.93,107.34 320.29,107.34 320.43,107.2 CN3601.48
DC_TEST_A3_B3: length 7.3
  BOTTOM w0.076: U4555.A3 174.79,74.01 U4555.B3 174.19,74.54 U4555.B2 174.04,74.39
  BOTTOM w0.102: v1(171.36,69.96) 171.08,70.24 171.08,70.85 174.03,73.81 174.03,74.38 174.04,74.39
DC_TEST_A61_B61: length 5.6
  BOTTOM w0.076: v1(215.42,74.03) 214.87,73.47 211.28,73.47 210.92,73.83 U4555.A61 210.92,74.48 210.85,74.55 U4555.B61
DC_TEST_AY2_AW2: length 1.4
  BOTTOM w0.076: U4555.AY2 174.2,96.4 U4555.AW2 173.61,95.85 U4555.AW1
DC_TEST_AY3_AW3: length 0.7
  BOTTOM w0.076: U4555.AY3 174.8,95.91 U4555.AW3
DC_TEST_AY61_AW61: length 4.3
  BOTTOM w0.076: v1(211.61,99.81) 211.61,97.27 210.94,96.6 U4555.AY61 210.94,95.95 210.86,95.87 U4555.AW61
DC_TEST_AY62_AW62: length 6.6
  BOTTOM w0.076: U4555.AW63 212.08,95.86 U4555.AW62 211.51,96.43 U4555.AY62 211.6,96.52 212.3,97.22 212.3,100.52 v1(211.61,101.2)
DC_TEST_B62_B63: length 5.9
  BOTTOM w0.076: U4555.A62 211.51,73.94 U4555.B62 212.03,74.61 U4555.B63 212.16,74.48 215.21,74.48 215.23,74.5 215.62,74.5 215.64,74.48 216,74.48 v1(216.44,74.92)
DC_TEST_C1_C2: length 0.7
  BOTTOM w0.076: U4555.C2 173.66,75.14 U4555.C1
DDR3_DRAMRST#: length 243.3
  TOP w0.102: v2(142.53,98.03) 143.03,98.54 143.03,99.68 142.44,100.27 R4550.2
  L5 w0.102: v2(177.3,144.38) 177.3,145.13 v2(180.24,148.07) ; v3(110.5,136.38) 111.26,135.62 111.26,131.4 114.7,127.96 114.7,125.43 115.86,124.27 115.86,117.24 115.86,117.24 115.86,116.89 126.73,106.01 140.28,106.01 141.94,104.35 141.94,98.61 v2(142.53,98.03)
  L6 w0.102: v2(254.29,144.26) 253.78,143.75 246.41,143.75 245.47,144.69 244.43,144.69 243.8,144.05 239.3,144.05 237.95,145.4 232.7,145.4 231.17,146.92 205.39,146.92 205.14,147.18 187.61,147.18 187.29,147.5 180.82,147.5 v2(180.24,148.07) 179.35,147.18 166.28,147.18 166.15,147.31 166.15,147.31 165.49,147.97 153.53,147.97 152.28,149.21 138.79,149.21 137.01,150.99 114.13,150.99 113.18,150.03 113.17,150.03 112.55,149.41 112.55,138.44 v3(110.5,136.38) ; v2(142.53,98.03) 142.53,96.33 143.55,95.31 145.92,95.31 146.82,94.41 146.82,92.29 147.28,91.83 147.7,91.83 v2(147.97,92.1)
  BOTTOM w0.102: R4553.2 147.97,92.47 v2(147.97,92.1) ; CN4125.30 v2(177.3,144.38) ; CN4100.30 254.3,144.24 v2(254.29,144.26)
DDR3_DRAMRST#_CPU: length 65.7
  TOP w0.102: v2(139.99,102.73) 139.99,102.65 R4550.1
  L5 w0.102: v2(182.07,93.9) 180.69,93.9 179.74,94.85 179.74,95.36 178.59,96.51 172.4,96.51 171.91,96.02 167.35,96.02 162.09,90.76 159.19,90.76 157.39,92.57 154.46,92.57 151.22,89.33 148.92,89.33 147.58,87.99 145.6,87.99 145.12,88.48 145.12,93.3 v3(146.03,94.21)
  L6 w0.102: v2(139.99,102.73) 141.78,100.94 141.78,96.4 143.97,94.21 v3(146.03,94.21)
  BOTTOM w0.076: U4555.AV15 182.19,94.99 182.48,94.7 182.48,94.4 182.07,93.99 v2(182.07,93.9)
DDR_PG_CTRL: length 191.7
  TOP w0.102: R4121.1 134.43,149.41 150.38,149.41 151.09,148.7 152.14,148.7 152.31,148.7 152.31,148.7 164.61,148.7 166.26,150.35 170.97,150.35 171.61,149.72 171.61,146.16 172.06,145.71 172.06,143.94 173.01,142.99 178.09,142.99 184.44,149.34 v3(184.44,149.85)
  L3 w0.102: v2(226.22,95.36) 226.98,95.36 228.51,96.89 228.51,102.98 240.82,115.3 240.82,140.07 239.87,141.02 239.87,142.16 239.45,142.58 203.61,142.58 200.54,145.65 196.76,145.65 195.61,146.8 188.68,146.8 185.63,149.85 v3(184.44,149.85)
  BOTTOM w0.076: U4555.AV61 210.9,94.87 212.01,94.87 212.03,94.89 212.3,94.89 212.64,95.23
  BOTTOM w0.102: 212.64,95.23 214.28,96.87 224.71,96.87 v2(226.22,95.36)
DDR_VTT_PG_CTRL: length 14.4
  TOP w0.102: v4(181.98,149.72) 181.98,147.9 180.96,146.88 v1(179.82,146.88) R4114.2 ; R4114.2 176.86,146.88 176.44,147.31 Q4101.3 176.38,147.42 Q4100.1 ; R4114.2 R4115.1
  BOTTOM w0.109: R7119.1 181.26,152.05 181.26,150.44 v4(181.98,149.72)
DDR_WR_VREF01: length 87.2
  TOP w0.254: v2(204.71,93.75) 205.25,94.28 208.12,94.28 212.25,98.41 212.25,102.63 214.76,105.14 v1(220.5,105.14) 223.98,105.14 230.33,111.49 236.94,111.49 243.11,117.67 243.11,124.53 242.53,125.11 242.53,127.87 246.67,132.01 246.67,144.13 247.3,144.77 248.44,144.77 249.41,143.79 C4121.1 249.67,143.79 250.6,142.86 250.98,142.86 252.04,141.8 R4105.2
  BOTTOM w0.254: v2(204.71,93.75) 204.67,93.75 204.32,93.4 204.3,93.4 U4555.AR51
DDR_WR_VREF02: length 142.7
  TOP w0.254: v2(245.14,144.26) 244.51,143.63 v1(244.51,142.86) 244.51,140.95 244.89,140.57 244.89,131.05 241.97,128.13 241.97,124.83 242.55,124.24 242.55,117.92 236.72,112.09 230.12,112.09 223.9,105.87 214.76,105.87 211.81,102.92 211.81,98.6 208.06,94.85 205.01,94.85 204.24,94.09 204.24,93.33 204.46,93.12 v2(204.7,93.12) ; v3(192.44,144.38) 191.68,145.15 190.28,145.15 189.47,145.95 C4122.1 R4112.2
  L6 w0.254: v2(245.14,144.26) 244.51,143.62 238.97,143.62 237.7,144.89 232.57,144.89 231.02,146.44 224.3,146.44 223.13,145.27 223.13,143.83 222.48,143.17 202.29,143.17 200.31,145.15 195.79,145.15 195.03,144.38 v3(192.44,144.38)
  BOTTOM w0.254: v2(204.7,93.12) 204.34,92.75 204.3,92.75 U4555.AP51
DETECT1#: length 30.6
  L5 w0.102: v3(319.97,129.88) 324.54,129.88 325.22,129.19 325.22,108.75 325.38,108.59 325.38,107.23 324.85,106.7 CN3601.1
  BOTTOM w0.102: CN3601.92 320.43,129.2 319.97,129.66 v3(319.97,129.88)
DEVSLP0: length 166.2
  TOP w0.102: R4767.2 170.05,82.42 170.05,80.54 v2(170.06,80.53) ; v2(225.27,74.28) 226.08,73.47 227.24,73.47 228.88,75.11 235.7,75.11 236.02,74.79 239.17,74.79 v1(239.81,74.15) 241.46,72.5 241.46,72.34 241.46,72.34 241.46,71.88 241.46,71.88 241.46,68.39 244.25,65.59 248.76,65.59 v2(249.32,66.15)
  L3 w0.076: v2(176.61,78.7) 175.7,78.7 174.35,80.05 170.54,80.05 v2(170.06,80.53)
  L5 w0.102: v2(176.61,78.7) 177.1,78.22 177.1,77.4 177.27,77.23 177.93,77.23 178.34,76.82 178.34,75.8 178.62,75.52 184.28,75.52 184.57,75.81 188.54,75.81 189.46,74.89 203.81,74.89 204.2,74.5 206.32,74.5 207.4,73.42 223.22,73.42 224.08,74.28 v2(225.27,74.28)
  L6 w0.102: v2(249.32,66.15) 249.32,65.77 249.53,65.57 250.11,65.57 250.48,65.93 250.48,67.67 256.28,73.47 258.25,73.47 260.53,75.75 260.53,78.47 263.48,81.41 263.48,82.57 265.35,84.44 276.56,84.44 277.6,83.4 280.3,83.4 281.59,84.69 286.48,84.69 288.58,86.79 288.58,89.26 288.58,89.26 288.58,89.77 287.97,90.38 287.97,92.3 v2(288.6,92.93)
  BOTTOM w0.076: 172.01,81.15 172.01,81.2 172.49,81.68 173.01,81.68 173.12,81.57 173.89,81.57 174.19,81.86 U4555.P2
  BOTTOM w0.102: CN1951.38 288.97,93.3 v2(288.6,92.93) ; v2(170.06,80.53) 170.06,80.6 170.47,81.01 171.86,81.01 172.01,81.15
DEVSLP1: length 105.9
  TOP w0.102: R4726.2 170.42,81.69 171.23,80.88 171.23,79.77 v4(170.53,79.08)
  L3 w0.102: v2(113.47,83.78) 113.65,83.96 115.33,83.96 116.26,83.02 133.18,83.02 138.1,78.1 138.46,78.1 140.25,76.31 148.11,76.31 149.41,77.61 151.52,77.61 154.08,75.04 156.47,75.04 v2(157.44,74.08)
  L5 w0.102: v2(96.43,86.22) 97.95,86.22 101.87,82.3 110.54,82.3 112.03,80.81 112.03,80 v2(112.02,80)
  BOTTOM w0.076: v4(170.53,79.08) 170.71,79.25 171.58,79.25 171.82,79.5 172.51,80.18 172.98,80.18 173.09,80.07 173.67,80.07 173.97,80.36 U4555.L2
  BOTTOM w0.102: v2(157.44,74.08) 158.71,74.08 160.53,75.91 161.12,75.91 161.27,76.06 165.96,76.06 168.1,78.2 169.66,78.2 v4(170.53,79.08) ; CN1700.P3 90.08,81.41 93.14,81.41 94.14,82.41 94.14,84.2 96.15,86.22 v2(96.43,86.22) ; v2(112.02,80) 112.02,82.91 112.89,83.78 v2(113.47,83.78)
DGPU_HOLD_RST#: length 19.9
  BOTTOM w0.076: U4555.P3 174.84,81.9 174.58,82.15 173.1,82.15 172.97,82.01 172.13,82.01 171.76,81.64 171.47,81.64
  BOTTOM w0.102: 171.47,81.64 169.34,81.64 169.06,81.35 v1(168.69,81.35) 168.27,81.35 166.86,79.94 165.08,79.94 163.99,78.85 163.99,78.19 163.63,77.84 161.79,77.84 161.58,77.84 160.89,78.52 160.89,79.54 160.18,80.25 159.05,80.25 R4751.2
DGPU_PRSNT#: length 13.1
  BOTTOM w0.076: U4555.Y3 174.58,85.14 173.16,85.14 173.05,85.03 172.52,85.03 172.43,84.94 171.96,84.94 171.65,85.25 169.27,85.25 169.25,85.24 169.22,85.24
  BOTTOM w0.102: R4709.2 163.45,85.81 ; 163.45,85.81 163.94,85.81 v1(164.24,86.12) 164.47,85.89 165.23,85.89 165.61,85.51 165.62,85.51 165.89,85.24 169.22,85.24 ; 163.45,85.81 R4919.1
DGPU_PWR_EN#: length 18.5
  BOTTOM w0.076: 169.79,79.58 169.97,79.75 171.61,79.75 172.39,80.54 172.49,80.54 172.49,80.54 172.97,80.54 173.01,80.54 173.12,80.65 174.58,80.65 174.84,80.39 U4555.L3
  BOTTOM w0.102: R4929.2 159.16,75.68 159.95,76.46 160.89,76.46 161.37,76.95 v1(162.21,76.95) 162.54,76.62 165.51,76.62 168.47,79.58 169.79,79.58
DGPU_PWROK: length 23.1
  TOP w0.102: v4(160.49,80.86) 160.49,80.47 159.54,79.52 159.54,77.83 159.16,77.46 159.16,76.82 v1(159.93,76.06) R4907.2
  L6 w0.102: v2(174.54,82.96) 174.22,82.64 174.03,82.64 173.49,82.1 171.49,82.1 171.3,81.91 169.21,81.91 168.29,80.99 163.75,80.99 162.84,81.9 160.86,81.9 160.49,81.53 v4(160.49,80.86)
  BOTTOM w0.076: v2(174.54,82.96) 174.54,82.86 174.84,82.57 U4555.T3
DMIC_CLK: length 259
  TOP w0.254: v4(114.1,117.97) 115.2,117.97 116.1,117.07 116.1,114.39 v1(115.86,114.15) 114.94,113.24 114.94,94.88 116.11,93.71 118.35,93.71 120.55,91.51 120.55,89.19 119.54,88.17 119.54,85.46 114.33,80.25 v2(113.95,80.25) ; C7654.1 296.2,64.76 v2(296.32,64.63) 296.32,64.5 295.9,64.08 R516.2
  L3 w0.254: v2(113.95,80.25) 114.2,80.5 123.88,80.5 125.12,79.26 128.57,79.26 128.98,78.85 131.77,78.85 134.31,76.31 136.6,76.31 140.01,72.9 140.01,68.31 142.58,65.75 157.03,65.75 161.58,61.2 164.67,61.2 171.74,54.13 v2(171.74,53.03)
  L5 w0.254: v2(171.74,53.03) 173.39,51.37 227.84,51.37 229.35,52.87 232.19,52.87 233.52,54.19 237.9,54.19 238.69,53.4 238.69,51.93 239.47,51.15 282.39,51.15 282.84,51.6 v2(282.84,52.79)
  L6 w0.254: v2(282.84,52.79) 282.84,56.43 283.85,57.44 283.85,58.03 286.38,60.56 286.87,60.56 289.42,63.12 294.81,63.12 v2(296.32,64.63)
  BOTTOM w0.254: v4(114.1,117.97) 113.82,118.25 CN3000.16
DMIC_CLK_DB: length 65.3
  L3 w0.102: v4(248.04,42.78) 248.04,44.18 246.39,45.83 v4(243.85,45.83) 243.85,46.1 242.34,47.61 237.1,47.61 236.16,46.67 200.85,46.67 200.27,47.25 196.15,47.25 195.76,46.87 194.3,46.87 v4(193.69,47.48)
  BOTTOM w0.114: CN600.1 242.53,45.32 243.35,45.32 v4(243.85,45.83) ; v4(248.04,42.78) 248.04,44.56 247.53,45.07 MIC601.3 ; v4(193.69,47.48) 193.54,47.48 193.18,47.13 193.18,46.34 193.59,45.93 MIC600.3
DMIC_DAT: length 259.9
  TOP w0.254: v2(296.3,61.15) 296.37,61.22 297.49,61.22 297.66,61.06 U501.4 ; v4(114.1,118.75) 115.43,118.75 v1(116.01,118.17) 116.8,117.38 116.8,113.52 115.45,112.18 115.45,96.35 116.82,94.98 118.14,94.98 118.78,94.35 118.78,94.02 121.09,91.7 121.09,88.99 120.05,87.95 120.05,85.25 114.42,79.61 113.7,79.61 113.32,80 113.32,80.63 v2(113.57,80.88)
  L3 w0.254: v2(172.67,52.99) 172.49,53.18 172.49,54.1 164.88,61.71 161.96,61.71 157.41,66.25 142.86,66.25 140.57,68.54 140.57,73.06 136.81,76.82 134.53,76.82 131.86,79.49 129.06,79.49 128.78,79.77 125.33,79.77 124.09,81 113.69,81 v2(113.57,80.88)
  L5 w0.254: v2(172.67,52.99) 173.64,52.03 225.02,52.03 226.68,53.69 231.98,53.69 232.99,54.7 238.38,54.7 241.42,51.66 260.72,51.66 260.81,51.75 281.46,51.75 v2(281.46,51.75)
  L6 w0.254: v2(281.46,51.75) 281.79,51.42 282.28,51.42 283.37,52.51 283.37,55.1 285.66,57.39 286.22,57.39 286.74,57.91 286.74,59.1 287.29,59.65 294.37,59.65 295.87,61.15 v2(296.3,61.15)
  BOTTOM w0.254: CN3000.15 114.1,118.75 v4(114.1,118.75)
DMIC_DATA_DB: length 54.6
  L3 w0.102: v4(244.62,44.18) 243.85,44.18 v4(241.51,46.52) 240.9,47.13 237.31,47.13 236.32,46.14 200.59,46.14 199.98,46.75 197.95,46.75 v4(197.62,46.42)
  BOTTOM w0.114: v4(244.62,44.18) 245.51,45.07 MIC601.4 ; CN600.2 241.8,46.23 241.51,46.52 v4(241.51,46.52) ; v4(197.62,46.42) 197.36,46.67 196.2,46.67 195.45,45.93 MIC600.4
DOCK_ID1: length 261.5
  TOP w0.102: Q5401.1 261.79,76.96 261.09,77.66 258.78,77.66 v2(258.38,78.06) ; R4728.2 v4(155,78.34) ; v2(319.95,113.07) 318.42,114.59 318.42,118.35 318.04,118.73 318.04,120.51 316.39,122.16 316.39,123.56 316.95,124.12 318.22,124.12 318.78,123.56 318.8,123.56 318.83,123.53 321.32,123.53 322.49,124.7 CN3601.37
  L3 w0.076: v2(179.36,82.54) 178.77,81.95 178.77,79.72 178.92,79.56 178.92,76.9 177.79,75.77 176.35,75.77 175.55,76.57 172.75,76.57 v2(171.88,77.44)
  L3 w0.102: v2(319.95,113.07) 317.1,110.22 315.37,110.22 314.74,110.86 308.67,110.86 v3(308.01,110.2)
  L5 w0.102: v2(258.38,78.06) 256.75,79.69 251.09,79.69 249.33,77.94 240.29,77.94 237.47,80.76 233.33,80.76 231.43,82.66 228.38,82.66 228.17,82.46 228.17,78.66 226.46,76.95 223.65,76.95 222.38,75.68 219.46,75.68 218.47,76.67 212.25,76.67 212.12,76.54 208.77,76.54 208.11,77.2 207.23,77.2 206.78,77.66 206.78,78.22 205.3,79.69 187.66,79.69 186.08,81.27 185.09,81.27 184.72,81.65 180.71,81.65 179.82,82.54 v2(179.36,82.54)
  L6 w0.102: v2(171.88,77.44) 171.5,77.81 167.03,77.81 165.81,76.59 159.26,76.59 157.8,78.06 155.29,78.06 v4(155,78.34) ; v2(258.38,78.06) 258.38,86.91 259.34,87.87 263.63,87.87 265.85,85.65 277.97,85.65 v2(279.41,87.08) 279.94,87.08 281.56,85.46 286.24,85.46 287.86,87.08 287.86,89.39 285.58,91.67 285.58,99.61 287.18,101.2 287.18,105.89 v2(286.68,106.39)
  BOTTOM w0.076: U4555.G2 174.19,78.11 173.89,77.82 172.86,77.82 172.48,77.44 v2(171.88,77.44)
  BOTTOM w0.102: v2(279.41,87.08) 276.99,84.67 276.99,80.1 276.37,79.47 276,79.47 Q5301.1 ; v2(286.68,106.39) 287.47,105.61 300.73,105.61 301.38,106.26 305.18,106.26 306.86,107.94 307.5,108.58 307.5,109.67 308.01,110.17 v3(308.01,110.2)
DP_DEMUX_SW: length 5.5
  BOTTOM w0.102: U5301.18 279.82,76.52 278.92,77.41 v1(278.92,78.09) 278.67,78.34 R5318.2 277.95,79.81 Q5301.3
DP_UTIL: length 6.6
  BOTTOM w0.102: U4555.A43 199.74,73.89 200.16,73.47 200.16,72.55 200.6,72.1 200.6,70.99 200.34,70.72 198.91,70.72 TP4500.1
DPB0_C_DN: length 2.9
  BOTTOM w0.114: U5301.7 280.04,72.12 279.96,72.03 278.98,72.03 278.67,72.35 278.06,72.35 C5302.2
DPB0_C_DP: length 3
  BOTTOM w0.114: C5301.2 277.77,71.78 278.11,72.12 278.57,72.12 278.88,71.81 280,71.81 280.09,71.72 U5301.6
DPB0_DN: length 91.1
  L3 w0.102: v2(276.34,72.42) 276.22,72.3 274.83,72.3 274.66,72.12 273.56,72.12 272.47,73.21 270.64,73.21 269.8,72.38 269.48,72.38 268.08,70.98 264.95,70.98 263.9,72.03 261.07,72.03 259.31,70.27 251.09,70.27 247.11,74.25 244.85,74.25 244.71,74.4 244.71,74.81 244.45,75.08 244.07,75.08 243.8,74.81 243.8,74.4 243.66,74.25 243.46,74.25 243.32,74.4 243.32,74.81 243.05,75.08 242.67,75.08 242.4,74.81 242.4,74.4 242.26,74.25 242.06,74.25 241.92,74.4 241.92,74.81 241.65,75.08 241.27,75.08 241.01,74.81 241.01,74.4 240.86,74.25 240.66,74.25 240.52,74.4 240.52,74.81 240.26,75.08 239.88,75.08 239.61,74.81 239.61,74.4 239.47,74.25 239.27,74.25 239.13,74.4 239.13,74.81 238.86,75.08 238.48,75.08 238.21,74.81 238.21,74.4 238.07,74.25 237.87,74.25 237.73,74.4 237.73,74.6 237.46,74.86 237.08,74.86 236.81,74.6 236.81,74.4 236.67,74.25 236.23,74.25 235.14,75.35 233.1,75.35 232.25,74.5 230.14,74.5 228.49,72.85 225.52,72.85 224.22,71.55 221.53,71.55 219.88,69.9 216.21,69.9 214.77,69.9 214.04,69.17 213.76,69.17 213.17,68.59 208.81,68.59 208.55,68.84 208.55,69.04 v2(208.77,69.26)
  BOTTOM w0.076: 207.49,73.09 207.49,73.1 207.47,73.12 207.47,73.16 207.45,73.18 207.45,73.41 207.39,73.47 207.39,73.99 207.33,74.16 207.33,74.27 207.35,74.33 207.36,74.34 207.37,74.39 207.39,74.42 207.39,74.61 207.34,74.76 207.25,74.91 207.25,74.91 207.25,75.32 207.05,75.51 206.37,75.51 U4555.C54
  BOTTOM w0.114: v2(208.77,69.26) 208.77,69.39 207.49,70.68 207.49,73.09 ; v2(276.34,72.42) 276.52,72.23 276.6,72.23 276.92,72.55 C5302.1
DPB0_DOCK_DN: length 75.8
  L6 w0.114: v2(286.77,74.13) 286.77,74.11 287.34,73.54 289.4,73.54 292.76,76.9 296.22,76.9 301.76,82.44 301.76,85.68 302.72,86.64 302.72,87.41 305.02,89.7 308.99,89.7 309.91,90.62 309.91,104.63 310.42,105.14 311.94,105.14 314.21,107.41 317.07,107.41 318.17,108.51 320.44,108.51 321.34,109.42 321.34,116.45 319.72,118.07 319.72,118.55 v2(319.54,118.73)
  BOTTOM w0.114: U5301.39 285.9,74.12 285.93,74.15 286.75,74.15 v2(286.77,74.13) ; CN3601.76 320.71,121.2 320.57,121.06 319.99,121.06 319.69,120.76 319.69,120.21 319.83,120.08 319.83,119.02 v2(319.54,118.73)
DPB0_DOCK_DP: length 75.8
  L6 w0.114: v3(320.19,118.53) 320.08,118.53 319.96,118.41 319.96,118.17 321.58,116.55 321.58,109.32 320.54,108.27 318.27,108.27 317.17,107.16 314.31,107.16 312.04,104.9 310.52,104.9 310.15,104.53 310.15,90.52 309.09,89.46 305.12,89.46 302.96,87.31 302.96,86.54 302,85.58 302,82.34 296.32,76.65 296.12,76.65 296.12,76.65 292.86,76.65 289.5,73.3 287.24,73.3 286.82,73.71 286.27,73.71 286.24,73.75 v2(286.21,73.75)
  BOTTOM w0.114: CN3601.75 320.67,120.7 320.53,120.84 320.09,120.84 319.92,120.67 319.92,120.31 320.05,120.17 320.05,118.7 320.19,118.56 v3(320.19,118.53) ; v2(286.21,73.75) 286.19,73.72 U5301.40
DPB0_DP: length 91
  L3 w0.102: v2(276.26,71.84) 276.26,71.85 276.03,72.08 274.92,72.08 274.75,71.91 273.47,71.91 272.38,73 270.73,73 269.89,72.16 269.57,72.16 268.17,70.76 264.86,70.76 263.81,71.82 261.16,71.82 259.4,70.05 251.01,70.05 247.02,74.04 244.77,74.04 244.5,74.31 244.5,74.72 244.36,74.86 244.16,74.86 244.02,74.72 244.02,74.31 243.75,74.04 243.37,74.04 243.1,74.31 243.1,74.72 242.96,74.86 242.76,74.86 242.62,74.72 242.62,74.31 242.35,74.04 241.97,74.04 241.7,74.31 241.7,74.72 241.56,74.86 241.36,74.86 241.22,74.72 241.22,74.31 240.95,74.04 240.57,74.04 240.31,74.31 240.31,74.72 240.17,74.86 239.97,74.86 239.82,74.72 239.82,74.31 239.56,74.04 239.18,74.04 238.91,74.31 238.91,74.72 238.77,74.86 238.57,74.86 238.43,74.72 238.43,74.31 238.16,74.04 237.78,74.04 237.51,74.31 237.51,74.51 237.37,74.65 237.17,74.65 237.03,74.51 237.03,74.31 236.76,74.04 236.14,74.04 235.05,75.13 233.19,75.13 232.34,74.28 230.23,74.28 228.58,72.63 225.61,72.63 224.31,71.33 221.62,71.33 219.97,69.68 216.12,69.68 214.86,69.68 214.13,68.96 213.85,68.96 213.26,68.37 208.72,68.37 208.34,68.75 208.34,69.06 v3(208.09,69.31)
  BOTTOM w0.076: 207.28,73.09 207.28,73.34 207.22,73.4 207.22,73.96 207.16,74.08 207.16,74.3 207.19,74.38 207.2,74.39 207.2,74.4 207.22,74.45 207.22,74.58 207.19,74.69 207.02,74.86 206.78,74.86 206.61,75.03 206.61,75.22 206.68,75.29 206.83,75.29 206.93,75.19 U4555.C55
  BOTTOM w0.114: v2(276.26,71.84) 276.26,71.84 276.42,72 276.66,72 C5301.1 ; 207.28,73.09 207.28,70.59 208.24,69.63 208.24,69.45 v3(208.09,69.31)
DPB0_PORT_C_DN: length 2.5
  BOTTOM w0.114: CN3300.3 320,35.55 319.58,35.55 319.28,35.24 318.67,35.24 C3301.2
DPB0_PORT_C_DP: length 2.5
  BOTTOM w0.114: CN3300.1 320.02,35.77 319.49,35.77 319.18,35.47 318.67,35.47 C3300.2
DPB0_PORT_DN: length 84
  L3 w0.102: v2(298.58,70.7) 298.84,70.96 298.84,71.7 298.99,71.84 298.99,72.25 298.86,72.38 298.1,72.38 297.86,72.62 297.86,73.68 298.13,73.95 301.94,73.95 302.9,74.91 307.83,74.91 308.69,75.78 312.1,75.78 313.66,74.22 313.66,61.2 313.41,60.95 313.41,55.42 314.97,53.86 314.97,52.69 314.41,52.13 313.24,52.13 312.96,51.85 312.96,51.28 313.58,50.66 314.87,50.66 315.4,50.12 315.4,35.01 315.63,34.78 316.95,34.78 317.15,34.99 317.15,35.27 316.78,35.63 316.6,35.63 316.49,35.52 v2(316.49,35.34)
  BOTTOM w0.114: U5301.49 285.42,70.04 285.86,70.04 286.34,69.56 294.1,69.56 294.27,69.39 296.64,69.39 297.31,70.06 298.64,70.06 298.79,70.21 298.79,70.52 298.61,70.7 v2(298.58,70.7) ; C3301.1 317.49,35.06 316.97,35.57 316.72,35.57 v2(316.49,35.34)
DPB0_PORT_DP: length 84.1
  L3 w0.102: v2(299.19,70.7) 299.06,70.83 299.06,71.61 299.21,71.75 299.21,72.34 298.95,72.59 298.19,72.59 298.08,72.71 298.08,73.59 298.22,73.73 302.03,73.73 302.99,74.7 307.92,74.7 308.78,75.56 312.01,75.56 313.44,74.13 313.44,61.29 313.19,61.03 313.19,55.33 314.75,53.77 314.75,52.78 314.32,52.35 313.15,52.35 312.74,51.94 312.74,51.19 313.49,50.44 314.78,50.44 315.18,50.03 315.18,34.92 315.54,34.57 317.04,34.57 317.37,34.9 317.37,35.36 316.87,35.85 316.67,35.85 v3(316.49,36.03)
  BOTTOM w0.114: v2(299.19,70.7) 299.07,70.57 299.07,70.17 298.74,69.84 297.41,69.84 296.74,69.16 294.17,69.16 294.01,69.33 286.25,69.33 285.86,69.72 U5301.50 ; C3300.1 317.44,35.85 316.67,35.85 v3(316.49,36.03)
DPB1_C_DN: length 5.2
  BOTTOM w0.114: U5301.10 280.04,73.32 279.96,73.24 278.67,73.24 278.62,73.29 278.45,73.45 276.51,73.45 276.2,73.14 275.88,73.14 275.59,73.43 C5304.2
DPB1_C_DP: length 5.2
  BOTTOM w0.114: C5303.2 275.9,72.91 276.29,72.91 276.61,73.23 278.36,73.23 278.4,73.18 278.58,73.01 279.97,73.01 280.06,72.92 U5301.9
DPB1_DN: length 89
  L3 w0.102: v4(210.52,69.85) 210.52,69.66 210.65,69.52 210.88,69.52 211.12,69.77 213.86,69.77 214.69,70.59 215.27,70.59 219.59,70.59 221.24,72.25 222.59,72.25 223.98,73.65 228.3,73.65 229.85,75.2 231.96,75.2 232.81,76.05 246.31,76.05 251.38,70.97 251.87,70.97 252.01,71.11 252.01,71.76 252.28,72.03 252.65,72.03 252.92,71.76 252.92,71.11 253.06,70.97 253.26,70.97 253.4,71.11 253.4,71.76 253.67,72.03 254.05,72.03 254.32,71.76 254.32,71.11 254.46,70.97 259.02,70.97 260.78,72.73 264.19,72.73 265.24,71.68 267.75,71.68 268.74,72.66 268.74,76.06 269.27,76.59 271.51,76.59 271.93,76.17 271.93,75.83 271.63,75.54 271.38,75.54 271.19,75.35 271.19,74.28 271.43,74.04 272.69,74.04 273.54,73.19 273.69,73.19 v2(273.96,73.46)
  BOTTOM w0.114: U4555.B58 208.88,74.85 208.88,71.78 209.56,71.1 209.71,71.1 209.84,70.97 209.84,70.83 209.66,70.65 209.56,70.65 209.48,70.58 209.48,70.42 209.66,70.24 209.78,70.24 209.92,70.38 210.06,70.38 210.16,70.27 210.16,70.13 210.06,70.03 210.06,69.82 210.22,69.66 210.39,69.66 210.52,69.78 v4(210.52,69.85) ; C5304.1 274.74,73.47 274.47,73.2 274.16,73.2 273.96,73.41 v2(273.96,73.46)
DPB1_DOCK_DN: length 74.6
  L6 w0.114: v2(288.37,75.41) 288.61,75.17 289.72,75.17 292.21,77.66 295.28,77.66 298.01,80.39 298.67,80.39 300.73,82.45 300.73,85.85 301.45,86.57 301.45,87.62 305.32,91.5 307.99,91.5 308.91,92.41 308.91,105.41 309.9,106.4 311.68,106.4 313.61,108.33 316.17,108.33 319.21,111.37 319.98,111.37 320.58,111.97 320.58,115.59 318.8,117.38 318.8,119.35 v2(318.64,119.5)
  BOTTOM w0.114: CN3601.79 320.53,122.7 320.39,122.56 319.7,122.56 318.91,121.77 318.91,119.69 318.72,119.5 318.72,119.5 v2(318.64,119.5) ; U5301.36 285.84,75.32 285.96,75.19 287.28,75.19 287.61,75.52 288.27,75.52 288.37,75.42 288.37,75.41 v2(288.37,75.41)
DPB1_DOCK_DP: length 74.5
  L6 w0.114: v3(319.33,119.51) 319.25,119.51 319.04,119.3 319.04,117.48 320.82,115.69 320.82,111.87 320.08,111.13 319.31,111.13 316.27,108.08 313.71,108.08 311.78,106.16 310,106.16 309.15,105.31 309.15,92.31 308.09,91.25 305.42,91.25 301.69,87.52 301.69,86.47 300.97,85.75 300.97,82.55 300.97,82.35 298.77,80.15 298.57,80.15 298.11,80.15 295.38,77.42 292.31,77.42 289.82,74.93 287.93,74.93 v2(287.76,75.09)
  BOTTOM w0.114: CN3601.78 320.48,122.2 320.36,122.33 319.79,122.33 319.14,121.67 319.14,119.71 v3(319.33,119.51) ; v2(287.76,75.09) 287.64,74.97 285.83,74.97 285.78,74.92 U5301.37
DPB1_DP: length 89.1
  L3 w0.102: v3(210.37,69.17) 210.37,69.17 210.37,69.22 210.46,69.31 210.64,69.31 210.66,69.31 210.67,69.31 210.97,69.31 211.21,69.55 213.95,69.55 214.77,70.38 215.36,70.38 215.36,70.38 216.41,70.38 216.41,70.38 219.68,70.38 221.33,72.03 222.68,72.03 224.07,73.43 228.39,73.43 229.94,74.98 232.05,74.98 232.9,75.83 246.22,75.83 251.29,70.75 251.96,70.75 252.22,71.02 252.22,71.67 252.37,71.81 252.57,71.81 252.71,71.67 252.71,71.02 252.97,70.75 253.35,70.75 253.62,71.02 253.62,71.67 253.76,71.81 253.96,71.81 254.1,71.67 254.1,71.02 254.37,70.75 259.11,70.75 260.87,72.51 264.1,72.51 265.15,71.46 267.84,71.46 268.96,72.57 268.96,75.97 269.36,76.38 271.42,76.38 271.71,76.08 271.71,75.92 271.54,75.75 271.29,75.75 270.97,75.44 270.97,74.19 271.34,73.82 272.6,73.82 273.45,72.97 273.74,72.97 v2(273.97,72.75)
  BOTTOM w0.114: v2(273.97,72.75) 273.97,72.76 274.18,72.97 274.47,72.97 274.74,72.7 C5303.1 ; v3(210.37,69.17) 210.37,69.18 210.37,69.2 209.25,70.32 209.25,71.09 208.66,71.68 208.66,74.64 208.56,74.73 208.56,74.99 208.87,75.3 U4555.C58
DPB1_PORT_C_DN: length 3.9
  BOTTOM w0.114: CN3300.6 321.28,34.02 320.79,34.02 320.69,34.12 319.68,34.12 319,33.44 318.64,33.44 C3306.2
DPB1_PORT_C_DP: length 4
  BOTTOM w0.114: CN3300.4 321.25,34.25 320.88,34.25 320.78,34.35 319.59,34.35 318.9,33.67 318.69,33.67 C3307.2
DPB1_PORT_DN: length 83.9
  L3 w0.102: v2(316.64,33.13) 316.25,33.53 314.93,33.53 314.48,33.97 314.48,49.41 314.15,49.74 313.2,49.74 312.05,50.9 312.05,52.28 312.84,53.08 313.56,53.08 313.68,53.21 313.68,53.74 313.49,53.93 312.66,53.93 312.43,54.16 312.43,61.84 312.75,62.15 312.75,70.11 312.6,70.25 311.98,70.25 311.72,70.51 311.72,70.89 311.98,71.16 312.6,71.16 312.75,71.3 312.75,71.5 312.6,71.64 311.98,71.64 311.72,71.91 311.72,72.29 311.98,72.56 312.6,72.56 312.75,72.7 312.75,73.83 311.72,74.86 309.15,74.86 308.29,74 303.28,74 302.32,73.04 300.08,73.04 299.9,72.86 299.9,70.47 299.27,69.84 297.59,69.84 297.09,70.34 296.39,70.34 296.28,70.24 296.28,70.04 v2(296.4,69.92)
  BOTTOM w0.114: C3306.1 317.49,33.18 317.21,33.46 316.77,33.46 316.64,33.34 v2(316.64,33.13) ; v2(296.4,69.92) 296.17,70.15 296.17,70.5 294.93,71.74 292.09,71.74 291.73,71.37 286.21,71.37 286.08,71.24 285.41,71.24 U5301.46
DPB1_PORT_DP: length 83.8
  L3 w0.102: v3(316.64,34.02) 316.36,33.74 315.02,33.74 314.7,34.06 314.7,49.5 314.24,49.96 313.29,49.96 312.26,50.99 312.26,52.19 312.93,52.87 313.65,52.87 313.9,53.12 313.9,53.83 313.58,54.15 312.74,54.15 312.64,54.25 312.64,61.75 312.96,62.06 312.96,70.2 312.69,70.46 312.07,70.46 311.93,70.6 311.93,70.8 312.07,70.95 312.69,70.95 312.96,71.21 312.96,71.59 312.69,71.86 312.07,71.86 311.93,72 311.93,72.2 312.07,72.34 312.69,72.34 312.96,72.61 312.96,73.92 311.81,75.08 309.06,75.08 308.2,74.22 303.19,74.22 302.23,73.25 299.99,73.25 299.69,72.95 299.69,70.56 299.18,70.05 297.68,70.05 297.17,70.56 296.3,70.56 296.07,70.33 296.07,70.21 v2(295.78,69.92)
  BOTTOM w0.114: v3(316.64,34.02) 316.64,33.82 316.77,33.69 317.16,33.69 C3307.1 ; U5301.47 285.43,71.01 286.17,71.01 286.3,71.14 291.82,71.14 292.19,71.51 294.83,71.51 295.94,70.4 295.94,70.06 295.94,70.05 295.94,70.05 295.82,69.92 v2(295.78,69.92)
DPB2_C_DN: length 2.8
  BOTTOM w0.114: C5306.2 278.17,74.56 278.87,74.56 279,74.43 279.96,74.43 280.05,74.52 U5301.13
DPB2_C_DP: length 2.8
  BOTTOM w0.114: C5305.2 277.82,74.08 278.08,74.34 278.78,74.34 278.91,74.2 279.97,74.2 280.05,74.12 U5301.12
DPB2_DN: length 91.4
  L3 w0.102: v2(276.2,74.85) 276.36,74.69 276.54,74.69 277.11,74.12 277.11,71.61 276.05,70.55 274.32,70.55 273.82,71.05 273.26,71.05 272.51,71.8 271.83,71.8 271.39,71.37 270.01,71.37 268.7,70.06 264.55,70.06 263.59,71.02 261.61,71.02 260.52,69.92 260.52,68.91 258.93,67.32 256.08,67.32 254.04,69.36 250.72,69.36 246.74,73.33 234.36,73.33 232.73,71.7 225.97,71.7 223.25,68.98 215.83,68.98 215.83,68.98 215.15,68.98 214.42,68.26 214.14,68.26 213.96,68.08 213.55,67.68 208.36,67.68 207.36,68.68 206.57,68.68 205.9,69.35 205.9,69.86 v4(205.74,70.01)
  BOTTOM w0.114: C5306.1 276.97,74.86 276.77,74.66 276.39,74.66 v2(276.2,74.85) ; v4(205.74,70.01) 205.73,70.02 205.73,70.78 206.62,71.66 206.62,74.02 206.93,74.33 206.93,74.53 U4555.B55
DPB2_DOCK_DN: length 74.9
  L6 w0.114: v3(317.39,119.92) 317.51,119.8 317.56,119.75 317.86,119.75 318.15,119.46 318.15,119.29 318.15,119.05 318.3,118.9 318.3,117.17 319.12,116.35 319.12,112.2 316.33,109.41 313.49,109.41 311.25,107.17 309.12,107.17 308.26,106.31 308.26,93.58 307.26,92.58 305.55,92.58 300.63,87.66 300.63,86.73 297.71,83.81 297.71,80.79 295.07,78.15 291.94,78.15 290.26,76.48 288.23,76.48 287.52,76.48 287.22,76.18 v2(287.22,75.93)
  BOTTOM w0.114: v3(317.39,119.92) 317.39,119.77 317.54,119.62 317.72,119.62 318,119.9 318,122.24 319.75,124 320.34,124 320.54,124.2 CN3601.82 ; v2(287.22,75.93) 287.08,75.93 286.82,76.19 286.4,76.19 286.33,76.12 U5301.34
DPB2_DOCK_DP: length 75
  L6 w0.114: v2(317.37,118.97) 317.3,118.97 317.2,119.07 317.2,119.41 317.3,119.51 317.76,119.51 317.91,119.36 317.91,119.19 317.91,118.95 318.06,118.8 318.06,117.07 318.88,116.25 318.88,112.3 316.23,109.65 313.39,109.65 311.15,107.41 309.02,107.41 308.02,106.41 308.02,93.68 307.16,92.82 305.45,92.82 300.39,87.76 300.39,86.83 297.47,83.91 297.47,80.89 294.97,78.4 291.84,78.4 290.16,76.72 288.33,76.72 287.42,76.72 286.98,76.28 286.59,75.89 v2(286.59,75.7)
  BOTTOM w0.114: CN3601.81 320.41,123.7 320.35,123.77 319.85,123.77 318.23,122.14 318.23,119.8 317.81,119.39 317.49,119.39 317.37,119.27 v2(317.37,118.97) ; v2(286.59,75.7) 286.49,75.81 286.07,75.81 285.98,75.72 U5301.35
DPB2_DP: length 91.3
  L3 w0.102: v2(276.21,74) 276.03,74.18 276.03,74.33 276.13,74.43 276.49,74.43 276.89,74.03 276.89,71.7 275.96,70.77 274.41,70.77 273.91,71.27 273.35,71.27 272.6,72.02 271.74,72.02 271.3,71.59 269.92,71.59 268.61,70.28 264.64,70.28 263.68,71.23 261.53,71.23 260.31,70.01 260.31,69 258.85,67.54 256.17,67.54 254.13,69.57 250.81,69.57 246.83,73.55 234.27,73.55 232.64,71.92 225.88,71.92 223.16,69.2 215.92,69.2 215.06,69.2 214.33,68.48 214.05,68.48 213.75,68.17 213.46,67.89 208.45,67.89 207.45,68.89 206.66,68.89 206.11,69.44 206.11,69.8 206.37,70.06 v3(206.43,70.06)
  BOTTOM w0.114: v3(206.43,70.06) 206.43,70.22 206.31,70.34 206.08,70.34 205.96,70.46 205.96,70.68 206.26,70.99 206.41,70.99 206.49,70.91 206.63,70.91 206.73,71.01 206.73,71.15 206.65,71.23 206.65,71.37 206.85,71.57 206.85,73.8 206.93,73.88 U4555.A55 ; C5305.1 276.97,74.3 276.84,74.43 276.46,74.43 276.21,74.18 v2(276.21,74)
DPB2_PORT_C_DN: length 2.4
  BOTTOM w0.114: CN3300.9 320.04,31.91 319.41,31.91 319.18,31.68 318.67,31.68 C3303.2
DPB2_PORT_C_DP: length 2.5
  BOTTOM w0.114: CN3300.7 319.99,32.14 319.32,32.14 319.09,31.91 318.67,31.91 C3302.2
DPB2_PORT_DN: length 84.3
  L3 w0.102: v2(296.96,71.16) 296.93,71.16 296.67,71.42 296.67,71.58 297.34,72.25 297.34,74.99 297.53,75.18 302.13,75.18 302.35,75.4 307.47,75.4 308.71,76.63 312.01,76.63 314.14,74.49 314.14,60.86 313.89,60.6 313.89,55.65 315.88,53.66 315.88,38.03 317.15,36.76 317.15,36.26 317.85,35.56 317.85,32.84 317.63,32.62 315.88,32.62 315.5,32.24 315.5,31.61 315.88,31.23 316.14,31.23 v2(316.39,30.97)
  BOTTOM w0.114: U5301.44 285.36,72.1 291.14,72.1 291.6,72.55 295.69,72.55 296.68,71.56 296.68,71.36 296.88,71.16 v2(296.96,71.16) ; C3303.1 317.41,31.43 316.72,31.43 316.39,31.1 v2(316.39,30.97)
DPB2_PORT_DP: length 84.3
  L3 w0.102: v2(296.32,71.14) 296.46,71.28 296.46,71.67 297.12,72.34 297.12,75.08 297.44,75.4 302.04,75.4 302.26,75.61 307.38,75.61 308.62,76.85 312.1,76.85 314.36,74.58 314.36,60.77 314.1,60.51 314.1,55.74 316.1,53.75 316.1,38.12 317.37,36.85 317.37,36.35 318.07,35.65 318.07,32.75 317.72,32.41 315.97,32.41 315.72,32.15 315.72,31.7 315.96,31.45 316.11,31.45 316.39,31.74 v3(316.39,31.86)
  BOTTOM w0.114: v2(296.32,71.14) 296.45,71.27 296.45,71.47 295.59,72.32 291.69,72.32 291.24,71.87 286.03,71.87 285.88,71.72 U5301.45 ; C3302.1 317.46,32.24 316.88,31.66 316.59,31.66 v3(316.39,31.86)
DPB3_C_DN: length 5.1
  BOTTOM w0.114: C5308.2 276.05,76.11 278.18,76.11 278.65,75.64 279.97,75.64 280.06,75.72 U5301.16
DPB3_C_DP: length 5.1
  BOTTOM w0.114: C5307.2 275.94,75.88 278.08,75.88 278.55,75.41 279.95,75.41 280.04,75.32 U5301.15
DPB3_DN: length 88.9
  L3 w0.102: v3(208.6,71.1) 208.6,71 208.82,70.79 210.86,70.79 211.16,70.49 213.8,70.49 214.6,71.29 219.3,71.29 221.05,73.05 222.04,73.05 224.42,75.42 229.09,75.42 229.56,75.89 231.67,75.89 232.52,76.74 248.11,76.74 252.08,72.77 254.7,72.77 255.31,72.16 255.31,71.83 255.48,71.67 258.53,71.67 260.7,73.84 260.7,77.04 260.97,77.31 261.53,77.31 261.82,77.01 261.82,73.67 261.94,73.56 262.14,73.56 262.31,73.72 262.31,75.56 262.57,75.83 262.95,75.83 263.22,75.56 263.22,75.32 263.36,75.18 263.56,75.18 263.7,75.32 263.7,76.26 264.21,76.76 268.28,76.76 268.87,77.35 272.24,77.35 272.84,76.76 272.84,76.22 273.03,76.04 273.73,76.04 v2(273.99,76.3)
  BOTTOM w0.114: v2(273.99,76.3) 273.99,76.24 274.17,76.06 274.38,76.06 C5308.1 ; U4555.A57 208.2,73.89 208.02,73.71 208.02,73.38 208.12,73.28 208.21,73.28 208.31,73.17 208.31,73.03 208.21,72.93 208.12,72.93 208.02,72.83 208.02,72.69 208.12,72.59 208.21,72.59 208.31,72.49 208.31,72.35 208.21,72.25 208.12,72.25 208.02,72.15 208.02,72 208.12,71.9 208.21,71.9 208.31,71.8 208.31,71.66 208.21,71.56 208.12,71.56 208.02,71.46 208.02,71.15 208.21,70.97 208.48,70.97 v3(208.6,71.1)
DPB3_DOCK_DN: length 75
  L6 w0.114: v3(316.89,117.18) 316.99,117.28 317.17,117.28 317.29,117.16 317.29,116.8 317.6,116.49 317.6,112.2 317.03,111.63 315.39,111.63 314.18,110.43 312.66,110.43 310.67,108.44 308.3,108.44 307.25,107.39 307.25,95.21 306.24,94.21 305.63,94.21 296.65,85.23 296.65,81.12 294.67,79.13 291.34,79.13 290.25,78.03 288.34,78.03 288.03,77.72 288.03,77.48 287.77,77.22 v2(287.69,77.22)
  BOTTOM w0.114: v2(287.69,77.22) 287.94,76.98 287.94,76.89 287.8,76.74 287.29,76.74 286.89,77.15 286.12,77.15 285.87,77.39 285.41,77.39 U5301.31 ; CN3601.85 320.41,125.7 320.28,125.56 319.82,125.56 317.24,122.98 317.24,121.04 316.41,120.22 316.41,118.44 316.16,118.19 316.16,117.64 316.43,117.38 316.69,117.38 v3(316.89,117.18)
DPB3_DOCK_DP: length 75
  L6 w0.114: v2(316.9,117.84) 316.9,117.71 317.02,117.59 317.2,117.59 317.53,117.26 317.53,116.9 317.84,116.59 317.84,112.1 317.13,111.39 315.49,111.39 314.28,110.19 312.76,110.19 310.77,108.2 308.4,108.2 307.49,107.29 307.49,95.11 306.34,93.97 305.73,93.97 296.89,85.13 296.89,81.02 294.77,78.89 291.44,78.89 290.35,77.79 288.44,77.79 288.27,77.62 288.27,77.38 288.4,77.25 v2(288.4,77.18)
  BOTTOM w0.114: CN3601.84 320.41,125.2 320.28,125.34 319.91,125.34 317.47,122.89 317.47,120.94 316.64,120.12 316.64,118.35 316.39,118.1 316.39,117.74 316.52,117.6 316.72,117.6 316.9,117.78 v2(316.9,117.84) ; U5301.32 286.8,76.92 287.2,76.52 287.89,76.52 288.17,76.79 288.17,76.95 v2(288.4,77.18)
DPB3_DP: length 89
  L3 w0.102: v2(274,75.57) 273.75,75.82 272.94,75.82 272.62,76.13 272.62,76.67 272.15,77.14 268.96,77.14 268.37,76.54 264.3,76.54 263.92,76.17 263.92,75.23 263.65,74.97 263.27,74.97 263.01,75.23 263.01,75.47 262.86,75.62 262.66,75.62 262.52,75.47 262.52,73.63 262.23,73.34 261.85,73.34 261.61,73.58 261.61,76.92 261.44,77.09 261.06,77.09 260.92,76.95 260.92,73.75 258.62,71.45 255.39,71.45 255.1,71.74 255.1,72.07 254.62,72.55 251.99,72.55 248.02,76.53 232.61,76.53 231.76,75.68 229.65,75.68 229.18,75.21 224.51,75.21 222.13,72.83 221.14,72.83 219.39,71.08 214.69,71.08 213.89,70.27 211.07,70.27 210.77,70.57 208.65,70.57 v4(208.47,70.39)
  BOTTOM w0.114: v2(274,75.57) 274,75.63 274.2,75.83 274.59,75.83 C5307.1 ; v4(208.47,70.39) 208.47,70.59 208.31,70.74 208.11,70.74 207.79,71.06 207.79,73.88 208,74.08 208,74.09 208.31,74.4 U4555.B57
DPB3_PORT_C_DN: length 3.9
  BOTTOM w0.114: CN3300.12 321.29,30.41 320.69,30.41 320.54,30.57 319.76,30.57 319.1,29.91 318.67,29.91 C3304.2
DPB3_PORT_C_DP: length 4
  BOTTOM w0.114: CN3300.10 321.24,30.64 320.78,30.64 320.63,30.8 319.67,30.8 319.01,30.13 318.67,30.13 C3305.2
DPB3_PORT_DN: length 84.7
  L3 w0.102: v2(316.36,29.32) 316.55,29.51 317.03,29.51 318.76,31.24 318.76,35.94 318.08,36.62 318.08,37.21 316.8,38.49 316.8,54.04 314.8,56.03 314.8,59.97 315.06,60.22 315.06,75 312.46,77.59 308.38,77.59 307.09,76.31 301.97,76.31 301.8,76.15 300.37,76.15 299.17,77.35 298.62,77.35 v2(298.45,77.52)
  BOTTOM w0.114: C3304.1 317.46,29.6 316.64,29.6 v2(316.36,29.32) ; v2(298.45,77.52) 298.3,77.37 297,77.37 295.84,76.21 295.84,74.58 294.81,73.54 286.89,73.54 286.61,73.27 285.96,73.27 285.91,73.32 U5301.41
DPB3_PORT_DP: length 84.6
  L3 w0.102: v3(316.39,30.08) 316.39,29.93 316.6,29.72 316.94,29.72 318.55,31.33 318.55,35.85 317.86,36.53 317.86,37.12 316.58,38.4 316.58,53.95 314.59,55.94 314.59,60.06 314.84,60.31 314.84,74.91 312.38,77.38 308.47,77.38 307.18,76.1 302.06,76.1 301.89,75.93 300.28,75.93 299.08,77.14 298.65,77.14 298.45,76.94 v2(298.45,76.86)
  BOTTOM w0.114: C3305.1 317.49,30.29 317.02,29.83 316.64,29.83 v3(316.39,30.08) ; v2(298.45,76.86) 298.45,76.92 298.24,77.14 297.09,77.14 296.07,76.12 296.07,74.48 294.9,73.31 286.98,73.31 286.73,73.06 286.04,73.06 285.9,72.92 U5301.42
DPB_AUX_C_DN: length 2.2
  BOTTOM w0.114: U5301.25 282.66,78.32 282.58,78.4 282.58,79.8 C5399.2
DPB_AUX_C_DP: length 2.3
  BOTTOM w0.114: U5301.24 282.26,78.34 282.35,78.43 282.35,79.74 282.02,80.08 C5398.2
DPB_AUX_DN: length 166.3
  L6 w0.114: v3(171.71,68.82) 171.87,68.66 171.87,68.36 172.23,68 173.29,68 174.54,69.25 176.28,69.25 176.47,69.44 178.08,69.44 179.8,71.17 182.15,71.17 183.21,70.11 190.71,70.11 191.48,69.34 197.85,69.34 198.51,70 204.01,70 204.26,69.75 204.26,69.16 205.67,67.75 206.27,67.75 207.77,66.25 207.77,60.03 211.48,56.31 229.04,56.31 230.89,58.16 242.75,58.16 242.93,58.34 251.02,58.34 251.5,57.86 254.83,57.86 256.16,56.53 265.68,56.53 267.38,58.23 267.8,58.23 270.2,60.63 270.2,63.1 267.51,65.8 267.05,65.8 264.31,68.54 264.31,77.61 264.61,77.91 265.88,77.91 266.47,78.5 266.47,79.67 267.94,81.14 272.59,81.14 273.21,81.76 281.02,81.76 281.58,81.2 282.29,81.2 282.59,81.51 282.59,81.91 v2(282.73,82.05)
  BOTTOM w0.076: U4555.C5 176.37,75.02 176.37,74.42 176.42,74.37 176.42,73.72 176.26,73.55 175.79,73.55 175.67,73.44
  BOTTOM w0.114: C5399.1 282.73,81.06 v2(282.73,82.05) ; v3(171.71,68.82) 171.95,69.06 171.95,71.29 173.88,73.22 175.45,73.22 175.67,73.44
DPB_AUX_DP: length 166.1
  L6 w0.114: v2(282.07,82.05) 282.15,82.05 282.35,81.85 282.35,81.61 282.19,81.44 281.68,81.44 281.12,82 273.11,82 272.49,81.38 267.84,81.38 266.22,79.77 266.22,78.6 265.78,78.15 264.51,78.15 264.07,77.71 264.07,68.44 266.95,65.56 267.41,65.56 269.96,63 269.96,60.73 267.7,58.47 267.28,58.47 265.58,56.77 256.26,56.77 254.93,58.1 251.6,58.1 251.12,58.58 242.83,58.58 242.65,58.41 230.79,58.41 228.94,56.55 211.58,56.55 208.01,60.13 208.01,66.35 206.37,67.99 205.77,67.99 204.5,69.26 204.5,69.85 204.11,70.24 198.41,70.24 197.75,69.58 191.58,69.58 190.81,70.35 183.31,70.35 182.25,71.41 179.7,71.41 177.98,69.68 176.37,69.68 176.18,69.49 174.44,69.49 173.19,68.24 172.33,68.24 172.11,68.46 172.11,68.65 172.27,68.81 v2(172.4,68.81)
  BOTTOM w0.076: 175.84,73.28 175.91,73.36 176.3,73.36 176.59,73.65 176.59,74.44 176.67,74.53 U4555.B5
  BOTTOM w0.114: C5398.1 282.12,80.93 282.51,81.32 282.51,81.62 v2(282.07,82.05) ; 175.84,73.28 175.62,73.06 175.55,72.99 173.98,72.99 172.18,71.2 172.18,70.97 172.31,70.84 172.36,70.84 172.5,70.71 172.5,70.52 172.36,70.38 172.31,70.38 172.18,70.25 172.18,70.06 172.31,69.92 172.36,69.92 172.5,69.79 172.5,69.6 172.36,69.47 172.31,69.47 172.18,69.33 172.18,69.02 v2(172.4,68.81)
DPB_DDCCLK: length 150
  TOP w0.114: v2(178.86,59.57) 178.86,60.83 v1(178.99,60.96) 179.99,61.96 181.9,61.96 183.88,63.94 183.88,66.63 182.49,68.02 182.15,68.35 181.66,68.84 179.69,68.84 179.1,69.43 179.1,75.81 v2(178.93,75.98)
  L5 w0.114: v2(178.86,59.57) 180.4,58.03 186.68,58.03 196.95,58.03 197.81,57.17 221.81,57.17 222.94,58.3 229.99,58.3 230.59,58.9 250.99,58.9 251.13,59.04 251.49,59.4 257.73,59.4 258.07,59.74 258.07,59.74 258.29,59.95 261.23,62.89 261.23,63.57 264.15,66.49 264.95,66.49 270.14,71.68 270.14,72.14 271.4,73.41 271.4,76.4 276.07,81.07 280.84,81.07 281.31,80.59 281.31,79.13 v2(281.08,78.9)
  BOTTOM w0.076: U4555.B9 179.22,74.53 178.69,74.01 178.69,73.31 177.65,72.27 177.65,71.66 176.36,70.37
  BOTTOM w0.114: 176.36,70.37 176.36,69.91 175.83,69.38 R4786.1 ; U4555.B9 179.25,74.53 179.25,75.27 178.93,75.6 v2(178.93,75.98) ; U5301.22 281.46,78.47 281.08,78.85 v2(281.08,78.9)
DPB_DDCDATA: length 152.1
  L3 w0.102: v4(175.8,70.09) 175.8,70.83 175.6,71.03 174.33,71.03 174.07,70.77 174.07,70.37 174.21,70.23 174.54,70.23 174.68,70.08 174.68,69.88 174.54,69.74 174.21,69.74 174.07,69.6 174.07,69.4 174.21,69.26 175.4,69.26 175.55,69.12 175.55,68.92 175.4,68.78 174.21,68.78 174.07,68.64 174.07,67.54 174.44,67.17 176.21,67.17 176.59,66.79 176.59,62.52 v3(179.54,59.57)
  L5 w0.114: v3(179.54,59.57) 180.63,58.48 197.08,58.48 198.02,57.54 221.39,57.54 222.57,58.71 229.73,58.71 230.4,59.39 241.03,59.39 250.96,59.39 250.98,59.4 251.58,60.01 257.82,60.01 260.86,63.05 260.86,63.72 263.99,66.86 264.8,66.86 269.77,71.83 269.77,72.3 271.04,73.56 271.04,76.81 275.68,81.45 281.03,81.45 281.7,80.78 v2(281.7,78.9)
  BOTTOM w0.076: v4(175.8,70.09) 175.8,70.14 177.46,71.8 177.46,72.3 178.53,73.37 178.53,74.12 178.89,74.47 U4555.C9
  BOTTOM w0.114: R4787.1 173.39,66.79 173.77,67.17 173.77,67.8 174.28,68.31 174.28,69.84 174.93,70.49 175.4,70.49 v4(175.8,70.09) ; v2(281.7,78.9) 281.86,78.73 U5301.23
DPB_DOCK_CA_DET: length 80.1
  L3 w0.102: CN3601.13 322.04,112.7 320.43,114.31 319.67,114.31 318.8,113.45 318.8,112.51 317.55,111.26 307.22,111.26 306.37,110.42 306.37,108.68 304.86,107.17 304.86,100.39 304.53,100.06 304.53,89.98 304.07,89.52 304.07,89.51 303.97,89.41 303.97,79.46 v3(303.84,79.33)
  L6 w0.102: v3(303.84,79.33) 303.51,79 300.46,79 299.73,78.27 298.62,78.27 296.4,76.04 293.97,76.04 292.77,74.84 291.87,74.84 290.82,73.79 288.44,71.41 286.62,71.41 285.53,72.5 285.53,75.88 v2(286.16,76.52)
  BOTTOM w0.102: U5301.33 v2(286.16,76.52)
DPB_DOCK_CLK_AUX_DP: length 84.8
  L3 w0.102: CN3601.39 324.4,125.8 324.25,125.95 323.9,125.95 323.73,125.79 323.73,125.53 323.8,125.46 323.8,125.44 323.85,125.39 323.85,124.99 323.75,124.9 323.75,124.5 323.83,124.42 323.83,124.36 323.86,124.33 323.86,124.1 323.73,123.97 323.43,123.97 CN3601.36
  L6 w0.114: CN3601.39 322.21,125.7 320.57,124.06 319.82,124.06 318.63,122.87 315.95,122.87 313.6,120.51 313.6,118.31 313.31,118.03 305.32,118.03 302.45,115.16 302.45,113.63 301.65,112.82 299.42,112.82 298.6,112 297.54,112 296.74,111.2 296.09,111.2 295.21,110.31 295.21,108.81 294.46,108.06 291.49,108.06 291.13,108.06 288.4,105.33 288.4,104.87 288.4,95.16 289.1,94.46 289.1,86.61 286.68,84.2 286.68,81.6 286.31,81.22 v2(285.89,81.22)
  BOTTOM w0.114: R5320.1 287.18,79.93 R5316.1 287.18,79.89 287.04,79.75 286.87,79.75 286.72,79.9 286.72,80.45 286.37,80.81 286.24,80.81 285.89,81.15 v2(285.89,81.22) 285.78,81.11 285.05,81.11 284.64,80.69 284.64,79.73 283.85,78.95 283.85,78 U5301.28
DPB_DOCK_DATA_AUX_DN: length 85.4
  L3 w0.102: CN3601.38 323.14,125.2 322.55,124.61 322.55,123.99 322.84,123.7 CN3601.35
  L6 w0.114: v2(285.85,80.42) 286.93,81.5 286.93,84.1 289.34,86.51 289.34,94.56 288.64,95.26 288.64,104.87 288.64,105.23 291.23,107.82 291.49,107.82 294.56,107.82 295.45,108.71 295.45,110.21 296.19,110.96 296.84,110.96 297.64,111.76 298.7,111.76 299.52,112.58 301.75,112.58 302.69,113.53 302.69,115.06 305.42,117.79 313.41,117.79 313.84,118.21 313.84,120.41 316.05,122.63 318.73,122.63 319.92,123.82 320.67,123.82 320.72,123.86 320.91,123.86 321.06,123.71 321.25,123.71 321.38,123.85 321.38,124.04 321.23,124.19 321.23,124.38 321.36,124.51 321.55,124.51 321.7,124.36 321.89,124.36 322.03,124.49 322.03,124.68 321.88,124.83 321.88,125.02 322.05,125.2 CN3601.38
  BOTTOM w0.114: R5319.1 287.99,78.21 R5317.1 287.2,79.1 286.49,79.8 286.49,80.36 286.27,80.58 286.01,80.58 v2(285.85,80.42) 285.85,80.57 285.55,80.88 285.15,80.88 284.87,80.6 284.87,79.64 284.45,79.23 284.21,78.98 284.05,78.83 284.05,78.65 284.26,78.44 U5301.29
DPB_DOCK_HPD: length 87.4
  L6 w0.102: CN3601.34 322.41,123.2 321.35,122.14 316.52,122.14 314.69,120.31 314.69,118.33 313.56,117.21 305.54,117.21 303.18,114.85 303.18,113.32 301.95,112.09 299.72,112.09 298.73,111.1 298.73,109.55 297.84,108.66 296.95,108.66 296.27,107.99 295.61,107.99 294.96,107.33 293.81,107.33 293.4,107.33 293.4,107.33 291.45,107.33 289.16,105.04 289.16,95.48 290.48,94.16 290.48,86.95 287.43,83.91 v2(287.43,82.41)
  BOTTOM w0.102: U5301.38 286.16,74.52 286.3,74.66 286.92,74.66 286.97,74.61 286.97,74.61 287.11,74.48 287.19,74.48 289.15,74.48 v1(289.57,74.89) 289.13,75.32 289.13,81.01 289.97,81.85 289.97,83.55 289.47,84.06 287.43,84.06 287.05,83.68 287.05,82.79 v2(287.43,82.41)
DPB_HPD: length 146.4
  TOP w0.102: v2(169.09,68.39) 169.3,68.18 170.34,68.18 170.97,67.55 v1(170.97,66.03) v2(170.97,65.11)
  L5 w0.102: v2(170.97,65.11) 172.42,63.66 172.84,63.66 174.04,62.46 174.04,61.35 177.73,57.67 186.53,57.67 196.78,57.67 197.63,56.82 197.65,56.82 197.66,56.81 221.96,56.81 223.09,57.94 230.14,57.94 230.74,58.54 240.92,58.54 242.5,56.96 250.28,56.96 251.49,58.17 251.66,58.33 259.14,58.33 266.12,65.31 266.12,67.11 270.54,71.54 271.43,71.54 272.89,73 272.89,73.95 273.64,74.7 274.31,74.7 275.5,73.52 277.53,73.52 278.54,72.5 278.54,71.11 v2(279.2,70.44)
  BOTTOM w0.076: 174.25,71.13 174.34,71.22 174.54,71.22 175.91,71.22 176.08,71.39 176.08,72.03 177.62,73.56 177.62,74.07 177.62,74.08 177.62,74.08 177.95,74.41 177.95,74.77 178.07,74.9 U4555.C8
  BOTTOM w0.102: U5301.3 279.28,70.52 v2(279.2,70.44) ; R4758.1 168.03,69.45 v2(169.09,68.39) 169.42,68.06 172.42,68.06 172.73,68.37 173.19,68.83 173.19,70.07 174.25,71.13
DPB_IN_CA_DET: length 3.2
  BOTTOM w0.102: U5301.4 279.88,70.92 279.81,70.85 278.92,70.85 278.67,70.6 TP5300.1
DPB_PORT_CA_DET: length 81.1
  TOP w0.102: v3(289.26,52.44) 288.91,52.79 288.91,53.22 286.65,55.48 286.65,59.32 286.29,59.68 284.64,59.68 283.37,60.95 283.37,62.27 281.83,63.8 281.83,64.51 281.39,64.96 281.39,70.14 282.35,71.11 283.62,71.11 284.64,72.12 285.78,72.12 v2(286.29,72.63)
  L5 w0.102: v2(318.93,28.81) 318.93,34.96 314.81,39.08 314.81,48.91 312.05,51.67 297.39,51.67 296.88,52.18 294.42,52.18 293.53,53.07 289.9,53.07 v3(289.26,52.44)
  BOTTOM w0.102: CN3300.13 319.51,28.31 318.59,28.31 R3304.1 318.34,28.61 318.55,28.81 v2(318.93,28.81) ; U5301.43 286.18,72.52 v2(286.29,72.63)
DPB_PORT_CLK_AUX_DP: length 100.2
  L3 w0.102: v2(315.32,58.69) 315.46,58.82 315.84,58.82 316.1,59.08 316.1,60.48 315.75,60.82 315.75,75.32 312.02,79.06 306.65,79.06 306.34,78.75 302.65,78.75 301.2,77.3 300.85,77.3 300.74,77.41 v2(300.74,77.41)
  L6 w0.114: v2(315.32,58.69) 315.18,58.82 314.62,58.82 314.39,58.59 314.39,56.83 315.89,55.32 315.89,53.57 316.77,52.69 316.77,37.81 318.19,36.38 318.19,27.15 v2(318.58,26.76)
  BOTTOM w0.114: v2(300.74,77.41) 300.74,77.41 300.55,77.23 300.48,77.23 298.94,78.77 298.94,79.92 298.39,80.47 295.85,80.47 291.12,85.2 286.16,85.2 284.79,83.83 284.79,81.87 283.88,80.95 283.88,80 283.09,79.21 283.09,78.02 U5301.26 ; v2(318.58,26.76) 318.22,27.12 318.22,27.55 R3303.1 318.68,27.67 319.24,27.1 319.55,27.1 CN3300.15
