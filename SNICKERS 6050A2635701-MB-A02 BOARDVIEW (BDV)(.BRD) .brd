# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Library data of the parts (continued)
U9100 = AH9249NTR_G1: part number: AH9249NTR_G1-BCD_AH9249NTR_G1_TSOT23_3P,6019B0944801,IC-HALL_BCD_3_SMD_V_145,1.60MM,,IC,MICROPOWER HALL SWITCH,SOT23,3P,TR; room: Sheet57
X400 = XTAL_4PIN_F: part number: XTAL_4PIN_F-25MHZ_10PF,6018B0054701,XTAL_320X250X090_4_220-2,1.05MM,XTAL_4PIN_F,,,CRYSTAL,25MHZ,20PPM,10PF,SMD,3.2X2.5,TR; room: Sheet49
X2500 = XTAL_4PIN_F: part number: XTAL_4PIN_F-25MHZ_10PF,6018B0054701,XTAL_320X250X090_4_220-2,1.05MM,XTAL_4PIN_F,,,CRYSTAL,25MHZ,20PPM,10PF,SMD,3.2X2.5,TR; room: Sheet41
X3065 = XTAL_4PIN_F: part number: XTAL_4PIN_F-27MHZ_10PF,6018B0057601,XTAL_320X250X090_4-2,1.05MM,XTAL_4PIN_F,,,CRYSTAL,27MHZ,10PPM,10PF,SMD,3.2X2.5X0.8,TR; room: Sheet36
X4750 = XTAL_4PIN: part number: XTAL_4PIN-32.768KHZ,6018A0001401,XPS_700X150X145_4,1.6MM,XTAL_4PIN,,,CRYSTAL,32.768KHZ,20PPM,12.5PF,SMD,7X1.5,TAP; room: Sheet27
X4751 = XTAL_4PIN_F: part number: XTAL_4PIN_F-24MHZ_12PF,6018B0059601,XTAL_320X250X090_4_220-2,1.05MM,XTAL_4PIN_F,,,CRYSTAL,24MHZ,+/-20PPM,12PF,SMD,3.2X2.5X0.75,TR; room: Sheet28

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
AEROSMIT-6012B0335005-002
  round 1.499 hole 0.991: 1(-7,0) 2(-5.001,0) 3(-3,0) 4(-1.001,0) 5(1.001,0) 6(3,0) 7(5.001,0) 8(7,0)
  oval 1.753x3.454 hole 0.991x2.692: G1(-10.127,0) G2(10.124,0)
AUDIO_SIGAT_7_R_265_540
  round 1.245 hole 1.245 unplated: (-3.5,0) (2.002,0)
  oval 1.245x1.753 hole 0.66x1.143: 1(-2.2,6.8) 2(-3.101,5.1) 3(2.349,6.8) 4(3.602,5.301) 5(4.351,2.099) 6(-4.1,6.8) 7(4.35,-0.65)
BTB_SAM_60_050_F_325
  round 1.016 hole 1.016 unplated: (-10.061,0.003) (10.066,0.003)
  rect 0.356x2.362 smd: 1(-7.249,-5.53) 2(-7.249,0.201) 3(-6.749,-5.53) 4(-6.749,0.201) 5(-6.248,-5.53) 6(-6.248,0.201) 7(-5.748,-5.53) 8(-5.748,0.201) 9(-5.248,-5.53) 10(-5.248,0.201) 11(-4.747,-5.53) 12(-4.747,0.201) 13(-4.247,-5.53) 14(-4.247,0.201) 15(-3.747,-5.53) 16(-3.747,0.201) 17(-3.249,-5.53) 18(-3.249,0.201) 19(-2.748,-5.53) 20(-2.748,0.201) 21(-2.248,-5.53) 22(-2.248,0.201) 23(-1.748,-5.53) 24(-1.748,0.201) 25(-1.247,-5.53) 26(-1.247,0.201) 27(-0.749,-5.53) 28(-0.749,0.201) 29(-0.249,-5.53) 30(-0.249,0.201) 31(0.254,-5.53) 32(0.254,0.201) 33(0.754,-5.53) 34(0.754,0.201) 35(1.252,-5.53) 36(1.252,0.201) 37(1.753,-5.53) 38(1.753,0.201) 39(2.253,-5.53) 40(2.253,0.201) 41(2.753,-5.53) 42(2.753,0.201) 43(3.254,-5.53) 44(3.254,0.201) 45(3.754,-5.53) 46(3.754,0.201) 47(4.252,-5.53) 48(4.252,0.201) 49(4.752,-5.53) 50(4.752,0.201) 51(5.253,-5.53) 52(5.253,0.201) 53(5.753,-5.53) 54(5.753,0.201) 55(6.253,-5.53) 56(6.253,0.201) 57(6.751,-5.53) 58(6.751,0.201) 59(7.254,-5.53) 60(7.254,0.201)
COMET-6012B0317701-002
  rect 0.61x1.295 smd: 1(-2.499,3.251) 2(-1.501,3.251) 3(-0.5,3.251) 4(0.5,3.251) 5(1.501,3.251) 6(2.499,3.251)
  rect 0.991x1.803 smd: G1(5.1,0.1) G2(-5.1,0.1)
COMET-6014B0228601-001
  custom 0.591x0.591 smd: 1(-3.025,1.008) 2(3.025,1.008)
  rect 2.057x0.254 smd: 3(-2.873,0) 4(2.873,0)
CPU_INT_BDW_2CGT3_B_400X240
  round 0.508 smd: A3(18.177,-11.314) A62(-18.722,-11.314) AW1(19.314,10.727) AW63(-19.314,10.743) AY2(18.771,11.314) AY62(-18.748,11.314) B2(18.806,-10.806) B63(-19.314,-10.722) C1(19.314,-10.177)
  round 0.381 smd: A4(17.421,-11.314) A5(16.76,-11.314) A6(15.564,-11.314) A59(-16.586,-11.314) A60(-17.412,-11.314) A61(-18.072,-11.314) AA9(14.282,0.262) AA21(7.627,0.175) AA23(6.199,0.175) AA58(-16.063,0.015) AB10(13.838,0.738) AB20(8.135,0.582) AB21(7.627,0.988) AB22(6.707,0.582) AB23(6.199,0.988) AB57(-15.743,0.666) AC9(14.282,1.215) AC20(8.135,1.394) AC22(6.707,1.394) AC58(-16.063,1.316) AD10(13.838,1.691) AD21(7.627,1.801) AD23(6.199,1.801) AD57(-15.743,1.966) AE9(14.282,2.167) AE10(13.838,2.643) AE20(8.135,2.207) AE21(7.627,2.614) AE22(6.707,2.207) AE23(6.199,2.614) AE58(-16.063,2.616) AF9(14.282,3.12) AF11(13.255,2.968) AF12(12.442,2.968) AF14(11.63,2.968) AF15(10.817,2.968) AF17(10.004,2.968) AF18(9.191,2.968) AF20(8.378,2.968) AF22(6.707,3.02) AG10(13.662,3.476) AG11(12.849,3.476) AG13(12.036,3.476) AG14(11.223,3.476) AG16(10.41,3.476) AG17(9.598,3.476) AG19(8.785,3.476) AG20(7.972,3.476) AG23(6.199,3.426) AG57(-15.743,3.267) AG58(-16.377,3.695) AH22(6.707,3.833) AH24(5.394,3.975) AH26(4.094,3.975) AH28(2.793,3.975) AH30(1.493,3.975) AH32(0.192,3.975) AH34(-1.108,3.975) AH36(-2.409,3.975) AH38(-3.709,3.975) AH40(-5.01,3.975) AH42(-6.31,3.975) AH44(-7.611,3.975) AH46(-8.911,3.975) AH49(-10.212,3.975) AH51(-11.512,3.975) AH53(-12.813,3.975) AH55(-14.113,3.975) AH57(-15.413,3.975) AJ23(6.199,4.239) AJ25(4.744,4.3) AJ27(3.443,4.3) AJ29(2.143,4.3) AJ31(0.843,4.3) AJ33(-0.458,4.3) AJ35(-1.758,4.3) AJ37(-3.059,4.3) AJ39(-4.359,4.3) AJ41(-5.66,4.3) AJ43(-6.96,4.3) AJ45(-8.261,4.3) AJ47(-9.561,4.3) AJ50(-10.862,4.3) AJ52(-12.162,4.3) AJ54(-13.463,4.3) AJ56(-14.763,4.3) AJ58(-16.064,4.3) AT1(19.314,8.683) AT63(-19.314,8.533) AU1(19.314,9.343) AU63(-19.314,9.359) AV1(19.314,10.004) AV2(18.654,9.993) AV62(-18.664,10.004) AV63(-19.314,10.019) AW2(18.654,10.654) AW3(17.993,10.654) AW61(-18.014,10.664) AW62(-18.664,10.664) AY3(18.047,11.314) AY4(17.387,11.314) AY5(16.726,11.314) AY59(-16.774,11.314) AY60(-17.434,11.314) AY61(-18.095,11.314) B3(18.056,-10.664) B61(-18.001,-10.654) B62(-18.664,-10.59) C2(18.664,-10.056) C62(-18.664,-9.93) C63(-19.314,-9.998) D1(19.314,-9.453) D63(-19.314,-9.338) E1(19.314,-8.792) E23(5.981,-8.713) E25(4.6,-8.713) E27(3.474,-8.713) E29(2.093,-8.713) E31(0.966,-8.713) E33(-0.415,-8.713) E35(-1.541,-8.713) E37(-2.922,-8.713) E39(-4.049,-8.713) E41(-5.43,-8.713) E43(-6.556,-8.713) E45(-7.937,-8.713) E47(-9.064,-8.713) E49(-10.444,-8.713) E51(-11.571,-8.713) E53(-12.952,-8.713) E55(-14.079,-8.713) E57(-15.459,-8.713) E63(-19.314,-8.667) F1(19.314,-7.878) F22(6.597,-8.256) F24(5.291,-8.188) F26(4.037,-8.188) F28(2.783,-8.188) F30(1.53,-8.188) F32(0.276,-8.188) F34(-0.978,-8.188) F36(-2.232,-8.188) F38(-3.485,-8.188) F40(-4.739,-8.188) F42(-5.993,-8.188) F44(-7.247,-8.188) F46(-8.5,-8.188) F48(-9.754,-8.188) F50(-11.008,-8.188) F52(-12.262,-8.188) F54(-13.515,-8.188) F56(-14.769,-8.188) F58(-16.063,-8.188) G22(6.707,-7.546) G23(5.981,-7.863) G25(4.6,-7.863) G27(3.474,-7.863) G29(2.093,-7.863) G31(0.966,-7.863) G33(-0.415,-7.863) G35(-1.541,-7.863) G37(-2.922,-7.863) G39(-4.049,-7.863) G41(-5.43,-7.863) G43(-6.556,-7.863) G45(-7.937,-7.863) G47(-9.064,-7.863) G49(-10.444,-7.863) G51(-11.571,-7.863) G53(-12.952,-7.863) G55(-14.079,-7.863) G57(-15.459,-7.863) H22(6.707,-6.734) H23(6.199,-7.14) H57(-15.743,-7.213) J22(6.707,-5.921) J23(6.199,-6.327) J58(-16.063,-6.487) K9(14.282,-5.453) K10(13.379,-5.614) K12(12.426,-5.614) K14(11.474,-5.614) K16(10.521,-5.614) K18(9.569,-5.614) K19(8.616,-5.614) K21(7.664,-5.614) K23(6.199,-5.514) K57(-15.743,-5.837) L10(13.838,-4.977) L11(12.902,-5.17) L13(11.95,-5.17) L15(10.997,-5.17) L17(10.045,-5.17) L18(9.092,-5.17) L20(8.135,-5.108) L22(6.707,-5.108) L58(-16.063,-5.186) M9(14.282,-4.5) M20(8.135,-4.295) M21(7.627,-4.702) M22(6.707,-4.295) M23(6.199,-4.702) M57(-15.743,-4.536) N10(13.838,-4.024) N21(7.627,-3.889) N23(6.199,-3.889) N58(-16.063,-3.886) P9(14.282,-3.548) P20(8.135,-3.482) P22(6.707,-3.482) P57(-15.743,-3.236) R10(13.838,-3.072) R20(8.135,-2.67) R21(7.627,-3.076) R22(6.707,-2.67) R23(6.199,-3.076) T9(14.282,-2.595) T21(7.627,-2.263) T23(6.199,-2.263) T58(-16.063,-2.585) U9(14.282,-1.643) U10(13.838,-2.119) U20(8.135,-1.857) U22(6.707,-1.857) U57(-15.743,-1.935) V10(13.838,-1.167) V21(7.627,-1.45) V23(6.199,-1.45) V58(-16.063,-1.285) W9(14.282,-0.69) W20(8.135,-1.044) W21(7.627,-0.638) W22(6.707,-1.044) W23(6.199,-0.638) W57(-15.743,-0.635) Y10(13.838,-0.214) Y20(8.135,-0.231) Y22(6.707,-0.231)
  round 0.305 smd: A8(14.776,-11.314) A9(13.862,-11.314) A11(12.948,-11.314) A12(12.198,-11.314) A14(11.284,-11.314) A15(10.37,-11.314) A17(9.62,-11.314) A18(8.706,-11.314) A20(7.791,-11.314) A21(7.042,-11.314) A23(6.128,-11.314) A24(5.291,-10.989) A25(4.6,-11.314) A27(3.474,-11.314) A28(2.783,-10.989) A29(2.093,-11.314) A31(0.966,-11.314) A32(0.276,-10.989) A33(-0.415,-11.314) A35(-1.541,-11.314) A36(-2.232,-10.989) A37(-2.922,-11.314) A39(-4.049,-11.314) A40(-4.739,-10.989) A41(-5.43,-11.314) A43(-6.556,-11.314) A44(-7.247,-10.989) A45(-7.937,-11.314) A47(-9.064,-11.314) A48(-9.754,-10.989) A49(-10.444,-11.314) A51(-11.571,-11.314) A52(-12.262,-10.989) A53(-12.952,-11.314) A55(-14.079,-11.314) A56(-14.769,-10.989) A57(-15.459,-11.314) AA1(19.314,0.402) AA2(18.664,0.402) AA3(18.014,0.364) AA4(17.363,0.364) AA59(-16.713,0.324) AA60(-17.363,0.324) AA61(-18.014,0.324) AA62(-18.664,0.362) AA63(-19.314,0.362) AB5(16.678,0.738) AB6(16.027,0.738) AB7(15.377,0.738) AB8(14.727,0.738) AC1(19.314,1.152) AC2(18.664,1.152) AC3(18.014,1.19) AC4(17.363,1.19) AC59(-16.713,1.15) AC60(-17.363,1.15) AC61(-18.014,1.15) AC62(-18.664,1.112) AC63(-19.314,1.112) AD1(19.314,1.901) AD2(18.664,1.901) AD3(18.014,1.863) AD4(17.363,1.863) AD5(16.678,1.691) AD6(16.027,1.691) AD7(15.377,1.691) AD8(14.727,1.691) AD59(-16.713,1.823) AD60(-17.363,1.823) AD61(-18.014,1.823) AD62(-18.664,1.861) AD63(-19.314,1.861) AE5(16.678,2.643) AE6(16.027,2.643) AE7(15.377,2.643) AE8(14.727,2.643) AE59(-16.713,2.648) AE60(-17.363,2.648) AE61(-18.014,2.648) AE62(-18.664,2.61) AE63(-19.314,2.61) AF1(19.314,2.65) AF2(18.664,2.65) AF3(18.014,2.688) AF4(17.363,2.688) AG1(19.314,3.4) AG2(18.664,3.4) AG3(18.014,3.361) AG4(17.363,3.361) AG5(16.678,3.596) AG6(16.027,3.596) AG7(15.377,3.596) AG8(14.727,3.596) AG21(7.359,3.807) AG60(-17.038,3.288) AG61(-17.689,3.288) AG62(-18.339,3.288) AG63(-18.989,3.288) AH1(19.314,4.149) AH2(18.664,4.149) AH3(18.014,4.187) AH4(17.363,4.187) AH10(13.662,4.162) AH11(12.849,4.162) AH13(12.036,4.162) AH14(11.223,4.162) AH16(10.41,4.162) AH17(9.598,4.162) AH19(8.785,4.162) AH20(7.972,4.162) AH60(-17.363,3.964) AH61(-18.014,3.964) AH62(-18.664,3.964) AH63(-19.314,3.964) AJ5(16.678,4.548) AJ6(16.027,4.548) AJ7(15.377,4.548) AJ8(14.727,4.548) AJ10(13.662,4.812) AJ11(12.849,4.812) AJ13(12.036,4.812) AJ14(11.223,4.812) AJ60(-17.038,4.64) AJ61(-17.689,4.64) AJ62(-18.339,4.64) AJ63(-18.989,4.64) AK1(19.314,4.898) AK2(18.664,4.898) AK3(18.014,4.86) AK4(17.363,4.86) AK8(15.011,5.137) AK18(9.466,4.952) AK20(8.513,4.952) AK21(7.561,4.952) AK60(-17.363,5.209) AK61(-18.014,5.209) AK62(-18.664,5.315) AK63(-19.314,5.315) AL1(19.314,5.647) AL2(18.664,5.647) AL3(18.014,5.686) AL4(17.363,5.686) AL5(16.413,5.462) AL7(15.575,5.462) AL8(15.011,5.787) AL10(13.657,5.462) AL11(13.093,5.787) AL13(11.738,5.462) AL15(11.174,5.787) AL17(10.092,5.268) AL18(9.466,5.602) AL20(8.513,5.602) AL21(7.561,5.602) AL22(6.608,5.602) AL23(5.786,5.602) AL25(4.81,5.602) AL26(3.858,5.602) AL28(2.905,5.602) AL29(1.953,5.602) AL31(1.054,5.277) AL32(0.49,5.602) AL33(-0.412,5.602) AL35(-1.415,5.602) AL36(-2.266,5.602) AL38(-3.32,5.602) AL39(-4.228,5.277) AL40(-4.817,5.602) AL42(-5.63,5.602) AL43(-6.582,5.602) AL45(-7.56,5.602) AL46(-8.487,5.602) AL48(-9.542,5.602) AL49(-10.443,5.602) AL51(-11.447,5.602) AL52(-12.269,5.602) AL54(-13.295,5.602) AL55(-14.248,5.602) AL57(-15.195,5.602) AL58(-16.094,5.602) AL60(-17.038,5.855) AL61(-17.689,5.855) AM1(19.314,6.397) AM2(18.664,6.397) AM3(18.014,6.359) AM4(17.363,6.359) AM5(16.413,6.112) AM7(15.575,6.112) AM8(15.011,6.437) AM10(13.657,6.112) AM11(13.093,6.437) AM13(11.738,6.112) AM15(11.174,6.437) AM17(10.092,5.919) AM18(9.466,6.252) AM20(8.513,6.252) AM21(7.561,6.252) AM22(6.608,6.252) AM23(5.786,6.252) AM25(4.81,6.252) AM26(3.858,6.252) AM28(2.905,6.252) AM29(1.953,6.252) AM31(1.054,5.927) AM32(0.49,6.252) AM33(-0.412,6.252) AM35(-1.415,6.252) AM36(-2.266,6.252) AM38(-3.32,6.252) AM40(-4.817,6.252) AM42(-5.63,6.252) AM43(-6.582,6.252) AM45(-7.56,6.252) AM46(-8.487,6.252) AM48(-9.542,6.252) AM49(-10.443,6.252) AM51(-11.447,6.252) AM52(-12.269,6.252) AM54(-13.295,6.252) AM55(-14.248,6.252) AM57(-15.195,6.252) AM58(-16.094,6.252) AM60(-17.363,6.501) AM61(-18.014,6.501) AM62(-18.664,6.395) AM63(-19.314,6.395) AN1(19.314,7.146) AN2(18.664,7.146) AN3(18.014,7.184) AN4(17.363,7.184) AN5(16.413,6.762) AN7(15.575,6.762) AN8(15.011,7.088) AN10(13.657,6.762) AN11(13.093,7.088) AN13(11.738,6.762) AN15(11.174,7.088) AN17(10.092,6.569) AN18(9.466,6.903) AN20(8.513,6.903) AN21(7.561,6.903) AN22(6.608,6.903) AN23(5.786,6.903) AN25(4.81,6.903) AN26(3.858,6.903) AN28(2.905,6.903) AN29(1.953,6.903) AN31(1.054,6.578) AN32(0.49,6.903) AN33(-0.412,6.903) AN35(-1.415,6.903) AN36(-2.266,6.903) AN38(-3.32,6.903) AN39(-4.228,6.578) AN40(-4.817,6.903) AN42(-5.63,6.903) AN43(-6.582,6.903) AN45(-7.56,6.903) AN46(-8.487,6.903) AN48(-9.542,6.903) AN49(-10.443,6.903) AN51(-11.447,6.903) AN52(-12.269,6.903) AN54(-13.295,6.903) AN55(-14.248,6.903) AN57(-15.195,6.903) AN58(-16.094,6.903) AN60(-17.038,7.07) AN61(-17.689,7.07) AN62(-18.339,7.07) AN63(-18.989,7.07) AP1(19.314,7.895) AP2(18.664,7.895) AP3(18.014,7.857) AP4(17.363,7.857) AP5(16.413,7.413) AP7(15.575,7.413) AP8(15.011,7.738) AP10(13.657,7.413) AP11(13.093,7.738) AP13(11.738,7.413) AP15(11.174,7.738) AP17(10.092,7.219) AP18(9.466,7.553) AP20(8.513,7.553) AP21(7.561,7.553) AP22(6.608,7.553) AP23(5.786,7.553) AP25(4.81,7.553) AP26(3.858,7.553) AP28(2.905,7.553) AP29(1.953,7.553) AP31(1.054,7.228) AP32(0.49,7.553) AP33(-0.412,7.553) AP35(-1.415,7.553) AP36(-2.266,7.553) AP38(-3.32,7.553) AP39(-4.228,7.228) AP40(-4.817,7.553) AP42(-5.63,7.553) AP43(-6.582,7.553) AP45(-7.56,7.553) AP46(-8.487,7.553) AP48(-9.542,7.553) AP49(-10.443,7.553) AP51(-11.447,7.553) AP52(-12.269,7.553) AP54(-13.295,7.553) AP55(-14.248,7.553) AP57(-15.195,7.553) AP58(-16.094,7.553) AP60(-17.363,7.746) AP61(-18.014,7.746) AP62(-18.664,7.746) AP63(-19.314,7.746) AR5(16.413,8.063) AR7(15.575,8.063) AR8(15.011,8.388) AR10(13.657,8.063) AR11(13.093,8.388) AR13(11.738,8.063) AR15(11.174,8.388) AR17(10.092,7.869) AR18(9.466,8.203) AR20(8.513,8.203) AR21(7.561,8.203) AR22(6.608,8.203) AR23(5.786,8.203) AR25(4.81,8.203) AR26(3.858,8.203) AR28(2.905,8.203) AR29(1.953,8.203) AR31(1.054,7.878) AR32(0.49,8.203) AR33(-0.412,8.203) AR35(-1.415,8.203) AR36(-2.266,8.203) AR38(-3.32,8.203) AR39(-4.228,7.878) AR40(-4.817,8.203) AR42(-5.63,8.203) AR43(-6.582,8.203) AR45(-7.56,8.203) AR46(-8.487,8.203) AR48(-9.542,8.203) AR49(-10.443,8.203) AR51(-11.447,8.203) AR52(-12.269,8.203) AR54(-13.295,8.203) AR55(-14.248,8.203) AR57(-15.195,8.203) AR58(-16.094,8.203) AT2(18.664,8.645) AT3(18.014,8.683) AT4(17.363,8.683) AT5(16.413,8.713) AT7(15.575,8.713) AT10(13.657,8.713) AT13(11.738,8.713) AT35(-1.122,8.905) AT37(-2.697,8.905) AT40(-4.272,8.905) AT42(-5.847,8.905) AT43(-7.422,8.905) AT46(-8.996,8.905) AT49(-10.597,8.933) AT61(-17.689,8.32) AT62(-18.498,8.376) AU2(18.659,9.333) AU3(17.999,9.333) AU4(17.338,9.333) AU6(15.977,9.363) AU7(15.151,9.363) AU8(14.478,9.363) AU10(13.653,9.363) AU11(12.98,9.363) AU12(12.154,9.363) AU14(11.481,9.363) AU15(10.656,9.363) AU16(10.092,9.038) AU17(9.454,9.363) AU18(8.778,9.038) AU19(8.21,9.363) AU20(7.563,9.038) AU21(6.917,9.363) AU22(6.348,9.038) AU23(5.672,9.363) AU24(4.996,9.038) AU25(4.321,9.363) AU26(3.645,9.038) AU27(3.076,9.363) AU28(2.43,9.038) AU29(1.783,9.363) AU30(1.214,9.038) AU31(0.539,9.363) AU33(-0.058,9.016) AU34(-0.66,9.363) AU35(-1.585,9.363) AU36(-2.235,9.363) AU37(-3.16,9.363) AU39(-3.81,9.363) AU40(-4.734,9.363) AU41(-5.385,9.363) AU42(-6.309,9.363) AU43(-6.959,9.363) AU44(-7.884,9.363) AU46(-8.534,9.363) AU47(-9.459,9.363) AU49(-10.109,9.363) AU50(-11.086,9.363) AU51(-11.666,9.038) AU52(-12.342,9.363) AU53(-13.017,9.038) AU54(-13.586,9.363) AU55(-14.233,9.038) AU56(-14.879,9.363) AU57(-15.448,9.038) AU58(-16.124,9.363) AU59(-16.688,9.038) AU60(-17.251,9.363) AU61(-17.963,9.087) AU62(-18.664,9.349) AV3(17.993,9.993) AV4(17.338,9.993) AV5(16.65,10.014) AV6(15.977,10.014) AV7(15.151,10.014) AV8(14.478,10.014) AV10(13.653,10.014) AV11(12.98,10.014) AV12(12.154,10.014) AV14(11.481,10.014) AV15(10.656,10.014) AV16(10.092,9.689) AV17(9.454,10.014) AV18(8.778,9.689) AV19(8.21,10.014) AV20(7.563,9.689) AV21(6.917,10.014) AV22(6.348,9.689) AV23(5.672,10.014) AV24(4.996,9.689) AV25(4.321,10.014) AV26(3.645,9.689) AV27(3.076,10.014) AV28(2.43,9.689) AV29(1.783,10.014) AV30(1.214,9.689) AV31(0.539,10.014) AV33(-0.086,9.689) AV34(-0.71,10.014) AV35(-1.535,10.014) AV36(-2.284,10.014) AV37(-3.11,10.014) AV39(-3.859,10.014) AV40(-4.685,10.014) AV41(-5.434,10.014) AV42(-6.26,10.014) AV43(-7.009,10.014) AV44(-7.834,10.014) AV46(-8.584,10.014) AV47(-9.409,10.014) AV49(-10.158,10.014) AV50(-10.984,10.014) AV51(-11.666,9.689) AV52(-12.342,10.014) AV53(-13.017,9.689) AV54(-13.586,10.014) AV55(-14.233,9.689) AV56(-14.879,10.014) AV57(-15.448,9.689) AV58(-16.124,10.014) AV59(-16.688,9.689) AV60(-17.251,10.014) AV61(-17.988,9.737) AW4(17.338,10.654) AW5(16.688,10.664) AW6(15.939,10.664) AW7(15.189,10.664) AW8(14.44,10.664) AW10(13.691,10.664) AW11(12.942,10.664) AW12(12.192,10.664) AW14(11.443,10.664) AW15(10.694,10.664) AW16(10.092,10.339) AW17(9.454,10.664) AW18(8.778,10.339) AW19(8.103,10.664) AW21(7.023,10.664) AW22(6.348,10.339) AW23(5.672,10.664) AW24(4.996,10.339) AW25(4.321,10.664) AW26(3.645,10.339) AW27(2.97,10.664) AW29(1.89,10.664) AW30(1.214,10.339) AW31(0.539,10.664) AW33(-0.137,10.339) AW34(-0.71,10.664) AW35(-1.535,10.664) AW36(-2.284,10.664) AW37(-3.11,10.664) AW39(-3.859,10.664) AW40(-4.685,10.664) AW41(-5.434,10.664) AW42(-6.26,10.664) AW43(-7.009,10.664) AW44(-7.834,10.664) AW46(-8.584,10.664) AW47(-9.409,10.664) AW49(-10.158,10.664) AW50(-10.984,10.664) AW51(-11.666,10.339) AW52(-12.342,10.664) AW53(-13.017,10.339) AW54(-13.693,10.664) AW56(-14.772,10.664) AW57(-15.448,10.339) AW58(-16.124,10.664) AW59(-16.688,10.339) AW60(-17.251,10.664) AY6(15.939,11.314) AY7(15.189,11.314) AY8(14.44,11.314) AY10(13.691,11.314) AY11(12.942,11.314) AY12(12.192,11.314) AY14(11.443,11.314) AY15(10.694,11.314) AY16(10.13,10.989) AY17(9.454,11.314) AY18(8.778,10.989) AY19(8.103,11.314) AY21(7.023,11.314) AY22(6.348,10.989) AY23(5.672,11.314) AY24(4.996,10.989) AY25(4.321,11.314) AY26(3.645,10.989) AY27(2.97,11.314) AY29(1.89,11.314) AY30(1.214,10.989) AY31(0.539,11.314) AY33(-0.137,10.989) AY34(-0.71,11.314) AY35(-1.535,11.314) AY36(-2.284,11.314) AY37(-3.11,11.314) AY39(-3.859,11.314) AY40(-4.685,11.314) AY41(-5.434,11.314) AY42(-6.26,11.314) AY43(-7.009,11.314) AY44(-7.834,11.314) AY46(-8.584,11.314) AY47(-9.409,11.314) AY49(-10.158,11.314) AY50(-10.984,11.314) AY51(-11.666,10.989) AY52(-12.342,11.314) AY53(-13.017,10.989) AY54(-13.693,11.314) AY56(-14.772,11.314) AY57(-15.448,10.989) AY58(-16.124,11.314) B4(17.393,-10.664) B5(16.176,-10.672) B6(15.196,-10.672) B8(14.423,-10.672) B9(13.598,-10.672) B11(12.617,-10.672) B12(11.845,-10.672) B14(11.02,-10.672) B15(10.039,-10.672) B17(9.267,-10.672) B18(8.442,-10.672) B20(7.461,-10.672) B21(7.042,-10.118) B22(6.689,-10.672) B23(5.864,-10.672) B24(5.291,-10.339) B25(4.6,-10.664) B26(4.037,-10.339) B27(3.474,-10.664) B28(2.783,-10.339) B29(2.093,-10.664) B30(1.53,-10.339) B31(0.966,-10.664) B32(0.276,-10.339) B33(-0.415,-10.664) B34(-0.978,-10.339) B35(-1.541,-10.664) B36(-2.232,-10.339) B37(-2.922,-10.664) B38(-3.485,-10.339) B39(-4.049,-10.664) B40(-4.739,-10.339) B41(-5.43,-10.664) B42(-5.993,-10.339) B43(-6.556,-10.664) B44(-7.247,-10.339) B45(-7.937,-10.664) B46(-8.5,-10.339) B47(-9.064,-10.664) B48(-9.754,-10.339) B49(-10.444,-10.664) B50(-11.008,-10.339) B51(-11.571,-10.664) B52(-12.262,-10.339) B53(-12.952,-10.664) B54(-13.515,-10.339) B55(-14.079,-10.664) B56(-14.769,-10.339) B57(-15.459,-10.664) B58(-16.023,-10.339) B59(-16.586,-10.664) B60(-17.351,-10.654) C3(18.012,-10.012) C4(17.196,-10.042) C5(16.542,-10.118) C6(15.538,-10.118) C8(14.776,-10.118) C9(13.964,-10.118) C11(12.96,-10.118) C12(12.198,-10.118) C14(11.386,-10.118) C15(10.382,-10.118) C17(9.62,-10.118) C18(8.807,-10.118) C20(7.804,-10.118) C21(7.423,-9.529) C22(6.636,-9.529) C23(6.229,-10.118) C24(5.263,-9.282) C25(4.6,-10.014) C26(4.037,-9.689) C27(3.474,-10.014) C28(2.756,-9.282) C29(2.093,-10.014) C30(1.53,-9.689) C31(0.966,-10.014) C32(0.248,-9.282) C33(-0.415,-10.014) C34(-0.978,-9.689) C35(-1.541,-10.014) C36(-2.259,-9.282) C37(-2.922,-10.014) C38(-3.485,-9.689) C39(-4.049,-10.014) C40(-4.767,-9.282) C41(-5.43,-10.014) C42(-5.993,-9.689) C43(-6.556,-10.014) C44(-7.274,-9.282) C45(-7.937,-10.014) C46(-8.5,-9.689) C47(-9.064,-10.014) C48(-9.756,-9.282) C49(-10.444,-10.014) C50(-11.008,-9.689) C51(-11.571,-10.014) C52(-12.264,-9.323) C53(-12.952,-10.014) C54(-13.515,-9.689) C55(-14.079,-10.014) C56(-14.771,-9.323) C57(-15.459,-10.014) C58(-16.023,-9.689) C59(-16.586,-10.014) C61(-17.689,-10.077) D2(18.664,-9.24) D3(18.014,-9.278) D5(16.636,-9.472) D6(15.945,-9.529) D8(15.157,-9.529) D9(14.37,-9.529) D11(13.462,-9.529) D12(12.579,-9.529) D14(11.792,-9.529) D15(10.884,-9.529) D17(10.001,-9.529) D18(9.214,-9.529) D20(8.306,-9.529) D21(7.079,-8.891) D23(5.937,-9.529) D25(4.6,-9.363) D26(4.037,-9.038) D27(3.474,-9.363) D29(2.093,-9.363) D30(1.53,-9.038) D31(0.966,-9.363) D33(-0.415,-9.363) D34(-0.978,-9.038) D35(-1.541,-9.363) D37(-2.922,-9.363) D38(-3.485,-9.038) D39(-4.049,-9.363) D41(-5.43,-9.363) D42(-5.993,-9.038) D43(-6.556,-9.363) D45(-7.937,-9.363) D46(-8.5,-9.038) D47(-9.064,-9.363) D49(-10.444,-9.363) D50(-11.008,-9.038) D51(-11.571,-9.363) D53(-12.952,-9.363) D54(-13.515,-9.038) D55(-14.079,-9.363) D57(-15.459,-9.363) D58(-16.023,-9.038) D59(-16.586,-9.363) D60(-17.363,-9.513) D61(-18.014,-9.513) D62(-18.664,-9.28) E2(18.664,-8.589) E3(18.014,-8.627) E4(17.363,-8.627) E5(16.712,-8.695) E6(15.76,-8.695) E8(14.807,-8.695) E10(13.855,-8.695) E11(12.902,-8.695) E13(11.95,-8.695) E15(10.997,-8.695) E17(10.045,-8.695) E18(9.092,-8.695) E20(8.14,-8.695) E59(-16.713,-8.667) E60(-17.363,-8.667) E61(-18.014,-8.667) E62(-18.664,-8.629) F2(18.664,-7.84) F3(18.014,-7.802) F4(17.363,-7.802) F5(16.712,-8.045) F6(15.76,-8.045) F8(14.807,-8.045) F10(13.855,-8.045) F11(12.902,-8.045) F13(11.95,-8.045) F15(10.997,-8.045) F17(10.045,-8.045) F18(9.092,-8.045) F20(8.14,-8.045) F59(-16.713,-7.842) F60(-17.363,-7.842) F61(-18.014,-7.842) F62(-18.664,-7.88) F63(-19.314,-7.88) G1(19.314,-7.091) G2(18.664,-7.091) G3(18.014,-7.129) G4(17.363,-7.129) G5(16.712,-7.395) G6(15.76,-7.395) G8(14.807,-7.395) G10(13.855,-7.395) G11(12.902,-7.395) G13(11.95,-7.395) G15(10.997,-7.395) G17(10.045,-7.395) G18(9.092,-7.395) G20(8.14,-7.395) H5(16.712,-6.745) H6(15.76,-6.745) H8(14.807,-6.745) H10(13.855,-6.745) H11(12.902,-6.745) H13(11.95,-6.745) H15(10.997,-6.745) H17(10.045,-6.745) H18(9.092,-6.745) H20(8.14,-6.745) H59(-16.713,-7.169) H60(-17.363,-7.169) H61(-18.014,-7.169) H62(-18.664,-7.131) H63(-19.314,-7.131) J1(19.314,-6.341) J2(18.664,-6.341) J3(18.014,-6.303) J4(17.363,-6.303) J5(16.687,-6.094) J6(15.747,-6.094) J8(14.807,-6.094) J10(13.855,-6.094) J11(12.902,-6.094) J13(11.95,-6.094) J15(10.997,-6.094) J17(10.045,-6.094) J18(9.092,-6.094) J20(8.14,-6.094) J21(7.219,-6.328) J59(-16.713,-6.343) J60(-17.363,-6.343) J61(-18.014,-6.343) J62(-18.664,-6.381) J63(-19.314,-6.381) K1(19.314,-5.592) K2(18.664,-5.592) K3(18.014,-5.63) K4(17.363,-5.63) K59(-16.713,-5.67) K60(-17.363,-5.67) K61(-18.014,-5.67) K62(-18.664,-5.632) K63(-19.314,-5.632) L1(19.314,-4.843) L2(18.664,-4.843) L3(18.014,-4.805) L4(17.363,-4.805) L5(16.678,-4.977) L6(16.027,-4.977) L7(15.377,-4.977) L8(14.727,-4.977) L59(-16.713,-4.845) L60(-17.363,-4.845) L61(-18.014,-4.845) L62(-18.664,-4.883) L63(-19.314,-4.883) N1(19.314,-4.093) N2(18.664,-4.093) N3(18.014,-4.132) N4(17.363,-4.132) N5(16.678,-4.024) N6(16.027,-4.024) N7(15.377,-4.024) N8(14.727,-4.024) N59(-16.713,-4.172) N60(-17.363,-4.172) N61(-18.014,-4.172) N62(-18.664,-4.134) N63(-19.314,-4.134) P1(19.314,-3.344) P2(18.664,-3.344) P3(18.014,-3.306) P4(17.363,-3.306) P59(-16.713,-3.346) P60(-17.363,-3.346) P61(-18.014,-3.346) P62(-18.664,-3.384) P63(-19.314,-3.384) R5(16.678,-3.072) R6(16.027,-3.072) R7(15.377,-3.072) R8(14.727,-3.072) T1(19.314,-2.595) T2(18.664,-2.595) T3(18.014,-2.633) T4(17.363,-2.633) T59(-16.713,-2.673) T60(-17.363,-2.673) T61(-18.014,-2.673) T62(-18.664,-2.635) T63(-19.314,-2.635) U1(19.314,-1.846) U2(18.664,-1.846) U3(18.014,-1.807) U4(17.363,-1.807) U5(16.678,-2.119) U6(16.027,-2.119) U7(15.377,-2.119) U8(14.727,-2.119) U59(-16.713,-1.848) U60(-17.363,-1.848) U61(-18.014,-1.848) U62(-18.664,-1.886) U63(-19.314,-1.886) V1(19.314,-1.096) V2(18.664,-1.096) V3(18.014,-1.134) V4(17.363,-1.134) V5(16.678,-1.167) V6(16.027,-1.167) V7(15.377,-1.167) V8(14.727,-1.167) V59(-16.713,-1.174) V60(-17.363,-1.174) V61(-18.014,-1.174) V62(-18.664,-1.136) V63(-19.314,-1.136) Y1(19.314,-0.347) Y2(18.664,-0.347) Y3(18.014,-0.309) Y4(17.363,-0.309) Y5(16.678,-0.214) Y6(16.027,-0.214) Y7(15.377,-0.214) Y8(14.727,-0.214) Y59(-16.713,-0.349) Y60(-17.363,-0.349) Y61(-18.014,-0.349) Y62(-18.664,-0.387) Y63(-19.314,-0.387)
  round 0.33 smd: AK22(6.659,4.952) AK23(5.786,4.952) AK25(4.81,4.952) AK26(3.858,4.952) AK28(2.905,4.952) AK29(2.004,4.952) AK32(0.49,4.952) AK33(-0.412,4.952) AK35(-1.415,4.952) AK36(-2.266,4.952) AK38(-3.295,4.952) AK40(-4.792,4.952) AK42(-5.63,4.952) AK43(-6.582,4.952) AK45(-7.56,4.952) AK46(-8.462,4.952) AK48(-9.516,4.952) AK49(-10.418,4.952) AK51(-11.421,4.952) AK52(-12.269,4.952) AK54(-13.295,4.952) AK55(-14.248,4.952) AK57(-15.195,4.952) AK58(-16.094,4.952)
CS_350X280X200_2
  rect 1.6x2.692 smd: 1(-1.501,0) 2(1.501,0)
CS_730X430X210_2
  rect 2.388x2.794 smd: 1(-3.2,0) 2(3.2,0)
CSC_100X050X040_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
CSC_100X050X055_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
CSC_160X080X080_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
CSC_160X080X090_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
CSC_200X125X130_2
  rect 0.813x1.295 smd: 1(-0.9,0) 2(0.9,0)
CSC_200X125X140_2
  rect 0.813x1.295 smd: 1(-0.9,0) 2(0.9,0)
CSC_460X200X180_2
  rect 1.778x2.413 smd: 1(-1.905,0) 2(1.905,0)
CST_320X160X180_2_245
  rect 1.346x1.499 smd: 1(-1.227,0) 2(1.227,0)
CSTJB_350X280X200_2_300
  rect 1.6x2.692 smd: 1(-1.501,0) 2(1.501,0)
DB10SG-6019B0999601-002
  custom 0.074x0.074 smd: 1(-1.6,-1.676) 2(-1.2,-1.676) 3(-0.8,-1.676) 6(-0.8,1.676) 7(-1.2,1.676) 8(-1.6,1.676)
  custom 0.159x0.159 smd: 4(0.6,-1.651) 5(0.6,1.651)
  rect 4.039x2.108 smd: 9(0,0)
DC_SIGAT_3_R_145_358
  oval 1.6x1.092 hole 1.194x0.711: 1(2.675,5.1) 3(-2.675,5.1)
  oval 1.092x1.6 hole 0.711x1.194: 2(0,5.1)
  oval 1.041x1.803 hole 0.66x1.397: 4(-6.35,2.601) 7(6.35,2.601)
  oval 0.991x2.794 hole 0.61x2.388: 5(-6.35,0) 6(-6.35,-6.5) 8(6.35,0) 9(6.35,-6.5)
DDR3_FOX_204_RV_400_4
  round 1.092 hole 1.092 unplated: (-33.401,0)
  round 1.6 hole 1.6 unplated: (33.401,0)
  rect 0.457x2.261 smd: 1(31.651,4.227) 2(31.351,-4.229) 3(31.052,4.227) 4(30.749,-4.229) 5(30.45,4.227) 6(30.15,-4.229) 7(29.85,4.227) 8(29.55,-4.229) 9(29.251,4.227) 10(28.951,-4.229) 11(28.651,4.227) 12(28.351,-4.229) 13(28.049,4.227) 14(27.75,-4.229) 15(27.45,4.227) 16(27.15,-4.229) 17(26.85,4.227) 18(26.551,-4.229) 19(26.251,4.227) 20(25.949,-4.229) 21(25.651,4.227) 22(25.349,-4.229) 23(25.049,4.227) 24(24.75,-4.229) 25(24.45,4.227) 26(24.15,-4.229) 27(23.851,4.227) 28(23.551,-4.229) 29(23.251,4.227) 30(22.951,-4.229) 31(22.649,4.227) 32(22.349,-4.229) 33(22.05,4.227) 34(21.75,-4.229) 35(21.45,4.227) 36(21.148,-4.229) 37(20.851,4.227) 38(20.551,-4.229) 39(20.251,4.227) 40(19.949,-4.229) 41(19.649,4.227) 42(19.35,-4.229) 43(19.05,4.227) 44(18.75,-4.229) 45(18.451,4.227) 46(18.151,-4.229) 47(17.851,4.227) 48(17.551,-4.229) 49(17.249,4.227) 50(16.949,-4.229) 51(16.65,4.227) 52(16.35,-4.229) 53(16.05,4.227) 54(15.751,-4.229) 55(15.451,4.227) 56(15.151,-4.229) 57(14.851,4.227) 58(14.549,-4.229) 59(14.249,4.227) 60(13.95,-4.229) 61(13.65,4.227) 62(13.35,-4.229) 63(13.051,4.227) 64(12.751,-4.229) 65(12.449,4.227) 66(12.151,-4.229) 67(11.849,4.227) 68(11.549,-4.229) 69(11.25,4.227) 70(10.95,-4.229) 71(10.65,4.227) 72(10.351,-4.229) 73(7.65,4.227) 74(7.348,-4.229) 75(7.051,4.227) 76(6.749,-4.229) 77(6.449,4.227) 78(6.149,-4.229) 79(5.85,4.227) 80(5.55,-4.229) 81(5.25,4.227) 82(4.95,-4.229) 83(4.651,4.227) 84(4.351,-4.229) 85(4.051,4.227) 86(3.749,-4.229) 87(3.449,4.227) 88(3.15,-4.229) 89(2.85,4.227) 90(2.55,-4.229) 91(2.25,4.227) 92(1.951,-4.229) 93(1.648,4.227) 94(1.351,-4.229) 95(1.049,4.227) 96(0.749,-4.229) 97(0.45,4.227) 98(0.15,-4.229) 99(-0.15,4.227) 100(-0.452,-4.229) 101(-0.752,4.227) 102(-1.049,-4.229) 103(-1.351,4.227) 104(-1.648,-4.229) 105(-1.951,4.227) 106(-2.25,-4.229) 107(-2.55,4.227) 108(-2.85,-4.229) 109(-3.152,4.227) 110(-3.452,-4.229) 111(-3.752,4.227) 112(-4.051,-4.229) 113(-4.351,4.227) 114(-4.651,-4.229) 115(-4.95,4.227) 116(-5.25,-4.229) 117(-5.55,4.227) 118(-5.852,-4.229) 119(-6.152,4.227) 120(-6.452,-4.229) 121(-6.749,4.227) 122(-7.051,-4.229) 123(-7.351,4.227) 124(-7.65,-4.229) 125(-7.95,4.227) 126(-8.25,-4.229) 127(-8.552,4.227) 128(-8.852,-4.229) 129(-9.152,4.227) 130(-9.449,-4.229) 131(-9.751,4.227) 132(-10.051,-4.229) 133(-10.351,4.227) 134(-10.65,-4.229) 135(-10.95,4.227) 136(-11.252,-4.229) 137(-11.549,4.227) 138(-11.852,-4.229) 139(-12.151,4.227) 140(-12.449,-4.229) 141(-12.751,4.227) 142(-13.051,-4.229) 143(-13.35,4.227) 144(-13.65,-4.229) 145(-13.952,4.227) 146(-14.252,-4.229) 147(-14.549,4.227) 148(-14.851,-4.229) 149(-15.151,4.227) 150(-15.451,-4.229) 151(-15.751,4.227) 152(-16.05,-4.229) 153(-16.35,4.227) 154(-16.65,-4.229) 155(-16.952,4.227) 156(-17.252,-4.229) 157(-17.551,4.227) 158(-17.851,-4.229) 159(-18.151,4.227) 160(-18.451,-4.229) 161(-18.75,4.227) 162(-19.05,-4.229) 163(-19.35,4.227) 164(-19.652,-4.229) 165(-19.952,4.227) 166(-20.251,-4.229) 167(-20.551,4.227) 168(-20.851,-4.229) 169(-21.151,4.227) 170(-21.45,-4.229) 171(-21.75,4.227) 172(-22.05,-4.229) 173(-22.352,4.227) 174(-22.652,-4.229) 175(-22.951,4.227) 176(-23.251,-4.229) 177(-23.551,4.227) 178(-23.851,-4.229) 179(-24.15,4.227) 180(-24.45,-4.229) 181(-24.75,4.227) 182(-25.049,-4.229) 183(-25.352,4.227) 184(-25.651,-4.229) 185(-25.949,4.227) 186(-26.251,-4.229) 187(-26.551,4.227) 188(-26.85,-4.229) 189(-27.15,4.227) 190(-27.45,-4.229) 191(-27.752,4.227) 192(-28.052,-4.229) 193(-28.351,4.227) 194(-28.651,-4.229) 195(-28.951,4.227) 196(-29.251,-4.229) 197(-29.55,4.227) 198(-29.85,-4.229) 199(-30.15,4.227) 200(-30.452,-4.229) 201(-30.752,4.227) 202(-31.052,-4.229) 203(-31.351,4.227) 204(-31.651,-4.229)
  rect 4.496x4.597 smd: G1(32.55,11.999) G2(-32.55,11.999)
DOCK_FOX_94_050_DIP_440
  round 1.143 hole 1.143 unplated: (-13.698,-0.003) (13.698,-0.003)
  oval 0.66x0.94 hole 0.508: 1(12.301,-0.602) 2(11.801,0.599) 3(11.3,-0.602) 4(10.8,0.599) 5(10.3,-0.602) 6(9.799,0.599) 7(9.301,-0.602) 8(8.799,0.599) 9(8.301,-0.602) 10(7.8,0.599) 11(7.3,-0.602) 12(6.8,0.599) 13(6.302,-0.602) 14(5.801,0.599) 15(5.301,-0.602) 16(4.801,0.599) 17(4.3,-0.602) 18(3.8,0.599) 19(3.299,-0.602) 20(2.802,0.599) 21(2.301,-0.602) 22(1.801,0.599) 23(1.3,-0.602) 24(0.8,0.599) 25(0.3,-0.602) 26(-0.201,0.599) 27(-0.701,-0.602) 28(-1.201,0.599) 29(-1.702,-0.602) 30(-2.2,0.599) 31(-2.7,-0.602) 32(-3.2,0.599) 33(-3.701,-0.602) 34(-4.201,0.599) 35(-4.699,-0.602) 36(-5.199,0.599) 37(-5.7,-0.602) 38(-6.2,0.599) 39(-6.701,-0.602) 40(-7.201,0.599) 41(-7.701,-0.602) 42(-8.202,0.599) 43(-8.7,-0.602) 44(-9.2,0.599) 45(-9.7,-0.602) 46(-10.201,0.599)
  rect 0.356x1.575 smd: 47(12.301,2.449) 48(11.801,2.449) 49(11.3,2.449) 50(10.8,2.449) 51(10.3,2.449) 52(9.799,2.449) 53(9.301,2.449) 54(8.799,2.449) 55(8.301,2.449) 56(7.8,2.449) 57(7.3,2.449) 58(6.8,2.449) 59(6.302,2.449) 60(5.801,2.449) 61(5.301,2.449) 62(4.801,2.449) 63(4.3,2.449) 64(3.8,2.449) 65(3.299,2.449) 66(2.802,2.449) 67(2.301,2.449) 68(1.801,2.449) 69(1.3,2.449) 70(0.8,2.449) 71(0.3,2.449) 72(-0.201,2.449) 73(-0.701,2.449) 74(-1.201,2.449) 75(-1.702,2.449) 76(-2.2,2.449) 77(-2.7,2.449) 78(-3.2,2.449) 79(-3.701,2.449) 80(-4.201,2.449) 81(-4.699,2.449) 82(-5.199,2.449) 83(-5.7,2.449) 84(-6.2,2.449) 85(-6.701,2.449) 86(-7.201,2.449) 87(-7.701,2.449) 88(-8.202,2.449) 89(-8.7,2.449) 90(-9.2,2.449) 91(-9.7,2.449) 92(-10.201,2.449)
  round 1.194 hole 0.787: G1(-11.801,1.849) P1(-11.801,-0.602)
  oval 1.143x2.54 hole 0.61x2.007: G2(14.724,-4.75) G3(14.724,1.519) G4(-14.727,-4.75) G5(-14.727,1.519)
DS_100X050X060_2_S2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
DS_160X080X090_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
DSMI_3A
  rect 1.016x1.27 smd: 1(-0.94,1.151) 2(0.965,1.151) 3(0,-1.151)
DSOD323_185X125X095_2_231
  rect 0.559x0.813 smd: 1(-1.152,0) 2(1.152,0)
DSOT23_290X130X110_3_095
  rect 0.508x1.219 smd: 1(-0.95,-1.085) 2(0.95,-1.085) 3(0,1.085)
DSOT23_292X130X110_3_095
  rect 0.787x0.889 smd: 1(-0.95,-1) 2(0.95,-1) 3(0,1)
DSSOD123_270X155X135_2
  rect 1.27x1.524 smd: 1(-1.6,0) 2(1.6,0)
DSSOD523_120X080X065_2-2
  rect 0.61x0.787 smd: 1(-0.749,0) 2(0.749,0)
DSSOT23_290X130X105_3_095
  rect 0.508x1.219 smd: 1(-0.95,-1.085) 2(0.95,-1.085) 3(0,1.085)
DSSOT23_290X150X140_3_095
  rect 0.991x0.991 smd: 1(-0.95,-1.201) 2(0.95,-1.201) 3(0,1.201)
DSSOT23_292X130X109_3_095
  rect 0.762x0.762 smd: 1(-0.95,-1.146) 2(0.95,-1.146) 3(0,1.146)
DSSOT363_200X125X110_6_065
  rect 0.305x0.914 smd: 1(-0.65,-0.889) 2(0,-0.889) 3(0.65,-0.889) 4(0.65,0.889) 5(0,0.889) 6(-0.65,0.889)
EMIS_BLM11
  rect 0.889x1.016 smd: 1(-0.66,0) 2(0.66,0)
EMIS_NFM60R
  rect 1.27x1.778 smd: 1(-1.524,0) 2(1.524,0)
  rect 0.889x1.016 smd: 3(0,0.813) 4(0,-0.813)
FIX_MASK
  round 1.016 smd: 1(0,0)
FPC_ACES_15_050_R_200
  rect 0.356x1.372 smd: 1(-3.5,3.051) 2(-3,3.051) 3(-2.499,3.051) 4(-2.002,3.051) 5(-1.501,3.051) 6(-1.001,3.051) 7(-0.5,3.051) 8(0,3.051) 9(0.5,3.051) 10(1.001,3.051) 11(1.501,3.051) 12(2.002,3.051) 13(2.499,3.051) 14(3,3.051) 15(3.5,3.051)
  rect 2.159x2.21 smd: G1(-5.827,-0.003) G2(5.827,-0.003)
FPC_ACES_18_050_R_200_1
  rect 0.356x1.372 smd: 1(-4.252,2.799) 2(-3.752,2.799) 3(-3.251,2.799) 4(-2.751,2.799) 5(-2.25,2.799) 6(-1.75,2.799) 7(-1.252,2.799) 8(-0.752,2.799) 9(-0.249,2.799) 10(0.249,2.799) 11(0.749,2.799) 12(1.25,2.799) 13(1.75,2.799) 14(2.25,2.799) 15(2.751,2.799) 16(3.251,2.799) 17(3.749,2.799) 18(4.249,2.799)
  rect 1.803x1.397 smd: G1(-5.9,-0.003) G2(5.9,-0.003)
FPC_ACES_34_080_R_200_1
  rect 0.305x1.295 smd: 1(-13.2,5.649) 2(-12.4,5.649) 3(-11.6,5.649) 4(-10.8,5.649) 5(-10,5.649) 6(-9.2,5.649) 7(-8.4,5.649) 8(-7.602,5.649) 9(-6.802,5.649) 10(-6.002,5.649) 11(-5.199,5.649) 12(-4.402,5.649) 13(-3.602,5.649) 14(-2.802,5.649) 15(-2.002,5.649) 16(-1.201,5.649) 17(-0.401,5.649) 18(0.401,5.649) 19(1.201,5.649) 20(2.002,5.649) 21(2.799,5.649) 22(3.599,5.649) 23(4.399,5.649) 24(5.199,5.649) 25(5.999,5.649) 26(6.8,5.649) 27(7.6,5.649) 28(8.4,5.649) 29(9.2,5.649) 30(10,5.649) 31(10.8,5.649) 32(11.6,5.649) 33(12.4,5.649) 34(13.2,5.649)
  rect 1.803x2.21 smd: G1(-15.55,-0.003) G2(15.55,-0.003)
FPC_ACES_40_050_R_180_1
  rect 0.356x0.914 smd: 1(-9.75,3.175) 2(-9.25,3.175) 3(-8.75,3.175) 4(-8.25,3.175) 5(-7.75,3.175) 6(-7.25,3.175) 7(-6.75,3.175) 8(-6.25,3.175) 9(-5.75,3.175) 10(-5.25,3.175) 11(-4.75,3.175) 12(-4.25,3.175) 13(-3.75,3.175) 14(-3.25,3.175) 15(-2.75,3.175) 16(-2.25,3.175) 17(-1.75,3.175) 18(-1.25,3.175) 19(-0.75,3.175) 20(-0.25,3.175) 21(0.25,3.175) 22(0.75,3.175) 23(1.25,3.175) 24(1.75,3.175) 25(2.25,3.175) 26(2.75,3.175) 27(3.25,3.175) 28(3.75,3.175) 29(4.25,3.175) 30(4.75,3.175) 31(5.25,3.175) 32(5.75,3.175) 33(6.25,3.175) 34(6.75,3.175) 35(7.25,3.175) 36(7.75,3.175) 37(8.25,3.175) 38(8.75,3.175) 39(9.25,3.175) 40(9.75,3.175)
  rect 0.787x2.007 smd: G1(-11.45,0) G2(11.45,0)
GALIEO16-6012B0073604-003
  round 0.711 hole 0.711 unplated: (-6.35,-1.9) (6.35,-1.9)
  custom 0.152x0.152 smd: 1(-5.499,-2.799) 23(5.502,-2.799)
  rect 0.61x1.6 smd: 2(-5.499,2.802) 3(-4.501,-2.799) 4(-4.501,2.802) 5(-3.5,-2.799) 6(-3.5,2.802) 7(-2.499,-2.799) 8(-2.499,2.802) 9(-1.499,-2.799) 10(-1.499,2.802) 11(-0.5,-2.799) 12(-0.5,2.802) 13(0.5,-2.799) 14(0.5,2.802) 15(1.501,-2.799) 16(1.501,2.802) 17(2.499,-2.799) 18(2.499,2.802) 19(3.503,-2.799) 20(3.503,2.802) 21(4.501,-2.799) 22(4.501,2.802) 24(5.502,2.802)
  rect 0.838x2.108 smd: G1(-6.825,0.45) G2(6.828,0.45)
HVQFN_600X600X100_40_050_T1
  custom 0.089x0.089 smd: 1(-2.25,-2.977) 2(-1.75,-2.977) 3(-1.25,-2.977) 4(-0.752,-2.977) 5(-0.249,-2.977) 6(0.249,-2.977) 7(0.752,-2.977) 8(1.25,-2.977) 9(1.75,-2.977) 10(2.25,-2.977) 11(2.977,-2.25) 12(2.977,-1.75) 13(2.977,-1.25) 14(2.977,-0.752) 15(2.977,-0.249) 16(2.977,0.249) 17(2.977,0.752) 18(2.977,1.25) 19(2.977,1.75) 20(2.977,2.25) 21(2.25,2.977) 22(1.75,2.977) 23(1.25,2.977) 24(0.752,2.977) 25(0.249,2.977) 26(-0.249,2.977) 27(-0.752,2.977) 28(-1.25,2.977) 29(-1.75,2.977) 30(-2.25,2.977) 31(-2.977,2.25) 32(-2.977,1.75) 33(-2.977,1.25) 34(-2.977,0.752) 35(-2.977,0.249) 36(-2.977,-0.249) 37(-2.977,-0.752) 38(-2.977,-1.25) 39(-2.977,-1.75) 40(-2.977,-2.25)
  rect 4.089x4.089 smd: 41(0,0)
IC-HALL_BCD_3_SMD_V_145
  rect 0.61x0.787 smd: 1(-0.95,-1.1) 2(0.95,-1.1) 3(0,1.1)
LED_EVERL_R_D_300X200X100_2
  rect 0.991x1.499 smd: 1(-1.501,0) 3(1.501,0)
  rect 0.889x0.889 smd: 2(0,0.65)
LED_EVERL_V_D_320X125X110
  rect 1.092x0.787 smd: 1(-1.351,-0.526) 2(-1.351,0.526) 3(1.351,0.526) 4(1.351,-0.526)
LED_EVERLI_V_S_160X080X040
  rect 0.787x0.787 smd: 1(-0.749,0) 2(0.752,0)
LGA_300X300X100_16_050
  rect 0.356x0.432 smd: 1(-1.001,-1.227) 2(-0.5,-1.227) 3(0,-1.227) 4(0.5,-1.227) 5(1.001,-1.227) 9(1.001,1.227) 10(0.5,1.227) 11(0,1.227) 12(-0.5,1.227) 13(-1.001,1.227)
  rect 0.432x0.356 smd: 6(1.227,-0.5) 7(1.227,0) 8(1.227,0.5) 14(-1.227,0.5) 15(-1.227,0) 16(-1.227,-0.5)
LS_100X050X055_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
LS_100X050X060_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
LS_160X080X100_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
LS_200X120X120_4
  rect 1.016x0.61 smd: 1(-0.8,0.5) 2(0.8,0.5) 3(0.8,-0.5) 4(-0.8,-0.5)
LS_500X500X200_2_340
  rect 1.6x5.004 smd: 1(-1.702,0) 2(1.702,0)
LS_700X660X300_2_555
  rect 1.953x3.505 smd: 1(-2.776,0) 2(2.776,0)
LS_700X660X300_4
  custom 0.488x0.488 smd: 1(-2.776,1.016) 2(2.776,1.016)
  rect 1.511x0.254 smd: 3(-2.603,0) 4(2.603,0)
MICP_KNOW_8_106
  rect 0.457x0.94 smd: 1(0.427,-0.676) 2(0.427,0.676) 3(-0.427,0.676) 4(-0.427,-0.676)
  custom 0.112x0.112 smd: 5(0,-1.775) 6(1.275,0) 7(0,1.775) 8(-1.275,0)
MICRO_300X300X110_8_065
  rect 0.381x1.041 smd: 1(-0.975,-2.12) 2(-0.325,-2.12) 3(0.325,-2.12) 4(0.975,-2.12) 5(0.975,2.12) 6(0.325,2.12) 7(-0.325,2.12) 8(-0.975,2.12)
MOSFET_300X300X112_8_065
  rect 0.432x0.869 smd: 1(-0.975,-1.4) 2(-0.325,-1.4) 3(0.325,-1.4) 4(0.975,-1.4)
  custom 0.636x0.636 smd: 5(0.975,1.527)
  rect 0.432x0.744 smd: 6(0.325,1.527) 7(-0.325,1.527) 8(-0.975,1.527)
MPCI_FOX_75_050_RV_300
  round 1.6 hole 1.6 unplated: (-10,0)
  round 1.092 hole 1.092 unplated: (10,0)
  rect 0.356x1.626 smd: 1(9.25,-5.275) 2(9,2.275) 3(8.75,-5.275) 4(8.5,2.275) 5(8.25,-5.275) 6(8,2.275) 7(7.75,-5.275) 8(7.5,2.275) 9(7.25,-5.275) 10(7,2.275) 11(6.75,-5.275) 12(6.5,2.275) 13(6.25,-5.275) 14(6,2.275) 15(5.75,-5.275) 16(5.5,2.275) 17(5.25,-5.275) 18(5,2.275) 19(4.75,-5.275) 20(4.5,2.275) 21(4.25,-5.275) 22(4,2.275) 23(3.75,-5.275) 32(1.5,2.275) 33(1.25,-5.275) 34(1,2.275) 35(0.75,-5.275) 36(0.5,2.275) 37(0.25,-5.275) 38(0,2.275) 39(-0.25,-5.275) 40(-0.5,2.275) 41(-0.75,-5.275) 42(-1,2.275) 43(-1.25,-5.275) 44(-1.5,2.275) 45(-1.75,-5.275) 46(-2,2.275) 47(-2.25,-5.275) 48(-2.5,2.275) 49(-2.75,-5.275) 50(-3,2.275) 51(-3.25,-5.275) 52(-3.5,2.275) 53(-3.75,-5.275) 54(-4,2.275) 55(-4.25,-5.275) 56(-4.5,2.275) 57(-4.75,-5.275) 58(-5,2.275) 59(-5.25,-5.275) 60(-5.5,2.275) 61(-5.75,-5.275) 62(-6,2.275) 63(-6.25,-5.275) 64(-6.5,2.275) 65(-6.75,-5.275) 66(-7,2.275) 67(-7.25,-5.275) 68(-7.5,2.275) 69(-7.75,-5.275) 70(-8,2.275) 71(-8.25,-5.275) 72(-8.5,2.275) 73(-8.75,-5.275) 74(-9,2.275) 75(-9.25,-5.275)
  rect 1.194x2.743 smd: G1(10.35,-4.5) G2(-10.35,-4.5)
MPCI_LOTES_75_050_RV_300
  round 1.6 hole 1.6 unplated: (-10,0)
  round 1.092 hole 1.092 unplated: (10,0)
  rect 0.356x1.626 smd: 1(9.251,-5.276) 2(8.999,2.276) 3(8.748,-5.276) 4(8.499,2.276) 5(8.25,-5.276) 6(8.001,2.276) 7(7.75,-5.276) 8(7.501,2.276) 9(7.249,-5.276) 10(7,2.276) 11(6.749,-5.276) 20(4.501,2.276) 21(4.249,-5.276) 22(4,2.276) 23(3.749,-5.276) 24(3.5,2.276) 25(3.251,-5.276) 26(3,2.276) 27(2.751,-5.276) 28(2.499,2.276) 29(2.25,-5.276) 30(1.999,2.276) 31(1.75,-5.276) 32(1.501,2.276) 33(1.25,-5.276) 34(1.001,2.276) 35(0.749,-5.276) 36(0.5,2.276) 37(0.249,-5.276) 38(0,2.276) 39(-0.249,-5.276) 40(-0.5,2.276) 41(-0.752,-5.276) 42(-1.001,2.276) 43(-1.252,-5.276) 44(-1.501,2.276) 45(-1.75,-5.276) 46(-2.002,2.276) 47(-2.25,-5.276) 48(-2.499,2.276) 49(-2.751,-5.276) 50(-3.002,2.276) 51(-3.251,-5.276) 52(-3.5,2.276) 53(-3.752,-5.276) 54(-4,2.276) 55(-4.252,-5.276) 56(-4.501,2.276) 57(-4.75,-5.276) 58(-5.001,2.276) 59(-5.25,-5.276) 60(-5.502,2.276) 61(-5.751,-5.276) 62(-6.002,2.276) 63(-6.251,-5.276) 64(-6.502,2.276) 65(-6.749,-5.276) 66(-7,2.276) 67(-7.252,-5.276) 68(-7.501,2.276) 69(-7.752,-5.276) 70(-8.001,2.276) 71(-8.252,-5.276) 72(-8.501,2.276) 73(-8.75,-5.276) 74(-9.002,2.276) 75(-9.251,-5.276)
  rect 1.194x2.743 smd: G1(10.351,-4.501) G2(-10.351,-4.501)
MPCI_LOTES_75_050_ST_300
  round 1.6 hole 1.6 unplated: (-10,0)
  round 1.092 hole 1.092 unplated: (10.003,0)
  rect 0.356x1.626 smd: 1(9.251,-5.276) 2(9.002,2.276) 3(8.75,-5.276) 4(8.501,2.276) 5(8.252,-5.276) 6(8.001,2.276) 7(7.752,-5.276) 8(7.501,2.276) 9(7.252,-5.276) 10(7,2.276) 11(6.749,-5.276) 12(6.502,2.276) 13(6.251,-5.276) 14(6.002,2.276) 15(5.751,-5.276) 16(5.502,2.276) 17(5.25,-5.276) 18(5.001,2.276) 19(4.75,-5.276) 20(4.501,2.276) 21(4.252,-5.276) 22(4,2.276) 23(3.752,-5.276) 24(3.5,2.276) 25(3.251,-5.276) 26(3.002,2.276) 27(2.751,-5.276) 28(2.499,2.276) 29(2.25,-5.276) 30(2.002,2.276) 31(1.75,-5.276) 32(1.501,2.276) 33(1.252,-5.276) 34(1.001,2.276) 35(0.752,-5.276) 36(0.5,2.276) 37(0.249,-5.276) 38(0.003,2.276) 39(-0.249,-5.276) 40(-0.5,2.276) 41(-0.749,-5.276) 42(-1.001,2.276) 43(-1.25,-5.276) 44(-1.501,2.276) 45(-1.75,-5.276) 46(-1.999,2.276) 47(-2.25,-5.276) 48(-2.499,2.276) 49(-2.751,-5.276) 50(-3,2.276) 51(-3.251,-5.276) 52(-3.5,2.276) 53(-3.749,-5.276) 54(-4,2.276) 55(-4.249,-5.276) 56(-4.501,2.276) 57(-4.75,-5.276) 58(-4.999,2.276) 67(-7.249,-5.276) 68(-7.501,2.276) 69(-7.75,-5.276) 70(-8.001,2.276) 71(-8.25,-5.276) 72(-8.499,2.276) 73(-8.748,-5.276) 74(-8.999,2.276) 75(-9.251,-5.276)
  rect 1.194x2.743 smd: G1(10.351,-4.501) G2(-10.351,-4.501)
MSOP_300X300X110_8_065
  rect 0.457x1.499 smd: 1(-0.975,-2.499) 2(-0.325,-2.499) 3(0.325,-2.499) 4(0.975,-2.499) 5(0.975,2.499) 6(0.325,2.499) 7(-0.325,2.499) 8(-0.975,2.499)
MSOP_300X300X122_8_065
  rect 0.406x1.27 smd: 1(-0.975,-2.197) 2(-0.325,-2.197) 3(0.325,-2.197) 4(0.975,-2.197) 5(0.975,2.197) 6(0.325,2.197) 7(-0.325,2.197) 8(-0.975,2.197)
MSOP_305X483X110_8_065
  rect 0.406x1.27 smd: 1(-0.975,-2.134) 2(-0.325,-2.134) 3(0.325,-2.134) 4(0.975,-2.134) 5(0.975,2.134) 6(0.325,2.134) 7(-0.325,2.134) 8(-0.975,2.134)
OBERONC-6014B0026101-006
  rect 2.057x2.997 smd: 1(-2.876,0) 2(2.876,0)
POWERPAD1X1M
  custom 0.194x0.194 smd: 1(-0.437,0) 2(0.437,0)
POWERPAD1X1M_NSP
  custom 0.194x0.194 smd: 1(-0.437,0) 2(0.437,0)
POWERPAD_2_0610
  custom 0.252x0.252 smd: 1(0,0) 2(1.27,0)
POWERPAD_2_0610_NSP
  custom 0.252x0.252 smd: 1(0,0) 2(1.27,0)
QFN_300X300X080_16_050_T1
  custom 0.089x0.089 smd: 1(-0.752,-1.476) 2(-0.249,-1.476) 3(0.249,-1.476) 4(0.752,-1.476) 5(1.476,-0.752) 6(1.476,-0.249) 7(1.476,0.249) 8(1.476,0.752) 9(0.752,1.476) 10(0.249,1.476) 11(-0.249,1.476) 12(-0.752,1.476) 13(-1.476,0.752) 14(-1.476,0.249) 15(-1.476,-0.249) 16(-1.476,-0.752)
  rect 1.702x1.702 smd: 17(0,0)
QFN_300X300X100_14_040_T2
  rect 1.092x0.203 smd: 1(-1.25,0.525) 2(-1.25,-0.175) 8(1.25,-0.525) 9(1.25,0.175)
  rect 0.297x0.787 smd: 3(-0.8,-1.45) 4(-0.4,-1.45) 5(0,-1.45) 6(0.4,-1.45) 7(0.8,-1.45) 10(0.8,1.45) 11(0.4,1.45) 12(0,1.45) 13(-0.4,1.45) 14(-0.8,1.45)
  rect 0.66x0.203 smd: 15(0,0.17)
  rect 0.66x0.279 smd: 16(0,-0.481)
QFN_350X350X100_20_050_T1
  rect 0.356x0.787 smd: 1(-1.001,-1.699) 2(-0.5,-1.699) 3(0,-1.699) 4(0.5,-1.699) 5(1.001,-1.699) 11(1.001,1.699) 12(0.5,1.699) 13(0,1.699) 14(-0.5,1.699) 15(-1.001,1.699)
  rect 0.787x0.356 smd: 6(1.699,-1.001) 7(1.699,-0.5) 8(1.699,0) 9(1.699,0.5) 10(1.699,1.001) 16(-1.699,1.001) 17(-1.699,0.5) 18(-1.699,0) 19(-1.699,-0.5) 20(-1.699,-1.001)
  rect 2.007x2.007 smd: 21(0,0)
QFN_400X400X080_20_050_T1
  custom 0.089x0.089 smd: 1(-1.001,-1.976) 2(-0.5,-1.976) 3(0,-1.976) 4(0.5,-1.976) 5(1.001,-1.976) 6(1.976,-1.001) 7(1.976,-0.5) 8(1.976,0) 9(1.976,0.5) 10(1.976,1.001) 11(1.001,1.974) 12(0.5,1.974) 13(0,1.974) 14(-0.5,1.974) 15(-1.001,1.974) 16(-1.976,1.001) 17(-1.976,0.5) 18(-1.976,0) 19(-1.976,-0.5) 20(-1.976,-1.001)
  rect 2.692x2.692 smd: 21(0,0)
QFN_400X400X090_32_040_T1
  custom 0.074x0.074 smd: 1(-1.4,-1.9) 8(1.4,-1.9) 9(1.9,-1.4) 16(1.9,1.4) 17(1.4,1.9) 24(-1.4,1.9) 25(-1.9,1.4) 32(-1.9,-1.4)
  rect 0.297x0.686 smd: 2(-1.001,-1.9) 3(-0.599,-1.9) 4(-0.201,-1.9) 5(0.201,-1.9) 6(0.599,-1.9) 7(1.001,-1.9) 18(1.001,1.9) 19(0.599,1.9) 20(0.201,1.9) 21(-0.201,1.9) 22(-0.599,1.9) 23(-1.001,1.9)
  rect 0.686x0.297 smd: 10(1.9,-1.001) 11(1.9,-0.599) 12(1.9,-0.201) 13(1.9,0.201) 14(1.9,0.599) 15(1.9,1.001) 26(-1.9,1.001) 27(-1.9,0.599) 28(-1.9,0.201) 29(-1.9,-0.201) 30(-1.9,-0.599) 31(-1.9,-1.001)
  rect 2.692x2.692 smd: 33(0,0)
QFN_400X400X100_23_050_P3
  rect 0.356x0.737 smd: 1(-1.25,-1.985) 2(-0.75,-1.985) 3(-0.25,-1.985) 4(0.25,-1.985) 5(0.75,-1.985) 6(1.25,-1.985) 12(1.25,1.985) 13(0.75,1.985) 14(0.25,1.985) 15(-0.25,1.985) 16(-0.75,1.985) 17(-1.25,1.985)
  rect 0.737x0.356 smd: 7(1.985,-1.25) 8(1.985,-0.75) 10(1.985,0.75) 18(-1.985,1.25) 19(-1.985,0.75) 20(-1.985,0.25) 21(-1.985,-0.25) 22(-1.985,-0.75) 23(-1.985,-1.25)
  custom 0.368x0.368 smd: 9(1.985,-0.25)
  custom 0.262x0.262 smd: 11(1.985,1.25)
QFN_400X400X100_32_040_T3
  custom 0.074x0.074 smd: 1(-1.4,-2) 2(-1,-2) 3(-0.6,-2) 4(-0.2,-2) 5(0.2,-2) 6(0.6,-2) 7(1,-2) 8(1.4,-2) 9(2,-1.4) 10(2,-1) 11(2,-0.6) 12(2,-0.2) 13(2,0.2) 14(2,0.6) 15(2,1) 16(2,1.4) 17(1.4,2) 18(1,2) 19(0.6,2) 20(0.2,2) 21(-0.2,2) 22(-0.6,2) 23(-1,2) 24(-1.4,2) 25(-2,1.4) 26(-2,1) 27(-2,0.6) 28(-2,0.2) 29(-2,-0.2) 30(-2,-0.6) 31(-2,-1) 32(-2,-1.4)
  rect 2.794x2.794 smd: 33(0,0)
QFN_600X600X090_48_040_T4
  rect 0.297x0.737 smd: 1(-2.2,-2.875) 2(-1.801,-2.875) 3(-1.4,-2.875) 4(-1.001,-2.875) 5(-0.599,-2.875) 6(-0.201,-2.875) 7(0.201,-2.875) 8(0.599,-2.875) 9(1.001,-2.875) 10(1.4,-2.875) 11(1.801,-2.875) 12(2.2,-2.875) 25(2.2,2.875) 26(1.801,2.875) 27(1.4,2.875) 28(1.001,2.875) 29(0.599,2.875) 30(0.201,2.875) 31(-0.201,2.875) 32(-0.599,2.875) 33(-1.001,2.875) 34(-1.4,2.875) 35(-1.801,2.875) 36(-2.2,2.875)
  rect 0.737x0.297 smd: 13(2.875,-2.2) 14(2.875,-1.801) 15(2.875,-1.4) 16(2.875,-1.001) 17(2.875,-0.599) 18(2.875,-0.201) 19(2.875,0.201) 20(2.875,0.599) 21(2.875,1.001) 22(2.875,1.4) 23(2.875,1.801) 24(2.875,2.2) 37(-2.875,2.2) 38(-2.875,1.801) 39(-2.875,1.4) 40(-2.875,1.001) 41(-2.875,0.599) 42(-2.875,0.201) 43(-2.875,-0.201) 44(-2.875,-0.599) 45(-2.875,-1.001) 46(-2.875,-1.4) 47(-2.875,-1.801) 48(-2.875,-2.2)
  rect 2.997x2.997 smd: 49(0,0)
QFN_600X600X100_48_040_T1
  rect 0.297x0.864 smd: 1(-2.2,-2.901) 2(-1.801,-2.901) 3(-1.4,-2.901) 4(-1.001,-2.901) 5(-0.599,-2.901) 6(-0.201,-2.901) 7(0.201,-2.901) 8(0.599,-2.901) 9(1.001,-2.901) 10(1.4,-2.901) 11(1.801,-2.901) 12(2.2,-2.901) 25(2.2,2.901) 26(1.801,2.901) 27(1.4,2.901) 28(1.001,2.901) 29(0.599,2.901) 30(0.201,2.901) 31(-0.201,2.901) 32(-0.599,2.901) 33(-1.001,2.901) 34(-1.4,2.901) 35(-1.801,2.901) 36(-2.2,2.901)
  rect 0.864x0.297 smd: 13(2.901,-2.2) 14(2.901,-1.801) 15(2.901,-1.4) 16(2.901,-1.001) 17(2.901,-0.599) 18(2.901,-0.201) 19(2.901,0.201) 20(2.901,0.599) 21(2.901,1.001) 22(2.901,1.4) 23(2.901,1.801) 24(2.901,2.2) 37(-2.901,2.2) 38(-2.901,1.801) 39(-2.901,1.4) 40(-2.901,1.001) 41(-2.901,0.599) 42(-2.901,0.201) 43(-2.901,-0.201) 44(-2.901,-0.599) 45(-2.901,-1.001) 46(-2.901,-1.4) 47(-2.901,-1.801) 48(-2.901,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
QFN_900X500X080_60_040_T1
  custom 0.074x0.074 smd: 1(-3.8,-2.475) 2(-3.4,-2.475) 3(-3,-2.475) 4(-2.6,-2.475) 5(-2.2,-2.475) 6(-1.8,-2.475) 7(-1.4,-2.475) 8(-1,-2.475) 9(-0.6,-2.475) 10(-0.2,-2.475) 11(0.2,-2.475) 12(0.6,-2.475) 13(1,-2.475) 14(1.4,-2.475) 15(1.8,-2.475) 16(2.2,-2.475) 17(2.6,-2.475) 18(3,-2.475) 19(3.4,-2.475) 20(3.8,-2.475) 21(4.475,-1.8) 22(4.475,-1.4) 23(4.475,-1) 24(4.475,-0.6) 25(4.475,-0.2) 26(4.475,0.2) 27(4.475,0.6) 28(4.475,1) 29(4.475,1.4) 30(4.475,1.8) 31(3.8,2.475) 32(3.4,2.475) 33(3,2.475) 34(2.6,2.475) 35(2.2,2.475) 36(1.8,2.475) 37(1.4,2.475) 38(1,2.475) 39(0.6,2.475) 40(0.2,2.475) 41(-0.2,2.475) 42(-0.6,2.475) 43(-1,2.475) 44(-1.4,2.475) 45(-1.8,2.475) 46(-2.2,2.475) 47(-2.6,2.475) 48(-3,2.475) 49(-3.4,2.475) 50(-3.8,2.475) 51(-4.475,1.8) 52(-4.475,1.4) 53(-4.475,1) 54(-4.475,0.6) 55(-4.475,0.2) 56(-4.475,-0.2) 57(-4.475,-0.6) 58(-4.475,-1) 59(-4.475,-1.4) 60(-4.475,-1.8)
  rect 7.01x2.997 smd: 61(0,0)
QFN_900X900X100_64_050_T5
  custom 0.089x0.089 smd: 1(-3.749,-4.501) 2(-3.251,-4.501) 3(-2.751,-4.501) 4(-2.25,-4.501) 5(-1.75,-4.501) 6(-1.25,-4.501) 7(-0.749,-4.501) 8(-0.249,-4.501) 9(0.249,-4.501) 10(0.749,-4.501) 11(1.25,-4.501) 12(1.75,-4.501) 13(2.25,-4.501) 14(2.751,-4.501) 15(3.251,-4.501) 16(3.749,-4.501) 17(4.501,-3.749) 18(4.501,-3.251) 19(4.501,-2.751) 20(4.501,-2.25) 21(4.501,-1.75) 22(4.501,-1.25) 23(4.501,-0.749) 24(4.501,-0.249) 25(4.501,0.249) 26(4.501,0.749) 27(4.501,1.25) 28(4.501,1.75) 29(4.501,2.25) 30(4.501,2.751) 31(4.501,3.251) 32(4.501,3.749) 33(3.749,4.501) 34(3.251,4.501) 35(2.751,4.501) 36(2.25,4.501) 37(1.75,4.501) 38(1.25,4.501) 39(0.749,4.501) 40(0.249,4.501) 41(-0.249,4.501) 42(-0.749,4.501) 43(-1.25,4.501) 44(-1.75,4.501) 45(-2.25,4.501) 46(-2.751,4.501) 47(-3.251,4.501) 48(-3.749,4.501) 49(-4.501,3.749) 50(-4.501,3.251) 51(-4.501,2.751) 52(-4.501,2.25) 53(-4.501,1.75) 54(-4.501,1.25) 55(-4.501,0.749) 56(-4.501,0.249) 57(-4.501,-0.249) 58(-4.501,-0.749) 59(-4.501,-1.25) 60(-4.501,-1.75) 61(-4.501,-2.25) 62(-4.501,-2.751) 63(-4.501,-3.251) 64(-4.501,-3.749)
  rect 5.994x5.994 smd: 65(0,0)
RJ45_FOX_12_DIP_RS_Y_510
  round 1.194 hole 0.889: 1(-3.571,3.551) 2(-2.55,4.651) 3(-1.532,3.551) 4(-0.511,4.651) 5(0.511,3.551) 6(1.532,4.651) 7(2.55,3.551) 8(3.571,4.651)
  round 1.295 hole 0.991: A1(7.102,1.75) A2(7.102,3.452) B1(-7.102,1.75) B2(-7.102,3.452)
  oval 0.991x2.007 hole 0.61x1.6: G1(7.95,-6.551) G2(7.95,0.003) G3(-7.95,-6.551) G4(-7.95,0.003)
