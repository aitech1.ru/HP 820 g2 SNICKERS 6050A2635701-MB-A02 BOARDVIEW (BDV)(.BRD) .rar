# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PR_AOUT_L_DOCK: length 48.9
  TOP w0.381: R566.2 307.46,77.84 v2(307.88,77.84) ; 321.6,116.2 319.95,116.2 v2(319.56,115.81) ; 321.6,116.2 v1(321.6,116.19) ; 321.6,116.2 CN3601.20
  L5 w0.381: v2(307.88,77.84) 308.26,77.46 309.53,77.46 310.23,78.15 310.23,82.87 312.27,84.91 312.27,102.46 312.28,102.48 312.28,102.53 316.9,107.15 316.9,108.34 318.75,110.19 318.75,115 v2(319.56,115.81)
PR_AOUT_R_AB: length 6.9
  TOP w0.254: U501.40 302.4,63.76 303.28,64.63 v3(303.56,64.63)
  L3 w0.254: v2(307.37,66.53) 306.99,66.15 305.92,66.15 304.4,64.63 v3(303.56,64.63)
PR_AOUT_R_DOCK: length 49.9
  TOP w0.381: R567.2 310.55,78.37 v1(310.52,78.39) 310.45,78.47 309.15,78.47 v2(309.02,78.34)
  L5 w0.102: CN3601.21 322.64,116.7
  L5 w0.381: v2(309.02,78.34) 309.59,78.92 309.59,83.14 311.63,85.17 311.63,103.52 316.21,108.1 316.21,108.14 316.21,108.14 316.21,108.73 318.12,110.64 318.12,115.26 319.3,116.44 319.34,116.44 319.6,116.7 322.64,116.7
PROC_DETECT_N: length 4.5
  TOP w0.076: TP4501.1 213.65,75.12 v4(213.47,75.3)
  BOTTOM w0.076: v4(213.47,75.3) 213.04,74.87 211.99,74.87 211.53,74.94 211.48,74.94 211.34,74.94 210.86,75.42 U4555.D61
PRTPWR2: length 8.7
  TOP w0.102: v2(275.65,65.42) 275.71,65.35 U2550.35
  BOTTOM w0.102: U2403.2 275.37,64.81 275.65,65.09 v2(275.65,65.42) 275.85,65.42 276.56,64.7 276.56,63.56 276.85,63.27 R2565.2 280.11,63.27 v1(280.19,63.36)
PRTPWR3: length 13.5
  TOP w0.102: v2(280.07,64.12) 279.31,64.88 278.86,64.88 278.5,65.24 277.32,65.24 276.71,64.63 U2550.33
  BOTTOM w0.102: U2402.2 277.68,64.65 277.91,64.88 278.67,64.88 279.05,64.5 279.69,64.5 v2(280.07,64.12) 280.19,64.12 280.74,63.57 280.74,62.94 282.2,61.48 282.2,60.5 R2566.2 282.2,60.38 v1(282.2,59.32)
PVADPTR: length 25.3
  TOP w0.254: L6035.1 305.01,142.07 305.01,144.03 306.23,145.25 R6016.1
  TOP w0.381: Q6010.1 298.15,139.73 v2(298.87,139.01) ; C6018.1 303.69,141.84 ; v2(290.03,134.48) 289.72,134.16 R6021.1 ; C3601.1 319.38,128.3 ; 301.91,141.84 R6017.1 ; 300.95,135.67 300.94,135.67 R6902.1 ; v2(293.4,134.3) 293.15,134.05 R6996.1 ; 310.59,131.49 C7616.1 ; 305.8,139.62 C6017.1 ; 317.59,128.3 C3600.1 ; 302.8,141.84 C6019.1
  L6 w0.508: v2(290.03,134.48) 290.9,133.61 292.72,133.61 v2(293.4,134.3)
  BOTTOM w0.508: v2(298.87,139.01) 295.49,139.01 293.4,136.93 v2(293.4,134.3)
  vias: v1(303.05,140.57)
PVCORE: length 60.8
  TOP w0.254: C4531.1 v5(192.56,78.98) ; 211.08,69.63 211.79,70.34 211.79,72.71 211.49,73.01 R4521.1 ; C4535.1 v5(197.39,78.98)
  TOP w0.381: C7460.2 196.29,60.38 ; C7463.2 224.25,68.14 ; C7459.2 195.66,61.27 ; C7612.1 189.9,74.28 ; C7462.2 225.46,55.51 ; C7461.2 224.57,55.41 ; 222.47,68.14 C7464.2
  BOTTOM w0.203: U4555.F59 209.56,77.36 209.31,77.1 209.31,76.85 209.08,76.62 209,76.54 208.36,76.54 U4555.E57
  BOTTOM w0.254: U4555.C52 205.11,76.39 v2(205.15,76.42) ; U4555.C44 200.12,76.48 v2(200.13,76.48) ; U4555.C28 v2(190.09,76.44) ; U4555.C40 197.62,76.41 v2(197.55,76.48) ; U4555.C32 192.6,76.33 v2(192.51,76.42) ; v2(202.58,76.47) 202.61,76.45 U4555.C48 ; U4555.C56 207.69,75.95 207.78,75.95 208.31,76.48 U4555.E57 U4555.G57 208,77.64 v2(207.79,77.64) 207.62,77.47 U4555.F56 ; U4555.C24 187.59,75.92 187.53,75.97 v4(187.53,76.44) ; U4555.C36 195.11,76.45 v2(195.08,76.48)
  BOTTOM w0.381: U4555.K57 v2(208.06,79.36) ; v2(190.09,76.44) 190.09,76.51 190.07,76.53 U4555.F28 ; U4555.AB57 208.05,85.87 v2(208.05,85.87) ; U4555.E29 U4555.G29 190.76,77.41 v2(190.38,77.79) ; U4555.F48 202.6,76.5 v2(202.58,76.47) ; U4555.M57 208.05,80.66 v2(208.05,80.67) ; U4555.F52 205.11,77.01 205.11,76.46 v2(205.15,76.42) ; v2(197.97,77.79) 198.28,77.49 U4555.G41 U4555.E41 ; U4555.F24 187.53,76.99 v4(187.53,76.44) ; U4555.W57 208.05,84.57 v2(208.05,84.57) ; v2(204.85,77.66) 204.74,77.66 U4555.G51 U4555.E51 ; U4555.E45 U4555.G45 200.79,77.34 v2(200.37,77.75) ; v2(189.72,77.81) 189.38,77.47 U4555.G27 U4555.E27 ; v2(205.44,77.82) 205.8,77.46 U4555.G53 U4555.E53 ; U4555.L22 186.55,80.5 U4555.M23 186.73,80.5 187.74,79.49 v2(187.74,78.9) ; v2(195.38,77.73) 195.77,77.34 U4555.G37 U4555.E37 ; U4555.AD57 208.05,87.17 v2(208.05,87.17) ; v2(207.93,83.26) 208.01,83.34 208.52,83.34 U4555.U57 ; U4555.AG57 208.06,88.47 207.53,87.94 v2(207.53,87.4) ; U4555.J23 186.65,78.9 v2(187.04,79.29) 186.65,79.68 U4555.K23 ; v2(207.93,81.97) 207.93,81.96 U4555.P57 ; U4555.E33 U4555.G33 193.26,77.41 v2(192.92,77.76) ; U4555.F32 192.57,76.49 v2(192.51,76.42) ; U4555.F36 v2(195.08,76.48) ; v2(194.75,77.73) 194.39,77.38 U4555.G35 U4555.E35 ; v2(202.89,77.74) 203.29,77.34 U4555.G49 U4555.E49 ; C7466.2 197.19,68.69 ; U4555.E39 U4555.G39 196.9,77.38 v2(197.3,77.78) ; U4555.F40 197.59,76.52 v2(197.55,76.48) ; U4555.H23 187.01,78.06 v2(187.26,77.81) 186.87,77.42 U4555.G23 U4555.E23 ; U4555.F44 200.1,76.51 v2(200.13,76.48) ; v2(202.3,77.72) 202.3,77.72 U4555.G47 U4555.E47 ; v2(192.26,77.79) 191.88,77.41 U4555.G31 U4555.E31 ; v2(187.87,77.81) 188.25,77.43 U4555.G25 U4555.E25 ; U4555.E43 U4555.G43 199.41,77.39 v2(199.76,77.75) ; v2(207.17,77.82) 206.93,77.58 U4555.G55 U4555.E55 ; 196.8,67.36 C7465.2 ; C7622.1 212,62.72
  vias: v1(207.55,73.77) v2(192.95,66.41) v2(192.95,64.7) v2(192.95,63.1) v2(193.2,65.47) v2(193.2,63.87) v2(197.76,64.7) v2(197.76,63.1) v2(198.01,65.47) v2(198.01,63.87) v5(196.88,66.53) v5(196.88,65.39) v5(196.88,64.25) v5(196.88,63.1) v5(201.71,66.53) v5(201.71,65.39) v5(201.71,64.25) v5(201.71,63.1) v5(206.53,66.15) v5(206.53,65.14) v5(206.53,64.12) v5(206.53,63.1) v5(221.01,67.3) v5(221.01,66.15) v5(221.01,65.01) v5(222.41,67.3) v5(222.41,66.15) v5(222.41,65.01) v5(223.81,67.3) v5(223.81,66.15) v5(223.81,65.01)
PVCORE_PG: length 46.3
  L6 w0.254: v2(237.14,75.35) 237.14,75.6 236.38,76.36 227.89,76.36 226.91,75.38 224.4,75.38 222.61,73.59 217.08,73.59 214.46,70.98 v3(213.65,70.98)
  BOTTOM w0.229: 210.09,73.48 209.84,73.73 209.84,74.05 209.82,74.08 209.82,74.68 209.44,75.06 U4555.C59
  BOTTOM w0.254: 210.09,73.48 211.32,72.25 212.38,72.25 v3(213.65,70.98) 216.01,70.98 R4593.1 ; v2(237.14,75.35) 237.25,75.45 237.25,79.87 237.27,79.89 237.27,80.63 237.12,80.78 236.48,80.78 236.35,80.66 234.98,80.66 234.65,80.99 233.2,80.99 233.07,80.85 U6600.3
PVPACK: length 11
  TOP w0.381: 138.08,68.44 C7609.1 ; C7611.1 v2(130.46,112.33) ; C7621.1 278.84,145.45 v5(278.54,145.15) ; C7502.1 138.13,65.14
  TOP w0.508: 133.51,83.16 CN4941.G2 ; CN4941.G2 134.38,84.23 ; CN4941.G2 133.51,85.31 ; CN4941.G2 132.64,84.23
  BOTTOM w0.381: C7618.1 v2(130.21,156.45) ; C7619.1 v2(214.41,158.23)
  BOTTOM w0.635: D7609.2 121.48,155.65 v2(121.44,155.69) ; D7610.2 v2(215.42,158.23)
  vias: v1(284.13,143.75) v5(129.83,111.24) v5(129.83,109.59) v5(130.92,110.48) v5(132.11,111.24) v5(132.11,109.59) v5(277.4,145.15) v5(278.04,144.13) v5(279.18,144.13) v5(279.81,145.15)
PVSIM: length 7.3
  TOP w0.254: D1451.1 257.29,81.65 v3(256.19,81.65)
  BOTTOM w0.254: R1407.1 257.76,73.7 257.36,74.1 257.28,74.1 256.91,74.48 C1413.1 ; 256.19,78.93 v3(256.19,81.65)
  BOTTOM w0.381: R1408.1 255.43,55.23 ; C1413.1 256.32,74.53 ; 256.51,75.42 C1414.1
  vias: v2(256.22,72.25) v2(256.85,72.25) v5(254.41,56.31) v5(254.41,55.42) v5(256.45,69.33)
PVSM_VCC_SM: length 77.6
  TOP w0.381: 75.71,108.72 68.98,108.72 68.78,108.92 68.75,108.94 68.36,109.33 64.93,109.33 64.42,109.84 64.42,113.27 65.31,114.16 R9000.1 66.53,115.76 67.85,117.08 67.85,121.65 68.36,122.16 72.55,122.16 73.44,121.27 79.41,121.27 80.3,122.16 80.3,136.26 79.15,137.4 71.49,137.4 71.11,137.02 C9015.1 v1(67.41,136.64) v4(64.11,136.64) ; 75.71,108.72 78.62,108.72 C9004.1 ; 75.71,108.72 U9000.11
  BOTTOM w0.381: v4(64.11,136.64) 62.78,135.31 CN9001.1
PVT_CS#: length 110.5
  TOP w0.114: U300.96 263.63,110.52 263.63,107.1 264.33,106.4 264.33,104.5 v2(264.83,104)
  L5 w0.114: v2(264.83,104) 264.19,104.63 260.82,104.63 259.11,102.93 259.11,98.39 257.27,96.55 252.81,96.55 251.87,95.62 251.87,93.97 253.02,92.82 255.05,92.82 259.21,88.66 259.21,84.93 260.76,83.37 261.53,82.62 261.53,80.6 260.67,79.75 260.67,79.06 260.67,76.1 259.14,74.57 253.97,74.57 250.36,70.96 249.3,70.96 248.5,70.96 246.41,68.87 246.41,68.09 245.45,67.13 244.6,67.13 243.98,66.51 243.01,66.51 242.28,67.24 v2(242.04,67.24)
  BOTTOM w0.114: v2(242.04,67.24) 242.19,67.24 242.37,67.06 243.24,66.19 243.24,62.72 244.1,61.86 244.1,57.14 243.56,56.6 241.57,56.6 v1(238.78,59.38) 237.98,60.18 233.71,60.18 233.59,60.06 233.59,59.38 R355.2 232.99,58.74 233.46,58.28 233.46,57.26 228.66,52.46 227.4,52.46 227.13,52.18 U366.1
PVT_MISO: length 95
  TOP w0.114: U300.94 264.48,108.44 264.7,108.22 264.7,104.89 v2(264.83,104.76)
  L5 w0.114: v2(243.49,66.96) 244.05,66.96 244.48,67.4 245.34,67.4 246.14,68.2 246.14,68.98 248.39,71.22 249.41,71.22 249.41,71.22 250.25,71.22 253.86,74.83 259.02,74.83 260.41,76.21 260.41,77.45 260.41,79.94 261.11,80.64 261.11,82.63 258.94,84.79 258.94,88.42 254.92,92.44 252.89,92.44 251.49,93.84 251.49,96 252.89,97.39 257.74,97.39 258.85,98.5 258.85,103.12 260.74,105.01 264.57,105.01 v2(264.83,104.76)
  BOTTOM w0.114: R390.1 236.72,59.59 v1(239.53,56.79) 240.25,56.07 243.57,56.07 244.63,57.14 244.63,62.09 243.52,63.2 243.52,66.93 v2(243.49,66.96)
PVT_MISO_R: length 13.6
  TOP w0.114: v2(229.27,52.06) 228.12,53.2 v3(228,53.2)
  BOTTOM w0.114: v3(228,53.2) 226.47,53.2 225.86,52.58 U366.2 ; v2(229.27,52.06) 229.27,52.65 234.09,57.47 R390.2
PVT_MOSI: length 74.4
  TOP w0.114: R396.2 v2(253.52,96.12)
  L5 w0.114: v2(253.52,96.12) 252.28,94.88 252.28,94.07 253.14,93.2 255.18,93.2 260.92,87.46 260.92,85.81 260.7,85.58 260.7,84.2 262.13,82.76 262.13,80.3 261.21,79.37 261.21,78.84 261.21,75.88 259.15,73.82 254.84,73.82 251.39,70.37 248.66,70.37 246.94,68.65 246.94,67.86 245.68,66.6 244.99,66.6 244.37,65.97 242.25,65.97 v2(242.17,66.05)
  BOTTOM w0.114: v2(242.17,66.05) 242.48,65.75 242.48,64.63 v1(240.82,62.98) 239.81,61.96 231.05,61.96 229.78,60.69 223.85,60.69 223.32,60.15 U366.5
PVT_SCLK: length 67.1
  TOP w0.114: R362.1 264.9,91.63 v1(265.11,91.43) 265.21,91.32 265.21,90.28 v2(264.45,89.52)
  L3 w0.102: v2(264.45,89.52) 263.56,89.52 260.51,86.47 v2(260.51,86.22)
  L5 w0.114: v2(260.51,86.22) 260.38,86.09 260.38,84.14 261.83,82.69 261.83,80.48 260.94,79.59 260.94,78.95 260.94,78.95 260.94,77.67 260.94,77.67 260.94,75.99 259.1,74.15 254.29,74.15 250.82,70.69 248.61,70.69 246.68,68.76 246.68,67.97 245.56,66.86 244.71,66.86 244.09,66.24 242.69,66.24 242.29,66.64 v2(242.11,66.64)
  BOTTOM w0.114: v2(242.11,66.64) 242.27,66.64 242.86,66.05 242.86,64.09 240.36,61.59 231.06,61.59 229.9,60.44 229.9,60.44 229.89,60.42 225,60.42 224.59,60.01 U366.6
PWM#_LED: length 34.6
  TOP w0.102: v2(264.95,100.82) 264.28,100.15 263.34,100.15 262.96,100.53 U300.118 ; v2(286.67,94.6) 287.69,94.6 v1(288.32,95.24) 288.32,95.87 289.19,96.73 290.31,96.73 290.88,96.17 Q301.1
  L5 w0.102: v2(286.67,94.6) 282.48,94.6 280.55,96.53 275.39,96.53 269.7,102.22 266.35,102.22 v2(264.95,100.82)
PWM_3S_FAN#: length 231
  TOP w0.102: U300.121 260.41,99.33 260.13,99.05 257.84,99.05 257,99.88 257,101.79 v1(256.95,101.84) 255.59,103.2 v2(255.59,103.36)
  L3 w0.102: v2(246.72,151.93) 246.29,151.5 246.29,150.23 247.56,148.96 253.71,148.96 255.59,147.08 259.47,147.08 261.02,145.53 261.02,129.14 261.55,128.61 261.55,123.07 260.92,122.44 259.77,122.44 256.6,119.26 256.6,113.5 258.5,111.6 258.5,109.1 257.97,108.57 256.76,108.57 255.96,107.77 255.96,103.73 v2(255.59,103.36)
  L6 w0.102: v2(246.72,151.93) 246.64,152 246.64,159.35 243.47,162.52 241.79,162.52 241.5,162.52 241.49,162.52 189.52,162.52 183.91,156.91 175.53,156.91 169.43,163 169.21,163.23 115.4,163.23 v2(114.92,162.75)
  BOTTOM w0.102: Q4300.2 118.29,155.69 118.07,155.92 118.07,160.64 115.96,162.75 v2(114.92,162.75)
PWR_BTN_OUT#: length 153.7
  TOP w0.102: v2(239.37,86.02) 239.36,86.02 CN4920.41 ; R103.2 287.35,116.7 v3(287.92,116.7) 288.39,117.17 D100.1 ; U300.4 264.88,94.02 265.21,93.69 v2(265.21,93.65)
  L3 w0.076: v2(207.42,80) 207.17,80 205.56,78.38 189.06,78.38 186.52,80.92 186.52,83.42 184.99,84.95 184.16,84.95 183.69,85.42 183.69,85.94 183.16,86.47 182.35,86.47 180.44,88.39 178.56,88.39 178.16,88.79 178.16,89.77 177.76,90.17 v2(177.21,90.17)
  L3 w0.102: v3(287.92,116.7) 287.49,116.27 287.49,113.96 283.04,109.51 282.64,109.51 276.97,109.51 274.16,106.71 270.85,106.71 269.78,105.64 269.78,99.89 265.27,95.38 265.27,93.71 v2(265.21,93.65) 265.21,92.53 257.73,85.04 256.61,85.04 255.12,83.55 250.5,83.55 249.51,84.54 242.86,84.54 241.91,85.49 239.9,85.49 v2(239.37,86.02)
  L5 w0.102: v2(207.42,80) 207.42,80.76 207.78,81.11 209.43,81.11 209.63,80.91 211.56,80.91 211.71,81.06 215.09,81.06 215.65,80.5 218.57,80.5 220.1,78.98 221.62,78.98 222.18,79.54 222.18,81.75 222.22,81.78 222.22,81.79 226.5,86.07 230.95,86.07 232.72,84.29 233.93,84.29 234.04,84.18 234.85,84.18 235.36,84.69 236,84.69 237.32,86.02 v2(239.37,86.02)
  BOTTOM w0.076: v2(177.21,90.17) 177.27,90.24 U4555.AL7
PWR_DEBUG: length 40.9
  TOP w0.254: v2(233.69,88.17) 234.83,87.03 CN4920.45 ; v2(217.58,77.68) 217.68,77.58 v1(218.73,77.58) 220.85,77.58 221.9,76.53 R4590.1
  L3 w0.254: v2(217.58,77.68) 218.73,78.83 218.73,80.53 220.51,82.31 222.97,82.31 225.73,85.08 230.26,85.08 233.35,88.17 v2(233.69,88.17)
  L5 w0.254: v2(217.58,77.68) 217.58,77.76 217.02,78.32 212.13,78.32 211.73,77.91 209.35,77.91 v2(209.17,77.73)
  BOTTOM w0.254: v2(209.17,77.73) 209.26,77.73 209.56,78.03 U4555.H59
PWR_GOOD_3: length 268.4
  TOP w0.102: 241.01,106.59 U7400.7 241.01,109.4 240.57,109.84 240.57,110.94 R7404.2 242.35,110.94 R7407.2 ; 241.01,106.59 240.57,106.16 239.34,106.16 R7406.2 ; 241.01,106.59 241.01,105.32 240.36,104.67 U7400.1 240.36,102.31 240.82,101.84 v2(240.82,101.53) ; v2(148.57,105.89) 148.89,105.89 152.18,102.6 152.18,100.06 151.04,98.92 151.04,96.23 151.37,95.89 151.37,92.78 152.09,92.07 152.09,89.98 153.1,88.97 R4925.2 ; 226.09,92.31 Q4920.2 Q4920.5 ; 226.09,92.31 Q4921.5 ; 226.09,92.31 226.6,92.82 226.6,93.33 226.85,93.58 228.11,93.58 228.36,93.33 v2(228.36,92.79) 228.36,92.61 228.65,92.31 Q4921.2 ; Q4926.5 240.32,84.65 240.61,84.95 241.08,84.95 241.46,85.33 241.46,85.58 241.89,86.01 C4920.1 241.79,86.19 v2(241.33,86.19) ; v2(273.21,115.05) 273.89,114.36 v1(273.89,113.9) 274.23,113.57 274.23,112.11 273.82,111.7 273.68,111.7 273.28,111.31 U300.72
  L5 w0.102: v2(273.21,115.05) 273.21,115.3 272.6,115.91 268.46,115.91 266.83,117.54 266.83,120.69 v2(266.22,121.3)
  L6 w0.102: v2(246.03,101.55) 246.57,102.09 248.19,102.09 251.75,105.65 251.75,105.93 258.97,113.15 268.6,113.15 271.15,115.71 272.55,115.71 v2(273.21,115.05) ; v2(241.33,86.19) 240.73,85.58 238.67,85.58 238.28,85.96 238.28,89.01 235.48,91.81 231.29,91.81 230.32,92.79 v2(228.36,92.79)
  BOTTOM w0.102: v2(148.57,105.89) 148.57,109.28 153.59,114.3 156.78,114.3 156.78,114.3 157.85,114.3 159.45,115.91 159.45,115.91 165.96,122.41 206.75,122.41 206.9,122.57 208.19,123.86 226.19,123.86 233.14,123.86 239.55,123.86 240.96,125.26 257.73,125.26 260.36,122.64 264.88,122.64 v2(266.22,121.3) ; v2(240.82,101.53) 241.44,102.15 245.44,102.15 v2(246.03,101.55) 245.75,101.27 245.75,90.78 242.76,87.79 241.69,87.79 240.9,87.01 240.9,86.35 241.06,86.19 v2(241.33,86.19)
PWRBTN#: length 25.9
  TOP w0.102: v3(273.72,112.38) 273.72,112.89 273.13,113.48 C100.1 272.83,112.89 273.21,112.51 273.21,111.99 272.88,111.66 U300.73 ; D100.3 289.21,120.13 287.81,120.13 287.26,119.58 R100.2 R101.2 286.08,119.58 v2(285.4,120.25)
  L3 w0.102: v3(273.72,112.38) 274.47,113.14 280.95,113.14 283.88,116.06 283.88,118.73 v2(285.4,120.25)
R_SPI_CLK_FLH: length 18.5
  TOP w0.114: C7488.2 173.87,85.98 v2(174.54,85.98)
  L6 w0.114: v3(159.93,87.48) 159.93,87.48 160.64,86.77 162.04,86.77 162.96,86.77 163.51,86.22 168.83,86.22 169.4,85.66 171.22,85.66 171.54,85.98 172.58,85.98 172.64,86.03 174.49,86.03 v2(174.54,85.98)
  BOTTOM w0.114: R4794.2 159.57,87.87 159.93,87.52 159.93,87.48 v3(159.93,87.48) ; U4555.AA3 174.54,85.86 v2(174.54,85.98)
R_SPI_CS0#_FLH: length 34.8
  L6 w0.076: v2(177.17,84.58) 176.94,84.81 176.94,85.61 176.71,85.84 175.71,85.84 175.33,85.46 174.79,85.46 174.76,85.44 173.51,85.44 173.01,84.94 171.77,84.94 171.58,85.13 169.22,85.13
  L6 w0.114: v2(155.1,82.43) 155.1,82.5 155.99,83.4 158.07,83.4 159.22,84.55 159.22,85.39 159.49,85.66 168.64,85.66 169,85.31 169.01,85.31 169.18,85.13 169.22,85.13
  BOTTOM w0.076: v2(177.17,84.58) 177.47,84.88 U4555.Y7
  BOTTOM w0.114: 147.99,82.28 v1(147.99,82.28) ; 147.99,82.28 150.35,82.28 151.07,83 154.53,83 v2(155.1,82.43) ; 147.99,82.28 147.78,82.49 R4790.2
R_SPI_HOLD#_DB: length 8.5
  BOTTOM w0.076: U4555.AF1 173.54,87.85 172.17,87.85 172.04,87.72 171.7,87.72 171.5,87.93 170.72,87.93 170.43,87.64 169.63,87.64 169.31,87.96 169.22,87.96
  BOTTOM w0.114: 169.22,87.96 167.76,87.96 166.99,88.72 R4795.2 166.99,89.13 v1(166.4,89.72)
R_SPI_SI_FLH: length 11.8
  BOTTOM w0.076: U4555.AA2 174.19,85.6 173.89,85.9 173.09,85.9 172.98,86.01 172.32,86.01 172.23,85.92 171.1,85.92 171.02,85.84
  BOTTOM w0.102: 171.02,85.84 169.22,85.84
  BOTTOM w0.114: R4796.2 164.74,86.35 166.51,86.35 167.02,85.84 168.56,85.84 v1(168.69,85.96) 168.82,85.84 169.22,85.84
R_SPI_WP#: length 13.9
  L6 w0.114: v2(176.51,84.58) 176.06,84.14 175.54,84.14 175.17,83.76 172.14,83.76 171.27,82.89 171.27,82.82 171.02,82.57 170.54,82.57 170.05,83.06 168.49,83.06 167.93,83.63 166.72,83.63 v3(166.32,83.23)
  BOTTOM w0.076: v2(176.51,84.58) 176.82,84.89 U4555.Y6
  BOTTOM w0.114: v3(166.32,83.23) 166.32,82.71 165.58,81.97 R4793.2
RD_DN: length 55.1
  TOP w0.089: CN3601.3 323.84,107.14 323.84,106.99 322.99,106.14 321.84,106.14 v1(321.34,105.65) 321.09,105.9 316.95,105.9 313.69,102.64 313.69,99.72 313.69,99.72 313.69,99.14 312.83,98.28 311.06,98.28 310.82,98.04 310.64,98.04 310.12,97.52 U470.19
  L3 w0.089: CN3601.3 324.49,107.79 324.49,108.08 324.38,108.2 323.95,108.2 323.84,108.09 323.84,107.99 323.67,107.82 323.67,107.58 323.84,107.41 323.84,106.99 323.49,106.64 322.32,106.64 320.73,108.23 318.93,108.23 317.41,106.7 317.41,105.72 313.76,102.07 313.76,92.45 313.84,92.37 313.91,92.37 314.01,92.27 314.01,92.12 313.91,92.02 313.84,92.02 313.76,91.94 313.76,91.69 313.87,91.58 314.18,91.58 314.28,91.48 314.28,91.33 314.18,91.23 313.87,91.23 313.76,91.12 313.76,90.89 314.22,90.44 314.36,90.44 314.55,90.63 314.7,90.63 314.8,90.52 314.8,90.37 314.61,90.19 314.61,90.04 314.94,89.71 315.28,89.71 315.38,89.82 315.38,90.18 315.48,90.28 315.63,90.28 315.74,90.18 315.74,89.82 315.84,89.71 316.18,89.71 JACK485.6
RD_DP: length 55.1
  TOP w0.089: CN3601.2 323.32,107.2 323.4,107.12 323.4,106.89 322.91,106.4 322.74,106.4 322.56,106.59 322.36,106.59 322.15,106.38 321.88,106.38 v1(321.34,106.92) 321.34,106.41 321.08,106.14 320.76,106.14 320.67,106.23 320.4,106.23 320.31,106.14 320.05,106.14 319.96,106.23 319.69,106.23 319.6,106.14 319.34,106.14 319.25,106.23 318.98,106.23 318.89,106.14 318.62,106.14 318.54,106.23 318.27,106.23 318.18,106.14 317.91,106.14 317.82,106.23 317.56,106.23 317.47,106.14 316.85,106.14 313.45,102.74 313.45,99.72 313.45,99.24 312.73,98.52 310.96,98.52 310.72,98.28 310.62,98.28 310.12,98.79 U470.20
  L3 w0.076: 316.95,89.42 317.5,89.97
  L3 w0.089: JACK485.3 318.56,87.93 318.56,89.64 318.23,89.97 317.5,89.97 ; CN3601.2 322.93,106.93 322.44,106.93 320.85,108.52 318.81,108.52 317.12,106.82 317.12,105.84 313.47,102.2 313.47,90.77 314.82,89.42 316.95,89.42
REC_MUTE_LED: length 14.7
  TOP w0.102: v2(270.16,89.27) 269.65,89.77 267.88,89.77 267.03,90.62 R392.1 ; Q320.6 277.38,91.59 v3(277.93,92.14)
  L5 w0.102: v3(277.93,92.14) 274.23,92.14 271.35,89.27 v2(270.16,89.27)
RSMRST#: length 218.4
  TOP w0.102: R330.2 265.59,114.87 v2(265.43,115.03) ; v2(214.79,153.78) 214.15,154.42 210.6,154.42 210.47,154.29 210.47,153.99 R7010.2 210.47,153.83 210.47,152.39 209.46,151.37 205.01,151.37 200.18,146.54 v2(200.18,144.26)
  L3 w0.102: v2(214.79,153.78) 215.3,154.29 215.3,156.58 220.37,161.65 251.38,161.65 253.57,159.46 253.57,152.44 257.21,148.8 260.71,148.8 267.19,142.33 267.19,140.22 266.5,139.53 266.5,136.54 265.38,135.41 265.38,115.08 v2(265.43,115.03)
  L6 w0.102: v3(161.02,105.01) 159.93,106.11 159.93,114.03 163.13,117.24 163.13,142.51 164.07,143.44 194.93,143.44 195.74,144.26 v2(200.18,144.26)
  BOTTOM w0.076: U4555.AW6 176.91,95.87 177.2,96.16 177.2,97.41 176.81,97.8 176.69,97.8 175.44,99.05
  BOTTOM w0.102: v3(161.02,105.01) 161.78,105.78 165.01,105.78 166.53,104.26 166.9,104.26 170.68,100.48 170.68,100.21 171.2,99.68 172.35,99.68 172.98,99.05 175.44,99.05
RTC_X1: length 17
  BOTTOM w0.076: 175.17,98.46 175.47,98.46 176.25,97.68 176.25,97.05 176.45,96.84 176.45,96.16 176.16,95.87 U4555.AW5
  BOTTOM w0.102: C4767.2 164.07,102.82 X4750.4 165.74,102.55 R4862.1 165.82,102.58 v1(166.7,102.58) 166.8,102.58 170.92,98.46 175.17,98.46
RTC_X2: length 15.6
  BOTTOM w0.076: U4555.AY5 176.12,96.52 175.98,96.66 175.98,97.49 175.36,98.1 175.17,98.1
  BOTTOM w0.102: 175.17,98.1 170.77,98.1 167.57,101.31 v1(166.7,101.31) 166.34,101.67 R4862.2 165.74,101.64 X4750.1 164.07,101.37 C4788.2
RTCRST#: length 68.6
  TOP w0.102: v2(131.86,78.08) 130.71,78.08 CN4941.9 ; v2(142.46,86.58) 142.46,86.66 143.49,87.7 143.49,96.07 144.52,97.11 v2(144.52,97.22)
  L6 w0.102: v2(144.52,97.22) 144.52,99.65 144.99,100.11 151.57,100.11 152.03,100.57 158.17,100.57 158.81,99.93 168.28,99.93 169.04,99.17 170.33,99.17 174.17,95.32 176.89,95.32 v2(177.28,94.94)
  BOTTOM w0.076: U4555.AU7 177.7,94.57 177.33,94.94 v2(177.28,94.94)
  BOTTOM w0.102: v2(142.46,86.58) 142.39,86.58 141.65,85.84 141.65,83.99 140.35,82.68 140.35,82.06 139.6,81.31 138.91,81.31 138.61,81.01 134.79,81.01 v2(131.86,78.08) ; R4845.2 144.51,97.94 C4768.1 144.51,97.24 v2(144.52,97.22)
RUNSCI_EC#: length 178.3
  TOP w0.102: v2(271.86,108.8) 271.68,108.98 U300.76 ; v3(165.64,107.96) 165.64,105.77 166.43,104.98 166.43,104.98 167.55,103.86 167.55,100.32 166.74,99.51 166.74,94.96 168.03,93.68 168.03,91.23 167.83,91.04 167.83,89.86 168.12,89.58 168.52,89.58 168.79,89.31 v2(168.79,76.5) ; v4(156.03,75.68) 155.14,76.57 R4785.1
  L5 w0.102: v2(271.86,108.8) 270.71,109.95 266.75,109.95 265.08,111.62 265.08,114.13 264.33,114.88 v2(264.33,116.29)
  L6 w0.102: v2(175.17,78.45) 174.79,78.07 174.24,78.07 172.17,76.01 170.31,76.01 169.82,76.5 v2(168.79,76.5) 167.63,76.5 166.45,75.32 158.53,75.32 158.32,75.53 157.74,76.11 156.47,76.11 156.04,75.68 v4(156.03,75.68)
  BOTTOM w0.076: U4555.G4 175.49,78.07 175.17,78.39 v2(175.17,78.45)
  BOTTOM w0.102: v2(264.33,116.29) 264.32,116.29 263.18,117.43 259.65,117.43 258.44,118.64 252.53,118.64 251.8,117.9 250.69,117.9 243.36,117.9 242.74,117.28 242.53,117.07 242.23,117.07 242.23,117.07 212.03,117.07 211.05,116.09 208.33,116.09 170.93,116.09 165.82,110.97 165.82,108.14 v3(165.64,107.96)
SA0_DIM0: length 5.6
  TOP w0.381: v2(201.8,136.51) 202.51,135.8 R4103.2 R4101.1
  BOTTOM w0.381: v2(201.8,136.51) CN4100.197
SA0_DIM1: length 6.8
  TOP w0.102: v3(124.09,137.64) 124.87,136.86 124.87,135.09 R4125.1
  BOTTOM w0.102: CN4125.197 124.8,136.93 v3(124.09,137.64)
SA1_DIM0: length 2.6
  TOP w0.102: v3(200.51,135.93) 200.86,135.58 R4100.1
  BOTTOM w0.102: CN4100.201 200.6,135.84 v3(200.51,135.93)
SA1_DIM1: length 2.7
  TOP w0.102: v3(123.54,135.91) 123.41,135.77 R4126.2
  BOTTOM w0.102: CN4125.201 123.6,135.85 v3(123.54,135.91)
SATA_RX1_C_DN: length 136.4
  TOP w0.114: v2(70.31,88.73) 70.54,88.5 70.54,88.25 69.63,87.34 69.63,84.35 71.03,82.94 71.22,82.94 74.61,82.94 75.02,82.54 76.06,82.54 C1702.1
  L3 w0.102: v2(169.32,75.3) 169.27,75.3 169.08,75.49 169.08,75.61 168.56,76.13 160.15,76.13 157.98,78.31 156.71,78.31 156.13,77.73 153.7,77.73 152.24,79.19 143.83,79.19 143.33,79.7 141.98,79.7 141.3,80.39 139.35,80.39 134.63,85.1 126.7,85.1 125.72,86.08 116.88,86.08 115.13,87.83 110.23,87.83 109.4,88.66 102.93,88.66 99.18,84.91 94.69,84.91 93.5,86.09 90.96,86.09 90.46,86.6 88.76,86.6 86.28,84.11 82.94,84.11 81.31,85.74 81.31,86.36 80.47,87.2 74.39,87.2 72.06,89.53 70.73,89.53 70.43,89.24 70.43,88.85 v2(70.31,88.73)
  L6 w0.076: 177.73,77.75 177.74,77.73 177.85,77.73 177.96,77.84 177.96,78.23 177.96,78.44 178.16,78.64 178.35,78.64 v2(178.51,78.8)
  L6 w0.114: v2(169.32,75.3) 169.25,75.22 169.25,75.03 169.54,74.74 171.38,74.74 174.36,77.71 175.06,77.71 175.48,78.14 176.97,78.14 177.36,77.75 177.73,77.75
  BOTTOM w0.076: v2(178.51,78.8) 178.2,79.1 178.04,79.1 U4555.J8
SATA_RX1_C_DP: length 136.3
  TOP w0.114: C1703.1 76.19,83.15 75.8,82.76 75.11,82.76 74.71,83.17 71.13,83.17 69.86,84.44 69.86,87.24 70.77,88.16 70.77,88.49 v2(71.01,88.73)
  L3 w0.102: v2(71.01,88.73) 70.89,88.73 70.65,88.97 70.65,89.15 70.82,89.32 71.97,89.32 74.3,86.99 80.38,86.99 81.1,86.27 81.1,85.65 82.85,83.9 86.37,83.9 88.85,86.38 90.37,86.38 90.87,85.88 93.41,85.88 94.6,84.69 99.27,84.69 103.02,88.45 109.31,88.45 110.14,87.62 115.04,87.62 116.79,85.87 125.63,85.87 126.61,84.89 134.54,84.89 139.26,80.17 141.21,80.17 141.89,79.49 143.24,79.49 143.74,78.98 152.15,78.98 153.61,77.52 156.22,77.52 156.8,78.09 157.89,78.09 160.06,75.92 168.47,75.92 168.87,75.52 168.87,75.4 v2(168.72,75.26)
  L6 w0.076: v2(178.52,78.19) 178.52,78.25 178.3,78.47 178.23,78.47 178.12,78.37 178.12,78.3 178.12,78.3 178.12,77.77 177.86,77.51 177.83,77.51
  L6 w0.114: 177.83,77.51 177.26,77.51 176.87,77.9 175.58,77.9 175.16,77.47 174.46,77.47 171.48,74.5 169.44,74.5 168.99,74.95 168.99,75.04 168.78,75.26 v2(168.72,75.26)
  BOTTOM w0.076: U4555.H8 178.04,78.45 178.26,78.45 v2(178.52,78.19)
SATA_RX1_DN: length 3.9
  TOP w0.114: CN1700.S5 78.15,80.7 78.56,81.11 78.56,82.11 77.83,82.84 77.25,82.84 77.04,82.63 C1702.2
SATA_RX1_DP: length 3.9
  TOP w0.114: C1703.2 77.04,83.3 77.27,83.07 77.93,83.07 78.79,82.2 78.79,81.11 CN1700.S6
SATA_TX1_C_DN: length 144.2
  TOP w0.114: v2(68.54,88.73) 68.34,88.54 68.34,83.69 69.88,82.15 70.47,82.15 C1704.1
  L3 w0.102: v2(68.54,88.73) 68.34,88.92 68.34,89.23 68.09,89.48 66.52,89.48 66.16,89.13 66.16,87.73 68.74,85.15 79.11,85.15 80.25,84.01 80.25,83.58 81.51,82.32 88.39,82.32 89.06,81.65 92.74,81.65 93.47,82.37 93.47,83.21 93.96,83.7 99.55,83.7 103.4,87.56 109.21,87.56 109.85,86.92 114.75,86.92 116.5,85.17 119.14,85.17 120.32,83.99 134.45,83.99 139.04,79.4 140.71,79.4 142.96,77.15 145.45,77.15 146.39,78.09 151.95,78.09 153.25,76.79 157.83,76.79 159.56,75.06 166.99,75.06 169.07,72.98 180.09,72.98 180.63,72.45 181.52,72.45 181.78,72.72 181.95,72.72 v2(182.16,72.51)
  BOTTOM w0.076: v2(182.16,72.51) 182.41,72.75 182.53,72.75 182.94,73.15 182.94,73.7 182.94,73.7 182.94,74.01 183.08,74.15 183.23,74.15 183.33,74.05 183.33,73.95 183.27,73.89 U4555.A17
SATA_TX1_C_DP: length 144.1
  TOP w0.114: C1705.1 70.32,81.93 69.79,81.93 68.12,83.6 68.12,88.52 67.9,88.73 v2(67.77,88.73)
  L3 w0.102: v2(67.77,88.73) 67.98,88.73 68.13,88.88 68.13,89.14 68,89.27 66.61,89.27 66.38,89.04 66.38,87.82 68.83,85.36 79.2,85.36 80.46,84.1 80.46,83.67 81.59,82.54 88.48,82.54 89.15,81.86 92.65,81.86 93.25,82.46 93.25,83.3 93.87,83.92 99.46,83.92 103.31,87.77 109.3,87.77 109.94,87.13 114.84,87.13 116.59,85.38 119.23,85.38 120.41,84.2 134.54,84.2 139.13,79.61 140.8,79.61 143.05,77.37 145.36,77.37 146.3,78.31 152.04,78.31 153.34,77 157.92,77 159.65,75.28 167.08,75.28 169.16,73.2 180.18,73.2 180.71,72.67 181.43,72.67 181.69,72.93 181.93,72.93 v2(182.16,73.17)
  BOTTOM w0.076: U4555.B17 183.37,74.32 183.02,74.32 182.77,74.07 182.77,74.01 182.77,73.22 182.46,72.91 182.25,72.91 182.16,73 v2(182.16,73.17)
SATA_TX1_DN: length 4.8
  TOP w0.114: C1704.2 71.83,82.15 74.37,82.15 75.01,81.52 75.01,81.09 CN1700.S3
SATA_TX1_DP: length 4.8
  TOP w0.114: C1705.2 71.58,81.69 71.81,81.93 74.28,81.93 74.78,81.42 74.78,81.16 74.32,80.7 CN1700.S2
SC_PWRSV#: length 91.1
  TOP w0.102: v2(102.37,85.35) 102.37,87.21 104.41,89.25 104.41,89.25 104.43,89.27 105.3,89.27 105.55,89.52 CN200.13
  L3 w0.102: v2(155.84,72.21) 155.42,72.63 151.04,72.63 148.88,74.79 140.19,74.79 137.01,77.96 135.54,77.96 131.82,81.69 113.99,81.69 111.8,83.87 103.62,83.87 103.03,84.47 103.03,84.69 v2(102.37,85.35)
  BOTTOM w0.076: 170.88,77.77 171.28,78.17 172.1,78.17 172.49,78.57 173.66,78.57 173.83,78.74 173.83,78.91 174.06,79.15 174.58,79.15 U4555.J3
  BOTTOM w0.102: 170.88,77.77 170.05,76.95 168.5,76.95 166.44,74.89 165.47,74.89 162.32,74.89 161.42,73.99 161.42,72.6 160.03,71.21 159.9,71.21 156.84,71.21 v2(155.84,72.21) 155.42,72.63 154.38,72.63 R4757.1
SC_PWRSV#_SM: length 31.3
  TOP w0.102: CN9000.13 77.5,106.54 v2(78.52,105.52)
  TOP w0.381: R9011.2 v3(70.64,121.52)
  L3 w0.102: v2(78.52,105.52) 76.87,103.87 71.28,103.87 69.76,105.4 69.76,108.95 68.49,110.22 68.49,119.11 70.64,121.27 v3(70.64,121.52)
SCAN_3S_IN<0>: length 26.7
  TOP w0.102: U300.29 274.88,94.11 275.24,93.75 v2(275.24,93.71) ; D302.6 285.89,89.27 285.65,89.02 285.4,89.02 285.14,88.76 285.14,88.16 v2(285.35,87.95) ; RS340.1 272.23,88.65 v1(272.09,88.5) 272.09,88.16 273.01,87.24 v2(273.85,87.24)
  L3 w0.102: v2(275.24,93.71) 275.44,93.51 275.44,91.85 274.73,91.15 274.73,89.29 275.11,88.91 275.11,88.33 274.03,87.24 v2(273.85,87.24)
  L6 w0.102: v2(273.85,87.24) 273.84,87.24 273.85,87.23 276.77,87.23 277.27,87.74 285.15,87.74 v2(285.35,87.95)
SCAN_3S_IN<1>: length 25.9
  TOP w0.102: v3(273.23,87.87) 272.95,88.15 RS340.2 ; v2(285.58,88.61) 285.81,88.38 286.77,88.38 287.19,87.96 D302.3 ; v2(275.03,93.11) 274.81,93.33 274.81,93.71 274.48,94.04 U300.28
  L3 w0.102: v2(275.03,93.11) 275.03,91.85 274.48,91.3 274.48,89.07 274.78,88.77 274.78,88.33 274.32,87.87 v3(273.23,87.87)
  L6 w0.102: v3(273.23,87.87) 273.97,87.87 274.35,87.49 276.47,87.49 277.1,88.12 284.45,88.12 284.93,88.61 v2(285.58,88.61)
SCAN_3S_IN<2>: length 17
  TOP w0.102: D304.6 281.07,90.68 v3(281.01,90.74) ; RS340.3 273.59,88.91 v2(273.72,88.78) ; U300.27 274.08,93.8 v2(274.18,93.7)
  L3 w0.102: v2(274.18,93.7) 274.48,93.41 274.48,91.93 273.72,91.17 v2(273.72,88.78)
  L6 w0.102: v3(281.01,90.74) 279.28,89.01 273.95,89.01 v2(273.72,88.78)
SCAN_3S_IN<3>: length 18.2
  TOP w0.102: v3(274.38,88.5) 274.23,88.65 RS340.4 ; U300.26 273.68,93.86 273.56,93.74 v2(273.56,93.74) ; v2(282.39,88.71) 282.37,88.69 282.37,87.79 D304.3
  L3 w0.102: v3(274.38,88.5) 274.21,88.33 273.56,88.33 273.21,88.68 273.21,91.43 273.59,91.81 273.59,93.71 v2(273.56,93.74)
  L6 w0.102: v3(274.38,88.5) 274.53,88.66 282.34,88.66 v2(282.39,88.71)
SCAN_3S_IN<4>: length 16.6
  TOP w0.102: U300.25 273.28,94.04 273.24,94 273.16,93.91 273.16,93.57 273.68,93.05 v2(274.01,93.05) 274.95,92.11 RS340.6 ; v3(282.73,92.19) 283.17,91.76 283.17,90.16 283.48,89.84 283.48,89.58 283.48,89.58 D303.6
  L6 w0.102: v2(274.01,93.05) 274.49,92.57 282.35,92.57 v3(282.73,92.19)
SCAN_3S_IN<5>: length 20.2
  TOP w0.102: D303.3 284.78,87.68 284.78,87.68 284.78,88.29 284.28,88.8 283.24,88.8 282.94,89.1 282.94,91.09 282.05,91.98 v3(281.34,91.98) ; RS340.7 274.23,92.18 273.73,92.68 273.3,92.68 v2(273.1,92.89) 272.92,93.06 272.92,94.12 272.88,94.16 U300.24
  L6 w0.102: v3(281.34,91.98) 280.9,91.54 274.44,91.54 v2(273.1,92.89)
SCAN_3S_IN<6>: length 19
  TOP w0.102: v3(284.13,93.46) 286.49,93.46 D301.3 ; U300.23 272.48,93.82 v2(272.52,93.78) 272.52,92.88 273.59,91.81 RS340.8
  L6 w0.102: v2(272.52,93.78) 273.26,94.52 279.13,94.52 279.69,93.97 283.62,93.97 v3(284.13,93.46)
SCAN_3S_IN<7>: length 12.6
  TOP w0.102: v2(272.7,86.98) 273.16,86.52 273.16,85.89 272.95,85.68 CN300.12 ; U300.22 272.08,92.87 v3(271.81,92.6) 272.28,92.6 272.95,91.93 RS340.9
  BOTTOM w0.102: v3(271.81,92.6) 272.7,91.71 v2(272.7,86.98)
SCAN_3S_OUT<0>: length 199.7
  TOP w0.102: v2(288.58,90.54) 289.01,90.1 289.01,86.29 289.75,85.55 CN300.33 ; v2(271.66,93.84) 271.68,93.86 U300.21 ; v2(244.84,64.11) 242.62,64.11 240.7,66.03 240.7,71.39 238.47,73.62 233.07,73.62 232.89,73.8 232.67,74.02 232.34,74.35 230.35,74.35 227.62,71.61 v1(226.73,71.61) 225.84,71.61 225.03,70.8 223.12,70.8 v2(222.66,70.34)
  L5 w0.102: v2(142.27,82.03) 142.27,81.39 142.78,80.88 142.78,80.38 148.34,74.81 151.39,74.81 151.8,75.22 155.89,75.22 156.02,75.1 159.27,75.1 160.55,73.82 173.08,73.82 174.07,72.83 178.6,72.83 179.53,73.77 182.68,73.77 183.27,73.19 183.27,72.71 183.92,72.06 186.95,72.06 187.92,71.1 195.2,71.1 196.91,72.81 203.03,72.81 204.84,70.99 206.75,70.99 207.77,69.97 208.64,69.97 209.15,70.48 213.67,70.48 214.62,69.53 221.85,69.53 v2(222.66,70.34) ; v2(288.58,90.54) 287.69,90.54 285.4,92.82 279.43,92.82 277.48,94.78 272.6,94.78 v2(271.66,93.84)
  L6 w0.102: v2(244.84,64.11) 244.84,64.94 246.82,66.91 246.82,68.69 248.66,70.53 250.93,70.53 257.37,76.97 257.37,87.93 261.53,92.09 261.53,96 262.29,96.76 268.74,96.76 v2(271.66,93.84)
  BOTTOM w0.102: R339.1 142.65,81.65 v2(142.27,82.03)
SCAN_3S_OUT<1>: length 184.4
  TOP w0.102: v2(271.53,93.21) 271.53,93.2 271.18,93.55 271.18,93.94 271.28,94.04 U300.20 ; v2(245.98,64.96) 242.35,64.96 241.1,66.2 241.1,71.56 238.64,74.03 233.24,74.03 232.51,74.75 229.1,74.75 227.24,72.88 v1(226.73,72.88) 226.22,72.88 224.64,71.31 222.36,71.31 v2(221.39,70.34) ; v2(275.35,86.08) 275.35,86.08 CN300.15
  L3 w0.102: v2(275.35,86.08) 273.6,86.08 273.13,86.55 273.13,87.18 272.57,87.74 272.57,92.75 272.11,93.21 v2(271.53,93.21)
  L5 w0.102: v2(221.39,70.34) 215.32,70.34 214.9,70.77 213.95,71.72 207.21,71.72 206,72.93 203.57,72.93 202.94,73.55 192.71,73.55 192.67,73.51 188.54,73.51 187.56,72.53 183.98,72.53 183.65,72.87 183.65,73.34 182.84,74.15 179.21,74.15 178.28,73.22 174.45,73.22 173.06,74.61 161.02,74.61 158.55,77.07 156.85,77.07 156.39,77.53 152.74,77.53 150.76,75.55 149.42,75.55 147.35,77.62 147.35,78.5 144.74,81.11 143.75,81.11 143.12,81.74 143.12,83.89 v2(142.86,84.14)
  L6 w0.102: v2(275.35,86.08) 273.6,86.08 273.16,86.52 273.16,87.13 272.57,87.72 264.34,87.72 263.81,88.25 259.21,88.25 257.69,86.73 257.69,77 250.93,70.24 248.73,70.24 247.07,68.59 247.07,66.23 245.98,65.14 v2(245.98,64.96)
  BOTTOM w0.102: v2(142.86,84.14) R338.1
SCAN_3S_OUT<2>: length 199
  TOP w0.102: v2(222.03,70.34) 222.74,71.05 224.9,71.05 226.09,72.25 227.36,72.25 v1(228.76,73.65) 229.66,74.55 232.43,74.55 232.87,74.1 233.03,73.94 233.15,73.82 238.55,73.82 240.9,71.48 240.9,66.12 242.49,64.53 246.39,64.53 246.87,65.01 248.83,65.01 v2(249.97,66.15) ; v2(270.15,93.2) 270.88,93.93 U300.19 ; v2(279.97,83.81) 287.44,83.81 287.77,84.14 288.53,84.14 288.94,84.55 288.94,85.04 CN300.32
  L3 w0.102: v2(270.15,93.2) 270.92,92.42 270.92,85.58 271.98,84.53 279.24,84.53 v2(279.97,83.81)
  L5 w0.102: v2(142.27,82.74) 142.72,82.29 142.72,81.58 143.11,81.19 143.11,80.55 143.87,79.79 143.87,79.66 148.32,75.22 151.06,75.22 152.74,76.9 156.17,76.9 156.5,76.57 158.21,76.57 160.59,74.18 173.11,74.18 174.26,73.03 178.52,73.03 179.45,73.96 182.76,73.96 183.46,73.27 183.46,72.79 183.94,72.31 187.7,72.31 188.66,73.27 192.7,73.27 192.79,73.36 195.62,73.36 195.8,73.18 203.01,73.18 204.95,71.24 206.84,71.24 207.13,71.53 213.85,71.53 214.81,70.57 215.48,69.9 221.58,69.9 v2(222.03,70.34)
  L6 w0.102: v2(279.97,83.81) 278.95,84.82 265.23,84.82 263.05,82.64 263.05,81.49 260.03,78.47 260.03,75.75 258.1,73.82 256.11,73.82 256.11,73.82 255.84,73.82 249.97,67.96 v2(249.97,66.15)
  BOTTOM w0.102: R336.1 142.48,82.54 v2(142.27,82.74)
SCAN_3S_OUT<3>: length 190.2
  TOP w0.102: v2(245.52,64.12) 245.11,63.7 242.74,63.7 240.49,65.95 240.49,71.31 238.39,73.42 233.84,73.42 232.37,71.94 231.4,71.94 231.05,72.3 229.06,72.3 v1(229.01,72.25) 227.9,71.13 225.74,71.13 225.08,70.47 223.43,70.47 v2(223.3,70.34) ; U300.18 270.48,94.18 v2(270.11,93.81) ; CN300.21 280.15,85.63 v2(279.76,86.01)
  L3 w0.102: v2(279.76,86.01) 278.48,84.73 272.16,84.73 271.18,85.71 271.18,92.74 270.11,93.81 v2(270.11,93.81)
  L5 w0.102: v2(223.3,70.34) 222.28,69.32 214.49,69.32 213.54,70.28 209.22,70.28 208.72,69.78 207.63,69.78 206.65,70.76 204.74,70.76 202.98,72.53 196.98,72.53 195.2,70.74 183.7,70.74 183.17,71.28 183.17,72.54 183.08,72.63 183.08,73.07 182.57,73.58 179.61,73.58 178.68,72.64 173.77,72.64 173.5,72.91 168.88,72.91 168.17,73.62 160.41,73.62 159.18,74.85 155.88,74.85 155.73,74.99 151.9,74.99 151.5,74.59 148.26,74.59 143.16,79.7 142.37,79.7 141.86,80.2 141.86,80.9 v2(141.9,80.93)
  L6 w0.102: v2(245.52,64.12) 245.72,64.12 247.43,65.83 247.43,66.92 247.96,67.45 247.96,67.8 248.32,68.16 249.49,68.16 251.03,69.71 251.03,69.78 255.28,74.03 256.19,74.03 258.02,74.03 259.67,75.68 259.67,79 262.85,82.18 262.85,82.73 265.19,85.08 278.82,85.08 v2(279.76,86.01)
  BOTTOM w0.102: v2(141.9,80.93) 142.69,80.93 R337.1
SCAN_3S_OUT<4>: length 20
  TOP w0.102: v2(272.83,96.12) 272.7,96 270.31,96 270.08,95.77 U300.17 ; CN300.19 278.55,86.59 v1(278.29,86.85) 278.29,87.77 277.53,88.53 277.3,88.53 276.89,88.94 276.89,89.52 277.12,89.75 277.6,89.75 v2(278.14,90.28)
  L3 w0.102: v2(272.83,96.12) 273.44,95.51 275.73,95.51 277.4,93.84 277.4,91.02 v2(278.14,90.28)
SCAN_3S_OUT<5>: length 30.3
  TOP w0.102: TP332.1 270.18,92.04 v2(270.18,92.57) 269.68,93.07 U300.16 ; CN300.31 288.15,85.05 288.15,84.53 287.97,84.34 287.69,84.34 287.56,84.21 279.53,84.21 v2(279.13,83.81)
  L3 w0.102: v2(270.18,92.57) 270.67,92.08 270.67,85.49 271.85,84.31 278.62,84.31 v2(279.13,83.81)
SCAN_3S_OUT<6>: length 20.4
  TOP w0.102: v2(276.23,87.92) 276.23,86.93 v1(276.63,86.54) 276.95,86.21 CN300.17 ; v2(271.3,96.63) 271,96.33 269.07,96.33 268.48,95.74 U300.13
  L3 w0.102: v2(271.3,96.63) 271.81,96.12 271.81,95.71 272.8,94.72 275.4,94.72 276.54,93.59 276.54,92.06 275.37,90.89 275.37,89.65 276.23,88.78 v2(276.23,87.92)
SCAN_3S_OUT<7>: length 21.7
  TOP w0.102: CN300.18 277.75,87.54 v1(277.32,87.97) 276.64,88.66 276.64,90.08 v2(276.87,90.31) ; v2(271.3,97.52) 270.36,96.58 268.81,96.58 268.08,95.85 U300.12
  L3 w0.102: v2(276.87,90.31) 276.87,93.8 275.49,95.18 272.88,95.18 272.32,95.74 272.32,96.51 v2(271.3,97.52)
SCAN_3S_OUT<8>: length 21.9
  TOP w0.102: CN300.20 279.35,84.64 278.54,83.83 v2(278.42,83.83) ; U300.10 267.28,92.87 266.86,92.44 v3(266.61,92.44)
  L3 w0.102: v2(278.42,83.83) 278.31,83.93 271.81,83.93 270.35,85.4 270.35,87.05 266.61,90.79 v3(266.61,92.44)
SCAN_3S_OUT<9>: length 12.7
  TOP w0.102: v1(270.26,86.52) 270.18,86.52 v2(269.71,86.06) 269.75,86.02 CN300.8 ; U300.9 266.88,94.06 267.01,93.93 267.01,93.41 266.74,93.14 v2(266.59,93.14)
  L3 w0.102: v2(269.71,86.06) 269.02,86.75 269.02,87.74 266.09,90.67 266.09,92.74 266.49,93.14 v2(266.59,93.14)
SCAN_3S_OUT<10>: length 20.3
  TOP w0.102: U300.8 266.48,93.88 v2(266.61,93.76) ; v2(275.67,88.17) v1(275.67,87.46) 275.67,86.47 276.15,85.99 CN300.16
  L3 w0.102: v2(275.67,88.17) 275.67,88.78 274.99,89.47 274.99,91.04 275.72,91.78 275.72,93.86 275.33,94.26 267.1,94.26 v2(266.61,93.76)
SCAN_3S_OUT<11>: length 33.2
  TOP w0.102: CN300.34 290.55,85.89 289.85,86.6 v1(289.85,86.85) v2(289.85,88) ; U300.7 266.08,94.16 266,94.08 266,92.15 266.22,91.93 267.09,91.93 267.63,91.39 267.63,90.8 v2(268.26,90.18)
  L5 w0.102: v2(268.26,90.18) 268.73,90.18 269.65,89.26 269.65,89.03 270.3,88.38 272.32,88.38 273.44,89.49 278.24,89.49 278.51,89.77 287.69,89.77 289.47,88 v2(289.85,88)
SCAN_3S_OUT<17>: length 109.4
  TOP w0.102: v4(323.63,154.38) SW154.3 ; v2(263.56,105.65) 263.56,105.01 263.07,104.53 U300.108 ; SW152.3 308.84,154.38 v2(308.83,154.38)
  L3 w0.102: v2(263.56,105.65) 265.17,107.27 265.17,110.01 266.34,111.18 266.34,112.27 267.5,113.43 267.5,119.53 268.38,120.41 268.38,131.65 271.85,135.11 279.54,135.11 284.82,129.83 285.05,129.6 289.67,129.6 295.94,135.88 295.94,140.19 308.83,153.08 v2(308.83,154.38)
  L6 w0.102: v4(323.63,154.38) 319.48,154.38 315.07,149.97 312.33,149.97 308.83,153.47 v2(308.83,154.38)
SCARDC6: length 58.5
  TOP w0.114: U9000.2 69.86,110.98 69.61,111.24 68.87,111.24 67.98,110.35 v3(65.82,110.35)
  BOTTOM w0.114: CN9001.6 36.26,132.77 34.82,132.77 32.93,130.87 32.93,118.1 38.39,112.63 63.53,112.63 v3(65.82,110.35)
SCARDC8: length 53.8
  TOP w0.114: U9000.1 69.21,110.54 69.11,110.65 68.95,110.65 68.14,109.84 65.56,109.84 65.31,110.09 65.31,111.24 v3(65.82,111.75)
  BOTTOM w0.114: CN9001.8 36.26,127.69 35.03,127.69 34.45,127.11 34.45,118.73 38.77,114.41 66.07,114.41 66.58,113.9 66.58,113.02 65.82,112.25 v3(65.82,111.75)
SCARDCLK: length 25.5
  TOP w0.114: v2(71.79,112.51) 72.46,111.83 U9000.6
  BOTTOM w0.114: v2(71.79,112.51) 71.79,113.9 67.98,117.71 67.98,121.92 68.23,122.17 68.23,126.22 66.07,128.38 64.87,128.38 63.02,130.23 CN9001.3
SCARDDATA: length 48.8
  TOP w0.102: R9001.1 66.28,113.52 v3(65.69,113.52)
  BOTTOM w0.114: v3(65.69,113.52) 38.51,113.52 33.69,118.35 33.69,129.14 34.77,130.23 36.26,130.23 CN9001.7
SCARDFCB: length 30.4
  TOP w0.114: U9000.3 70.51,111.24 69.88,111.87 68.74,111.87 67.72,110.86 v3(67.22,110.86)
  BOTTOM w0.114: CN9001.4 62.52,127.69 66.13,127.69 67.85,125.97 67.85,122.41 67.6,122.16 67.6,116.95 70.01,114.54 70.01,113.02 69.63,112.63 67.34,112.63 66.71,112 66.71,111.36 v3(67.22,110.86)
SCARDRST: length 28.9
  TOP w0.114: U9000.5 v2(71.81,111.34)
  BOTTOM w0.114: CN9001.2 63.46,132.77 64.17,132.07 64.17,129.91 65.18,128.89 66.33,128.89 68.71,126.5 68.71,122.13 68.36,121.78 68.36,118.6 72.68,114.29 72.68,112 72.02,111.34 v2(71.81,111.34)
SCL_BAT_CHG: length 217
  TOP w0.102: v2(171.04,69.01) 171.04,68.55 172.45,67.14 172.45,64.45 173.64,63.26 173.64,59.93 v1(172.63,58.91) 172.12,58.41 166.15,58.41 164.67,59.88 R6053.1 ; R307.1 257.73,103.59 v4(260.51,103.59) 261.17,102.93 U300.112
  TOP w0.254: U6000.9 287.31,129.77 v4(287.05,130.03)
  L3 w0.102: v4(287.05,130.03) 284.91,130.03 284.68,130.26 279.62,135.32 271.77,135.32 268.18,131.73 268.18,120.49 267.3,119.61 267.3,113.52 266.14,112.35 266.14,111.42 264.95,110.23 264.95,107.7 262.53,105.28 262.53,104.88 261.24,103.59 v4(260.51,103.59)
  L5 w0.102: v2(171.04,69.01) 171.04,68.92 171.82,68.13 173.67,68.13 174.02,68.49 176.12,68.49 176.49,68.11 177.91,68.11 178.79,69 181.42,69 181.45,68.97 181.45,68.95 183.13,67.27 185.2,67.27 185.46,67.53 191.38,67.53 192.06,68.21 197.78,68.21 199.82,66.17 199.82,62.68 200.27,62.24 212.25,62.24 213.12,63.1 219.81,63.1 220.59,63.89 226.97,63.89 227.23,64.15 244.2,64.15 244.6,64.55 246.36,64.55 247.57,65.76 247.57,66.59 248.27,67.3 248.27,67.53 248.52,67.78 250.18,67.78 250.84,68.43 252.54,68.43 254.88,70.77 258.75,70.77 261.19,73.21 261.19,74.25 262.28,75.34 262.28,78.23 262.28,78.46 263.48,79.66 263.48,92.63 263.81,92.96 263.81,97.78 262.54,99.05 262.54,101.56 v4(260.51,103.59)
SD_MMC_CD#: length 82.6
  TOP w0.114: v2(297.77,76.11) 297.09,75.42 v1(297.03,75.42) 296.96,75.42 296.66,75.12 296.66,74.36 295.56,73.26 295.56,72.12 295.4,71.96 U800.30 ; v2(285.99,58.18) 286.04,58.13 286.04,55.46 v2(288.4,53.1)
  L5 w0.114: v2(278.8,65.52) 279.81,66.53 279.81,67.66 281.05,68.9 281.05,73.68 279.86,74.87 278.46,74.87 276.77,76.57 276.77,76.95 277.15,77.33 278.38,77.33 279.14,76.57 281.54,76.57 284.95,79.97 284.95,81.16 287.87,84.09 289.15,84.09 291.5,81.75 292.46,81.75 296.32,77.89 296.32,76.06 296.88,75.5 297.16,75.5 v2(297.77,76.11)
  L6 w0.114: v2(288.4,53.1) 288.4,52.36 289.34,51.42 297.93,51.42 v2(299.42,52.91)
  BOTTOM w0.114: v2(285.99,58.18) 285.63,58.53 284,58.53 283.1,59.44 283.1,61.47 281.31,63.26 281.31,64 280.21,65.1 279.26,65.1 278.85,65.52 v2(278.8,65.52) ; CN820.11 v2(299.42,52.91)
SD_MMC_CLK: length 21.2
  TOP w0.114: U800.17 291.75,69.32 291.27,68.84 v2(290.66,68.84)
  BOTTOM w0.114: v2(290.66,68.84) 290.66,68.51 289.85,67.7 289.85,67.12 289.03,66.3 289.03,66.02 289.17,65.88 289.46,65.88 289.59,65.75 289.59,65.56 289.46,65.43 289.17,65.43 289.03,65.29 289.03,65.1 289.17,64.97 289.46,64.97 289.59,64.84 289.59,64.65 289.46,64.51 289.17,64.51 289.03,64.38 289.03,64.17 289.48,63.72 289.67,63.72 289.89,63.94 290.08,63.94 290.21,63.8 290.21,63.61 290,63.4 290,63.21 290.13,63.07 290.32,63.07 290.54,63.29 290.73,63.29 290.86,63.16 290.86,62.97 290.64,62.75 290.64,62.56 291.09,62.11 292.16,62.11 292.44,61.83 293.12,61.83 294.32,60.64 v1(294.8,60.64) 295.13,60.64 296.2,61.71 298.12,61.71 CN820.5
SD_MMC_CMD: length 17.5
  TOP w0.114: U800.19 292.55,68.49 291.14,67.08 291.14,64.81 291.78,64.17 294.27,64.17 294.98,64.88 294.98,66.83 296.22,68.08 297.49,68.08 v2(298.25,68.84)
  BOTTOM w0.114: v1(296.63,68.57) 297.39,68.57 297.9,69.07 CN820.2
SD_MMC_DATA0: length 21.1
  TOP w0.114: U800.16 290.99,69.96 290.1,69.07 290.1,68.64 289.77,68.31 289.11,68.31 v2(288.78,67.98)
  BOTTOM w0.114: CN820.7 297.56,57.26 v1(296.45,57.26) 295.82,57.26 293.92,59.16 293.92,59.35 294.12,59.55 294.12,59.74 293.99,59.88 293.8,59.88 293.59,59.67 293.28,59.67 291.86,61.09 291.48,61.09 288.65,63.92 288.65,67.24 288.78,67.37 v2(288.78,67.98)
SD_MMC_DATA1: length 21.9
  TOP w0.114: U800.15 290.85,70.36 289.22,68.73 288.89,68.73 288.27,68.11 v2(288.27,67.57)
  BOTTOM w0.114: v2(288.27,67.57) 288.27,63.78 290.73,61.32 291.33,60.72 291.59,60.72 v1(293.28,59.04) 293.94,58.38 294.14,58.38 297.59,54.92 CN820.8
SD_MMC_DATA2: length 20.7
  TOP w0.114: U800.21 293.35,68.82 294.06,68.11 v1(295.03,68.11) 295.13,68.11 v2(295.74,68.72)
  BOTTOM w0.114: CN820.9 299.3,74.07 300.14,73.23 300.56,73.23 300.69,73.1 300.69,72.91 300.56,72.77 300.14,72.77 300.01,72.64 300.01,72.45 300.14,72.32 300.56,72.32 300.69,72.18 300.69,71.99 300.56,71.86 300.14,71.86 300.01,71.73 300.01,71.54 300.14,71.4 300.56,71.4 300.69,71.27 300.69,71.08 300.56,70.95 300.14,70.95 300.01,70.81 300.01,70.62 300.14,70.49 300.56,70.49 300.69,70.35 300.69,70.17 300.56,70.03 300.14,70.03 300.01,69.9 300.01,69.71 300.14,69.57 300.56,69.57 300.69,69.44 300.69,69.25 300.56,69.12 300.14,69.12 300.01,68.98 300.01,68.29 299.68,67.96 296.45,67.96 295.74,68.67 v2(295.74,68.72)
SD_MMC_DATA3: length 20.2
  TOP w0.114: U800.20 292.95,68.29 291.7,67.04 291.7,64.96 292.03,64.63 294.16,64.63 294.52,64.98 294.52,66.9 296.21,68.59 v1(296.55,68.59) 296.56,68.6 296.56,69.37 296.67,69.47 296.83,69.47 297.41,68.89 297.56,68.89 297.67,69 297.67,69.15 297.09,69.73 297.09,69.89 297.19,69.99 297.35,69.99 297.93,69.41 298.08,69.41 298.19,69.52 298.19,69.67 297.61,70.25 297.61,70.41 297.77,70.57 v2(297.92,70.57)
  BOTTOM w0.114: CN820.1 297.92,71.25 v2(297.92,70.57)
SD_MMC_WP: length 36.5
  TOP w0.114: U800.29 295.53,71.56 295.95,71.98 295.95,72.12 296.45,72.62 296.59,72.62 v2(296.6,72.63)
  BOTTOM w0.114: CN820.10 299.07,53.91 299.75,54.6 299.75,56.83 300.31,57.39 303.44,57.39 303.94,57.9 303.94,62.34 303,63.28 303,65.82 302.04,66.79 302.04,74.66 301.33,75.37 297.03,75.37 296.6,74.94 v2(296.6,72.63)
SDA_BAT_CHG: length 213
  TOP w0.102: R306.1 v4(260.97,104.13) 260.98,104.11 260.98,103.58 261.24,103.33 U300.111 ; v2(170.55,68.61) 170.55,68.48 171.74,67.3 v1(171.74,64.12) 173.13,62.72 173.13,60.26 171.82,58.95 167.26,58.95 166.32,59.88 R6051.1
  TOP w0.254: U6000.8 v4(287.81,130.03)
  L3 w0.102: v4(287.81,130.03) 287.38,130.46 284.76,130.46 281.76,133.47 279.71,135.52 271.68,135.52 267.98,131.82 267.98,120.61 267.09,119.72 267.09,113.59 265.93,112.44 265.93,111.5 264.61,110.18 264.61,107.75 260.98,104.13 v4(260.97,104.13)
  L5 w0.102: v2(170.55,68.61) 170.78,68.61 171.58,67.8 173.69,67.8 174.15,68.27 176.05,68.27 176.41,67.91 177.99,67.91 178.88,68.8 181.31,68.8 183.04,67.07 185.77,67.07 185.95,67.25 191.57,67.25 192.05,67.73 197.98,67.73 199.62,66.09 199.62,62.57 200.18,62 212.38,62 213.24,62.86 219.91,62.86 220.68,63.62 227.41,63.62 227.53,63.74 244.25,63.74 244.29,63.7 245.8,63.7 247.77,65.67 247.77,66.42 248.11,66.76 249.84,66.76 251.17,68.09 252.61,68.09 255.04,70.52 258.79,70.52 261.58,73.3 261.58,74.35 262.48,75.25 262.48,78.31 263.68,79.51 263.68,92.54 264.01,92.87 264.01,98.1 262.92,99.19 262.92,102.17 v4(260.97,104.13)
SG_IN: length 19.1
  L6 w0.102: v2(160.41,77.35) 161.8,77.35 162.63,78.17 172.17,78.17 173.79,79.8 174.93,79.8 v2(175.11,79.98)
  BOTTOM w0.076: U4555.K4 175.11,79.94 v2(175.11,79.98)
  BOTTOM w0.102: R4730.1 R4731.1 159.09,77.84 159.92,77.84 v2(160.41,77.35)
SLP_A: length 21.3
  TOP w0.102: R4718.1 159.46,93.58 160.18,93.58 160.88,94.29 v3(160.88,94.69)
  L6 w0.102: v2(175.95,90.25) 175.74,90.03 174.3,90.03 174.07,90.25 174.07,90.93 172.99,92.02 172.41,92.59 170.47,92.59 169.73,93.33 166.33,93.33 164.8,94.86 161.05,94.86 v3(160.88,94.69)
  BOTTOM w0.076: U4555.AL5 176.37,90.66 v2(175.95,90.25)
SLP_LAN#: length 183.8
  TOP w0.076: v2(177.17,89.27) 177.17,89.29 177.6,89.72 177.6,90.46 177.25,90.81 177.25,92.72 177.25,92.72 177.25,93.05 177.25,93.05 177.25,93.69 176.62,94.32 175.7,94.32 175.29,94.73
  TOP w0.102: 175.29,94.73 175.29,95.85 174.05,97.09 174.05,98.56 174.66,99.17 174.66,104.76 v2(175.05,105.15) ; v2(274.35,106.28) 273.77,105.7 273.77,102.22 275.5,100.49 275.5,98.16 276.72,96.93 U300.34 ; v3(302.04,119.34) 302.04,118.45 301.43,117.84 300.01,117.84 299.46,118.38 Q7056.5
  L5 w0.102: v3(302.04,119.34) 302.04,117.42 302.32,117.14 302.32,112.82 301.81,112.31 300.32,112.31 299.85,111.84 299.85,109.06 298.76,107.97 298.76,106.44 297.24,104.91 296.09,104.91 293.9,102.72 293.9,102.34 v2(293.02,101.46)
  BOTTOM w0.102: v2(175.05,105.15) 175.05,105.81 v1(175.41,106.17) 177.3,108.07 182,108.07 182.04,108.07 182.04,108.07 183.15,108.07 183.15,108.07 237.77,108.07 238.35,107.49 242.85,107.49 243.37,108.01 245.91,108.01 246.57,107.35 248.71,107.35 249.04,107.68 256.07,107.68 256.48,108.1 258.87,108.1 259.09,108.32 260.05,108.32 260.8,107.57 264.94,107.57 266.79,105.72 269.73,105.72 270.92,106.92 273.72,106.92 v2(274.35,106.28) 275.47,107.4 284.54,107.4 289.85,102.09 292.39,102.09 v2(293.02,101.46) ; U4555.AJ7 177.47,89.75 177.17,89.45 v2(177.17,89.27)
SLP_S3#_3R: length 649
  TOP w0.102: v2(130.72,73.42) 131.17,73.42 131.57,73.83 131.57,74.33 131.32,74.58 CN4941.2 ; R7414.1 244.11,102.05 244.53,102.47 v2(244.53,102.81) ; v2(318.55,42.1) 319,41.65 U3300.3 ; v1(300.13,75.55) 301.02,75.55 304.58,79.11 v2(304.58,79.28) ; v2(143.42,97.4) 142.78,96.77 142.78,89.06 141.89,88.17 141.89,87.36 141.68,87.15 141.68,85.92 142.23,85.37 v2(142.54,85.37) ; R3600.1 310.88,118.95 Q7002.1 309.19,120.64 v2(309.19,120.75) ; v2(173.83,106.07) 173.51,105.75 173.51,105.01 173.82,104.71 173.82,100.98 173.2,100.36 173.2,96.71 174.4,95.5 174.4,94.26 v2(175.19,93.47)
  TOP w0.254: v2(103.46,141.46) 103.46,141.67 101.89,143.24 R7020.1
  L3 w0.102: v2(301.53,120.64) 302.29,120.64 302.79,120.13 308.58,120.13 v2(309.19,120.75) ; v2(307.25,110.2) 307.25,109.05 305.21,107.02 305.21,100.24 304.88,99.91 304.88,89.82 304.32,89.27 304.32,79.54 v2(304.58,79.28) ; v2(130.72,73.42) 132.26,74.97 132.26,76.41 130.26,78.42 128.8,78.42 128.39,78.83 124.94,78.83 124.33,79.44 113.87,79.44 110.75,82.55 106.05,82.55 105.34,81.84 105.34,80.42 104.81,79.89 72.66,79.89 71.49,81.06 70.57,81.06 69.08,82.55 54.29,82.55 50.33,78.6 42.54,78.6 v2(42.43,78.49) ; v2(317.66,38.85) 317.66,41.18 318.55,42.07 v2(318.55,42.1) ; v2(244.53,102.81) 244.1,103.25 244.1,109.28 v2(244.32,109.5) ; v3(181.26,149.72) 181.26,149.97 181.77,150.48 182.79,150.48 184.23,149.03 185.78,149.03 188.4,146.42 195.49,146.42 196.61,145.3 200.39,145.3 203.49,142.2 222.05,142.2 224.38,139.88 224.38,135.05 229.21,130.22 v2(229.21,109.65)
  L5 w0.102: v2(103.46,141.46) 103.41,141.51 103.41,144.58 109.18,150.35 v2(111.41,150.35) ; v2(309.19,120.75) 308.46,120.02 308.46,114.9 309.84,113.52 310.37,113.52 310.8,113.1 310.8,112.17 309.23,110.6 307.65,110.6 v2(307.25,110.2) ; v2(311.49,54.6) 313.8,54.6 316.29,52.11 316.29,40.22 v2(317.66,38.85)
  L6 w0.102: v2(143.42,97.4) 143.42,97.39 144.05,96.76 146.64,96.76 148.51,98.63 161.35,98.63 161.8,98.19 163.18,98.19 170.47,98.19 v2(175.19,93.47) ; v2(42.43,78.49) 42.43,78.46 42.05,78.08 41.36,78.08 41.28,78.01 40.97,78.01 40.42,77.46 v2(40.42,72.25) ; v2(268.13,107.05) 269.31,105.86 269.31,102.32 272.39,99.25 276.66,99.25 277.98,97.93 279.53,97.93 281.43,99.83 281.43,104.85 290.37,113.78 290.37,114.41 296.59,120.64 v2(301.53,120.64) ; v2(111.41,150.35) 111.78,150.35 113.49,152.07 137.32,152.07 139.27,150.12 152.66,150.12 153.91,148.88 176.36,148.88 177.6,150.12 180.85,150.12 v3(181.26,149.72)
  BOTTOM w0.076: v2(175.19,93.47) 175.19,93.58 U4555.AT4
  BOTTOM w0.102: v2(42.43,78.49) 42.43,78.66 42.73,78.96 U2511.6 ; v2(304.58,79.28) 306.79,77.07 309.79,77.07 312.45,74.41 312.45,69.96 312.83,69.58 312.83,65.39 311.82,64.37 311.82,54.93 v2(311.49,54.6) ; v2(173.83,106.07) 174.15,106.38 174.15,107.68 175.88,109.41 213.93,109.41 214.16,109.65 v2(229.21,109.65) 229.24,109.68 240.48,109.68 240.61,109.55 240.65,109.5 v2(244.32,109.5) 247.41,109.5 247.56,109.65 255.22,109.65 255.71,110.14 258.55,110.14 258.87,109.83 262.06,109.83 262.96,108.92 264.98,108.92 266.99,106.92 268,106.92 v2(268.13,107.05) 268.51,107.43 R398.1 ; v2(130.72,73.42) 132.4,75.11 132.4,76.66 132.9,77.16 132.9,77.89 135.31,80.3 138.9,80.3 139.2,80.6 139.9,80.6 141.06,81.76 141.06,82.06 141.06,82.06 141.06,82.39 142.38,83.71 142.38,83.75 142.38,85.21 v2(142.54,85.37) ; v2(40.42,72.25) 39.28,71.11 38.13,71.11 37.54,70.51 U3051.4
