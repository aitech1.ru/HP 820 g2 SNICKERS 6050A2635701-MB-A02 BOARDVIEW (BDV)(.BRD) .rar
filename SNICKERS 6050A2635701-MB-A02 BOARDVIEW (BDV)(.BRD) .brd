# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
RSC_100X050X035_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_100X050X040_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_100X050X040_2_15_SHORT
  rect 0.457x0.381 smd: (0,0)
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_100X050X040_2_SHORT
  rect 0.508x0.127 smd: (0,0)
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_100X050X055_2
  custom 0.112x0.112 smd: 1(-0.427,0) 2(0.424,0)
RSC_160X080X055_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
RSC_160X080X080_2
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
RSC_160X080X080_2_25_SHORT
  rect 0.584x0.635 smd: (0,0)
  rect 0.813x0.813 smd: 1(-0.6,0) 2(0.6,0)
RSC_200X125X115_2
  rect 0.813x1.295 smd: 1(-0.9,0) 2(0.9,0)
RSC_320X160X080_4
  custom 0.349x0.349 smd: 1(-1.989,0.508) 2(1.989,0.508)
  rect 1.041x0.254 smd: 3(-1.232,0) 4(1.232,0)
RSC_320X160X160_4
  custom 0.349x0.349 smd: 1(-1.989,0.508) 2(1.989,0.508)
  rect 1.041x0.254 smd: 3(-1.232,0) 4(1.232,0)
RSC_368X216X050_10_064
  rect 0.559x1.143 smd: 1(-1.356,-0.826) 5(1.356,-0.826) 6(1.356,0.826) 10(-1.356,0.826)
  rect 0.406x1.143 smd: 2(-0.64,-0.826) 3(0,-0.826) 4(0.64,-0.826) 7(0.64,0.826) 8(0,0.826) 9(-0.64,0.826)
SCREW230_500_1P
  custom 1.219x1.219 hole 2.311: 1(0,0)
SCREW230_600_1P
  custom 1.243x1.243 hole 2.311: 1(0,0)
SCREW230_600_NP_1P
  round 2.311 hole 2.311 unplated: (0,0)
  custom 1.499x1.499 hole 0.305: 1(0,2.499)
SCREW280_500_NP_1P
  round 2.794 hole 2.794 unplated: (0,0)
  custom 1.251x1.251 hole 0.305: 1(0,2)
SCREW300_800_1P
  custom 1.973x1.973 hole 2.997: 1(0,0)
SCREW300_800_NP_1P
  round 2.997 hole 2.997 unplated: (0,0)
  custom 1.999x1.999 hole 0.305: 1(0,3)
SCREW330_600_1P
  round 5.994 hole 3.302: 1(0,0)
SCREW360_800_1P
  round 8.001 hole 3.607: 1(0,0)
SCREW360_800_NP_1P
  round 3.607 hole 3.607 unplated: (0,0)
  custom 2x2 hole 0.305: 1(0,3)
SD_FULLP_12_SMD_RV_455
  round 1.092 hole 1.092 unplated: (-12.71,10.071)
  rect 0.991x1.6 smd: 1(-6.876,16.149) 2(-4.374,16.149) 3(-1.875,16.149) 4(0.627,16.149) 5(3.127,16.149) 6(5.626,16.149) 7(8.125,16.149) 9(-9.375,16.149)
  rect 0.787x1.6 smd: 8(9.776,16.149)
  rect 0.457x1.6 smd: 10(10.79,16.149) 11(11.791,16.149) 12(12.89,16.149)
  oval 1.118x2.108 hole 0.61x1.6: G1(-14.531,-0.003)
  oval 0.914x2.108 hole 0.406x1.6: G2(13.371,-0.003)
SIM_TAIT_9_ST_150-001
  round 1.168 hole 1.168 unplated: (-7.65,-0.003) (7.65,-0.003)
  rect 0.889x1.499 smd: CD(-4.836,8.999) P1(5.326,8.999) P2(2.786,8.999) P3(0.246,8.999) P4(-2.296,8.999) P5(4.054,8.999) P6(1.516,8.999) P7(-1.026,8.999) P8(-3.566,8.999)
  rect 2.007x4.089 smd: G1(10,-13.426) G2(-10,-13.426)
SMART_CONCT_10_ST_S_255
  rect 1.397x2.261 smd: 1(3.81,13.129) 2(1.27,13.129) 3(-1.27,13.129) 4(-3.81,13.129) 5(3.81,-13.132) 6(1.27,-13.132) 7(-1.27,-13.132) 8(-3.81,-13.132) 9(-8.89,5.22) 10(-11.43,5.22)
SMDTEST40
  round 1.016 smd: 1(0,0)
SOP_523X528X216_8_127
  rect 0.483x1.473 smd: 1(-1.905,-3.724) 2(-0.635,-3.724) 3(0.635,-3.724) 4(1.905,-3.724) 5(1.905,3.724) 6(0.635,3.724) 7(-0.635,3.724) 8(-1.905,3.724)
SOP_528X528X216_8_127
  rect 0.66x1.524 smd: 1(-1.905,-3.747) 2(-0.635,-3.747) 3(0.635,-3.747) 4(1.905,-3.747) 5(1.905,3.747) 6(0.635,3.747) 7(-0.635,3.747) 8(-1.905,3.747)
SOP_1560X850X240_24_127
  rect 0.813x1.549 smd: 1(-6.985,-4.475) 2(-5.715,-4.475) 3(-4.445,-4.475) 4(-3.175,-4.475) 5(-1.905,-4.475) 6(-0.635,-4.475) 7(0.635,-4.475) 8(1.905,-4.475) 9(3.175,-4.475) 10(4.445,-4.475) 11(5.715,-4.475) 12(6.985,-4.475) 13(6.985,4.475) 14(5.715,4.475) 15(4.445,4.475) 16(3.175,4.475) 17(1.905,4.475) 18(0.635,4.475) 19(-0.635,4.475) 20(-1.905,4.475) 21(-3.175,4.475) 22(-4.445,4.475) 23(-5.715,4.475) 24(-6.985,4.475)
SSOP_200X125X100_5_065
  rect 0.406x1.016 smd: 1(-0.65,-1.049) 2(0,-1.049) 3(0.65,-1.049) 4(0.65,1.049) 5(-0.65,1.049)
SSOP_290X160X140_5_095
  rect 0.66x1.016 smd: 1(-0.95,-1.27) 2(0,-1.27) 3(0.95,-1.27)
  rect 0.762x1.016 smd: 4(0.95,1.27) 5(-0.95,1.27)
SSOP_1020X530X200_28_065
  rect 0.457x1.651 smd: 1(-4.224,-3.619) 2(-3.574,-3.619) 3(-2.926,-3.619) 4(-2.276,-3.619) 5(-1.626,-3.619) 6(-0.975,-3.619) 7(-0.325,-3.619) 8(0.325,-3.619) 9(0.975,-3.619) 10(1.626,-3.619) 11(2.276,-3.619) 12(2.926,-3.619) 13(3.574,-3.619) 14(4.224,-3.619) 15(4.224,3.619) 16(3.574,3.619) 17(2.926,3.619) 18(2.276,3.619) 19(1.626,3.619) 20(0.975,3.619) 21(0.325,3.619) 22(-0.325,3.619) 23(-0.975,3.619) 24(-1.626,3.619) 25(-2.276,3.619) 26(-2.926,3.619) 27(-3.574,3.619) 28(-4.224,3.619)
ST133ID-6011B0115101-001
  rect 0.991x1.499 smd: 1(1.501,0) 2(-1.501,0)
  rect 0.889x0.889 smd: NC(0,0.65)
STD_R_F45016_D10008_M20012_SN
  round 1.448 hole 1.143: 1(0,0)
STD_R_FF40016_D30010_M20026_SN
  round 5.512 hole 3.15: 1(0,0)
STRIKE-6014B0099601-002
  rect 1.016x2.362 smd: 1(-1.146,0) 2(1.146,0)
SWBACK-6012B0275004-003
  rect 0.356x1.372 smd: 1(1.75,2.649) 2(1.25,2.649) 3(0.752,2.649) 4(0.249,2.649) 5(-0.249,2.649) 6(-0.752,2.649) 7(-1.25,2.649) 8(-1.75,2.649)
  rect 2.21x1.397 smd: G1(3.601,-0.003) G2(-3.601,-0.003)
SWBACK-6012B0334801-002
  round 1.016 hole 0.711: 1(-4.582,0.102) 2(-2.291,0.102) 3(-0.003,0.102) 4(2.289,0.102) 5(4.58,0.102) 6(-5.728,0.102) 7(-3.437,0.102) 8(-1.146,0.102) 9(1.146,0.102) 10(3.434,0.102) 11(-4.582,1.501) 12(-2.291,1.501) 13(-0.003,1.501) 14(2.289,1.501) 15(4.58,1.501)
  oval 1.473x3.302 hole 0.711x2.54: G1(-10.051,0) G2(10.051,0)
SWBACK-6012B0452401-001
  rect 0.406x0.991 smd: 1(-2.7,1.551) 2(-2.101,1.551) 3(-1.501,1.551) 4(-0.902,1.551) 5(-0.3,1.551) 6(0.3,1.551) 7(0.902,1.551) 8(1.501,1.551) 9(2.101,1.551) 10(2.7,1.551)
  rect 0.711x1.041 smd: G1(-3.65,-0.025) G2(3.65,-0.025)
SWBACK-6012B0519601-001
  oval 0.762x0.813 hole 0.61: 1(6.2,0.65) 2(6.302,-0.599) 3(5.199,0.65) 4(4.699,-0.599) 5(3.602,0.902) 6(3.701,-0.599) 7(2.601,0.65) 8(2.7,-0.599) 9(1.6,0.65) 10(1.1,-0.599) 11(0,0.902) 12(0.102,-0.599) 13(-1.001,0.902) 14(-1.501,-0.599) 15(-2.002,0.65) 16(-3.101,-0.599) 17(-3,0.65) 18(-4.1,-0.599) 19(-4,0.65) 20(-5.1,-0.599)
  oval 1.473x2.87 hole 0.711x2.108: G1(-8.202,0) G3(8.202,0)
  oval 1.473x2.464 hole 0.711x1.702: G2(-8.202,-5.679) G4(8.202,-5.679)
SWBACK-6012B0520601-005
  oval 0.889x2.591 hole 0.508x2.21: G1(21.702,-0.003) G2(-21.702,-0.003)
  round 1.067 hole 0.686: P1(1.905,0.899) P2(0.635,0.899) P3(-0.635,0.899) P4(-1.905,0.899) P5(-3.175,0.899) P6(-4.445,0.899) P7(-5.715,0.899) P8(-6.985,0.899) P9(-8.255,0.899) P10(-9.525,0.899) P11(-10.795,0.899) P12(-12.065,0.899) P13(-13.335,0.899) P14(-14.605,0.899) P15(-15.875,0.899) S1(15.875,0.899) S2(14.605,0.899) S3(13.335,0.899) S4(12.065,0.899) S5(10.795,0.899) S6(9.525,0.899) S7(8.255,0.899)
SWBACK-6012B0522301-001
  round 0.838 hole 0.838 unplated: (-10.5,0) (10.5,0)
  rect 0.356x1.219 smd: 1(9.751,2.126) 2(9.251,2.126) 3(8.75,2.126) 4(8.25,2.126) 5(7.75,2.126) 6(7.249,2.126) 7(6.749,2.126) 8(6.248,2.126) 9(5.751,2.126) 10(5.25,2.126) 11(4.75,2.126) 12(4.249,2.126) 13(3.752,2.126) 14(3.251,2.126) 15(2.751,2.126) 16(2.25,2.126) 17(1.75,2.126) 18(1.25,2.126) 19(0.749,2.126) 20(0.249,2.126) 21(-0.249,2.126) 22(-0.752,2.126) 23(-1.25,2.126) 24(-1.75,2.126) 25(-2.25,2.126) 26(-2.751,2.126) 27(-3.251,2.126) 28(-3.752,2.126) 29(-4.252,2.126) 30(-4.75,2.126) 31(-5.25,2.126) 32(-5.751,2.126) 33(-6.248,2.126) 34(-6.749,2.126) 35(-7.252,2.126) 36(-7.752,2.126) 37(-8.25,2.126) 38(-8.75,2.126) 39(-9.251,2.126) 40(-9.751,2.126)
  rect 1.499x2.997 smd: G1(12.25,0) G2(-12.25,0)
  rect 2.794x1.499 smd: G3(5.7,-2.05) G4(-5.7,-2.05)
SWBACK-6026B0150101-002
  rect 0.787x1.702 smd: 1(2.576,3.85) 2(1.306,3.85) 3(0.036,3.85) 4(-1.234,3.85) 5(-1.234,-3.85) 6(0.036,-3.85) 7(1.306,-3.85) 8(2.576,-3.85)
SWCH-TACT_MISKI_5_SMD_V_170
  rect 1.143x1.041 smd: 1(-1.676,0.726) 2(1.676,0.726) 3(-1.676,-0.726) 4(1.676,-0.726)
  rect 1.092x0.762 smd: G1(0,1.527)
TDFN_300X300X080_10_050_T5
  rect 0.356x0.787 smd: 1(-1,-1.5) 2(-0.5,-1.5) 3(0,-1.5) 4(0.5,-1.5) 5(1,-1.5) 6(1,1.5) 7(0.5,1.5) 8(0,1.5) 9(-0.5,1.5) 10(-1,1.5)
  rect 2.591x1.6 smd: 11(0,0)
TOOTSIE-6011B0129301-005
  rect 0.77x0.772 smd: 1(-1.1,0) 2(1.1,0)
TP24
  round 0.61 smd: 1(0,0)
TQFP_1400X1400X120_128_040
  rect 1.473x0.297 smd: 1(-7.798,6.276) 2(-7.798,5.824) 3(-7.798,5.425) 4(-7.798,5.024) 5(-7.798,4.625) 6(-7.798,4.224) 7(-7.798,3.825) 8(-7.798,3.424) 9(-7.798,3.025) 10(-7.798,2.624) 11(-7.798,2.225) 12(-7.798,1.824) 13(-7.798,1.425) 14(-7.798,1.026) 15(-7.798,0.625) 16(-7.798,0.226) 17(-7.798,-0.175) 18(-7.798,-0.574) 19(-7.798,-0.975) 20(-7.798,-1.374) 21(-7.798,-1.775) 22(-7.798,-2.174) 23(-7.798,-2.573) 24(-7.798,-2.974) 25(-7.798,-3.376) 26(-7.798,-3.774) 27(-7.798,-4.176) 28(-7.798,-4.575) 29(-7.798,-4.976) 30(-7.798,-5.375) 31(-7.798,-5.776) 32(-7.798,-6.226) 65(7.798,-6.226) 66(7.798,-5.776) 67(7.798,-5.375) 68(7.798,-4.976) 69(7.798,-4.575) 70(7.798,-4.176) 71(7.798,-3.774) 72(7.798,-3.376) 73(7.798,-2.974) 74(7.798,-2.573) 75(7.798,-2.174) 76(7.798,-1.775) 77(7.798,-1.374) 78(7.798,-0.975) 79(7.798,-0.574) 80(7.798,-0.175) 81(7.798,0.226) 82(7.798,0.625) 83(7.798,1.026) 84(7.798,1.425) 85(7.798,1.824) 86(7.798,2.225) 87(7.798,2.624) 88(7.798,3.025) 89(7.798,3.424) 90(7.798,3.825) 91(7.798,4.224) 92(7.798,4.625) 93(7.798,5.024) 94(7.798,5.425) 95(7.798,5.824) 96(7.798,6.276)
  rect 0.297x1.473 smd: 33(-6.251,-7.772) 34(-5.799,-7.772) 35(-5.4,-7.772) 36(-4.999,-7.772) 37(-4.6,-7.772) 38(-4.199,-7.772) 39(-3.8,-7.772) 40(-3.399,-7.772) 41(-3,-7.772) 42(-2.598,-7.772) 43(-2.2,-7.772) 44(-1.798,-7.772) 45(-1.4,-7.772) 46(-0.998,-7.772) 47(-0.599,-7.772) 48(-0.198,-7.772) 49(0.201,-7.772) 50(0.599,-7.772) 51(0.998,-7.772) 52(1.4,-7.772) 53(1.801,-7.772) 54(2.2,-7.772) 55(2.598,-7.772) 56(3,-7.772) 57(3.401,-7.772) 58(3.8,-7.772) 59(4.201,-7.772) 60(4.6,-7.772) 61(5.001,-7.772) 62(5.4,-7.772) 63(5.801,-7.772) 64(6.251,-7.772) 97(6.251,7.823) 98(5.801,7.823) 99(5.4,7.823) 100(5.001,7.823) 101(4.6,7.823) 102(4.201,7.823) 103(3.8,7.823) 104(3.401,7.823) 105(3,7.823) 106(2.598,7.823) 107(2.2,7.823) 108(1.801,7.823) 109(1.4,7.823) 110(0.998,7.823) 111(0.599,7.823) 112(0.201,7.823) 113(-0.198,7.823) 114(-0.599,7.823) 115(-0.998,7.823) 116(-1.4,7.823) 117(-1.798,7.823) 118(-2.2,7.823) 119(-2.598,7.823) 120(-3,7.823) 121(-3.399,7.823) 122(-3.8,7.823) 123(-4.199,7.823) 124(-4.6,7.823) 125(-4.999,7.823) 126(-5.4,7.823) 127(-5.799,7.823) 128(-6.251,7.823)
TSOP_290X160X125_6_095
  rect 0.635x0.787 smd: 1(-0.95,-1.201) 2(0,-1.201) 3(0.95,-1.201) 4(0.95,1.201) 5(0,1.201) 6(-0.95,1.201)
TSOT23_290X130X110_3_095
  rect 0.762x1.016 smd: 1(-0.95,-1.085) 2(0.95,-1.085) 3(0,1.085)
TSOT23_290X130X110_3_096
  rect 0.508x1.295 smd: B(-0.96,-1.049) C(0,1.049) E(0.96,-1.049)
TSOT23_290X130X110_3_096_P1
  rect 0.508x1.295 smd: 1(-0.96,-1.049) 2(0.96,-1.049) 3(0,1.049)
TSOT23_290X160X130_5_095
  rect 0.66x1.016 smd: 1(-0.95,-1.3) 2(0,-1.3) 3(0.95,-1.3) 4(0.95,1.29) 5(-0.95,1.29)
TSOT23_292X130X120_3_095
  rect 0.711x0.787 smd: 1(-0.95,-0.925) 2(0,0.925) 3(0.95,-0.925)
TSOT23_292X160X125_5_095
  rect 0.66x1.016 smd: 1(-0.95,-1.295) 2(0,-1.295) 3(0.95,-1.295) 4(0.95,1.295) 5(-0.95,1.295)
TSOT323_200X125X110_3_065
  rect 0.508x1.143 smd: 1(-0.65,-1.113) 2(0.65,-1.113) 3(0,1.113)
TSOT_290X160X110_6_095
  rect 0.711x0.991 smd: 1(-0.95,-1.3) 2(0,-1.3) 3(0.95,-1.3) 4(0.95,1.3) 5(0,1.3) 6(-0.95,1.3)
TSSC88_200X125X110_6_065
  rect 0.406x0.508 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(0,0.95) 6(-0.65,0.95)
TSSC88_200X125X110_6_065-2
  rect 0.406x0.508 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(0,0.95) 6(-0.65,0.95)
TSSOP_970X440X110_28_065_P2
  rect 0.508x1.397 smd: 1(-4.225,-3.05) 2(-3.575,-3.05) 3(-2.925,-3.05) 4(-2.275,-3.05) 5(-1.625,-3.05) 6(-0.975,-3.05) 7(-0.325,-3.05) 8(0.325,-3.05) 9(0.975,-3.05) 10(1.625,-3.05) 11(2.275,-3.05) 12(2.925,-3.05) 13(3.575,-3.05) 14(4.225,-3.05) 15(4.225,3.05) 16(3.575,3.05) 17(2.925,3.05) 18(2.275,3.05) 19(1.625,3.05) 20(0.975,3.05) 21(0.325,3.05) 22(-0.325,3.05) 23(-0.975,3.05) 24(-1.625,3.05) 25(-2.275,3.05) 26(-2.925,3.05) 27(-3.575,3.05) 28(-4.225,3.05)
TSSOT23_290X130X120_3_095
  rect 0.787x0.889 smd: D(0,1.001) G(-0.95,-1.001) S(0.95,-1.001)
TSSOT23_290X160X135_5_095
  rect 0.66x1.016 smd: 1(-0.95,-1.295) 2(0,-1.295) 3(0.95,-1.295) 4(0.95,1.295) 5(-0.95,1.295)
TSSOT23_292X130X111_3_095
  rect 0.787x0.889 smd: 1(-0.95,-1.001) 2(0.95,-1.001) 3(0,1.001)
TSSOT23_292X130X111_3_096
  rect 0.787x0.889 smd: 1(-0.955,-1.001) 2(0.955,-1.001) 3(0,1.001)
TSSOT323_200X125X100_3_065
  rect 0.711x0.889 smd: 1(-0.65,-0.95) 2(0.65,-0.95) 3(0,0.95)
unnamed#2
  round 4.013 hole 4.013 unplated: (0,0)
unnamed#3
  oval 2.21x2.007 hole 2.21x2.007 unplated: (0.1,0)
unnamed#4
  rect 2.007x2.007 smd: (0,0) (0,0)
unnamed#5
  round 0.635 hole 0.635 unplated: (0,0) (1,-0.3) (2,-0.3) (3,0)
unnamed#6
  round 0.635 hole 0.635 unplated: (0,0) (1,-0.3) (2,-0.3) (3,-0.3) (4,0)
unnamed#7
  oval 1.6x1.295 hole 1.6x1.295 unplated: (0.15,0)
unnamed#8
  oval 3.988x2.007 hole 3.988x2.007 unplated: (1,0)
USB3_SIGAT_9_DIP_SS_S_240_526
  round 1.295 hole 0.711: 1(-3.5,-0.599) 2(-1.001,-0.599) 3(1.001,-0.599) 4(3.5,-0.599) 5(4,0.902) 6(2.002,0.902) 7(0,0.902) 8(-2.002,0.902) 9(-4,0.902)
  oval 1.397x2.388 hole 0.787x1.854: G1(-6.401,0) G3(6.401,0)
  oval 1.397x3.2 hole 0.787x2.591: G2(-7.851,-6.599) G4(7.851,-6.599)
WDFN_300X300X080_10_050_T1
  rect 0.356x0.787 smd: 1(-1.016,-1.499) 2(-0.508,-1.499) 3(0,-1.499) 4(0.508,-1.499) 5(1.016,-1.499) 6(1.016,1.499) 7(0.508,1.499) 8(0,1.499) 9(-0.508,1.499) 10(-1.016,1.499)
  rect 2.388x1.6 smd: 11(0,0)
WTB_ACES_4_125_SMD_R_M_340_1
  rect 0.787x1.6 smd: 1(-1.877,2.901) 2(-0.627,2.901) 3(0.625,2.901) 4(1.875,2.901)
  rect 2.108x2.997 smd: G1(4.425,0.003) G2(-4.427,0.003)
WTB_ENTRY_2_100_SMD_R_M_295
  rect 0.61x1.549 smd: 1(-0.5,3.775) 2(0.5,3.775)
  rect 1.194x2.007 smd: G1(-1.8,0) G2(1.8,0)
XPS_700X150X145_4
  rect 1.194x0.61 smd: 1(-3.15,-0.45) 2(3.152,-0.45) 3(3.152,0.452) 4(-3.15,0.452)
XTAL_320X250X090_4-2
  rect 1.397x1.194 smd: 1(-1.1,-0.9) 2(1.1,-0.9) 3(1.1,0.9) 4(-1.1,0.9)
XTAL_320X250X090_4_220-2
  rect 1.397x1.194 smd: 1(-1.1,-0.851) 2(1.1,-0.851) 3(1.1,0.851) 4(-1.1,0.851)

## Nets
1V2A_PG: D2551.1 R2568.2(B) U6450.4
1V05A_PG: U6300.1(PGOOD)
1V5S_PG: R7428.1(A) U6350.4
3V3DS_PG: R7000.2(B) U6100.4
5V_PG: R7010.1(A) U6150.4
AGND_AUDIO: C501.2(B) C504.2(B) C506.2(B) C507.2(B) C511.2(B) C512.2(B) C513.2(B) C516.2(B) C517.2(B) C529.2(B) C550.2(B) C551.2(B) C553.2(B) C554.2(B) C555.2(B) C562.2(B) C563.2(B) C565.2(B) C566.2(B) C567.2(B) C574.2(B) C575.2(B) C601.2(B) C602.2(B) C603.2(B) C605.2(B) C613.2(B) C614.2(B) C615.2(B) C617.2(B) C7520.1(A) C7521.1(A) C7578.1(A) C7579.1(A) CN3601.16 CN3601.19 CN3601.22 JACK600.5 JACK600.6 Q528.1(S1) Q528.4(S2) Q600.2(S) R502.2(B) R506.2(B) R507.2(B) R520.2(B) R521.2(B) R529.1(A) R530.2(B) R552.1(A) R557.1(A) R560.2(B) R562.2(B) R563.2(B) R565.2(B) R571.1(A) R572.1(A) R605.2(B) R619.2(B) U501.26(AVSS1) U501.33(AVSS2) U550.3 U550.9 U550.10 U550.13 U550.19 U550.21(TML-PAD) U551.3 U551.9 U551.10 U551.13 U551.19 U551.21(TML-PAD) U610.4(GND)
AGND_KBC: C301.2(B) C304.1(A) C306.2(B) C307.2(B) C313.1(A) PAD310.2 U300.45(AVSS)
DGND: C100.2(B) C131.2(B) C302.2(B) C303.2(B) C305.2(B) C308.2(B) C310.2(B) C311.2(B) C312.2(B) C314.2(B) C315.2(B) C316.2(B) C320.2(B) C321.2(B) C335.2(B) C366.2(B) C400.1(A) C401.2(B) C402.2(B) C403.2(B) C404.1(A) C409.2(B) C474.2(B) C475.2(B) C476.2(B) C477.2(B) C478.2(B) C479.2(B) C486.2(B) C502.2(B) C503.2(B) C505.2(B) C508.2(B) C509.2(B) C510.2(B) C515.2(B) C519.2(B) C523.2(B) C527.2(B) C532.2(B) C800.2(B) C801.2(B) C802.2(B) C803.2(B) C804.2(B) C805.2(B) C806.2(B) C807.2(B) C808.2(B) C810.2(B) C1000.2(B) C1001.2(B) C1301.2(B) C1303.2(B) C1304.2(B) C1305.2(B) C1307.2(B) C1405.2(B) C1413.2(B) C1414.2(B) C1415.2(B) C1451.2(B) C1452.2(B) C1453.2(B) C1700.2(B) C1701.2(B) C1956.2(B) C2200.2(B) C2201.2(B) C2250.2(B) C2251.2(B) C2255.2(B) C2256.2(B) C2401.2(B) C2402.2(B) C2408.2(B) C2411.2(B) C2412.2(B) C2413.2(B) C2414.2(B) C2415.2(B) C2503.2(B) C2512.2(B) C2513.2(B) C2514.2(B) C2550.1(A) C2551.2(B) C2552.2(B) C2553.2(B) C2554.2(B) C2555.2(B) C2556.2(B) C2557.2(B) C2558.2(B) C2559.2(B) C2560.2(B) C2561.2(B) C2562.2(B) C2563.2(B) C2564.2(B) C2566.1(A) C2575.2(B) C2578.1(A) C2582.2(B) C2583.2(B) C2584.2(B) C2590.2(B) C2950.2(B) C2952.2(B) C2971.2(B) C2990.2(B) C2994.2(B) C2995.2(B) C3003.2(B) C3006.2(B) C3015.2(B) C3051.2(B) C3052.2(B) C3053.2(B) C3054.2(B) C3055.2(B) C3056.2(B) C3058.2(B) C3059.2(B) C3060.2(B) C3061.2(B) C3062.2(B) C3065.2(B) C3066.2(B) C3067.2(B) C3068.2(B) C3069.1(A) C3070.1(A) C3071.2(B) C3072.2(B) C3073.2(B) C3074.2(B) C3077.1(A) C3085.2(B) C3087.2(B) C3088.2(B) C3089.2(B) C3090.2(B) C3091.2(B) C3092.2(B) C3093.2(B) C3094.2(B) C3308.2(B) C3310.2(B) C3311.2(B) C3357.2(B) C3501.2(B) C3502.2(B) C3503.2(B) C3504.2(B) C3506.2(B) C3600.2(B) C3601.2(B) C3602.2(B) C4100.2(B) C4101.2(B) C4102.2(B) C4103.2(B) C4104.2(B) C4105.2(B) C4106.2(B) C4107.2(B) C4108.2(B) C4109.2(B) C4110.2(B) C4111.2(B) C4112.2(B) C4113.2(B) C4114.2(B) C4115.2(B) C4116.2(B) C4117.2(B) C4118.2(B) C4119.2(B) C4120.2(B) C4125.2(B) C4126.2(B) C4127.2(B) C4128.2(B) C4129.2(B) C4130.2(B) C4131.2(B) C4132.2(B) C4133.2(B) C4134.2(B) C4135.2(B) C4136.2(B) C4137.2(B) C4138.2(B) C4139.2(B) C4140.2(B) C4141.2(B) C4142.2(B) C4143.2(B) C4144.2(B) C4145.2(B) C4146.2(B) C4147.2(B) C4202.2(B) C4205.2(B) C4207.2(B) C4209.2(B) C4211.2(B) C4214.2(B) C4411.2(B) C4514.2(B) C4515.2(B) C4516.2(B) C4521.2(B) C4522.2(B) C4525.2(B) C4526.2(B) C4527.2(B) C4528.2(B) C4529.2(B) C4530.2(B) C4531.2(B) C4532.2(B) C4533.2(B) C4534.2(B) C4535.2(B) C4536.2(B) C4537.2(B) C4538.2(B) C4539.2(B) C4540.2(B) C4542.2(B) C4544.2(B) C4545.2(B) C4547.2(B) C4548.2(B) C4549.2(B) C4555.2(B) C4559.2(B) C4560.2(B) C4561.2(B) C4590.2(B) C4700.2(B) C4701.2(B) C4709.2(B) C4710.2(B) C4712.1(A) C4714.2(B) C4716.2(B) C4717.2(B) C4718.2(B) C4719.2(B) C4720.2(B) C4721.2(B) C4723.2(B) C4724.2(B) C4728.2(B) C4729.2(B) C4730.1(A) C4746.1(A) C4751.2(B) C4753.2(B) C4754.2(B) C4755.2(B) C4758.1(A) C4760.2(B) C4761.2(B) C4762.2(B) C4763.2(B) C4764.2(B) C4765.1(A) C4766.2(B) C4767.1(A) C4768.2(B) C4785.2(B) C4786.2(B) C4787.2(B) C4788.1(A) C4789.2(B) C4790.2(B) C4792.2(B) C4826.2(B) C4828.2(B) C4920.2(B) C4935.2(B) C4937.2(B) C4943.2(B) C4990.2(B) C5009.2(B) C5309.2(B) C5310.2(B) C5311.2(B) C5312.2(B) C5313.2(B) C5314.2(B) C5409.2(B) C5410.2(B) C5411.2(B) C5412.2(B) C5413.2(B) C5414.2(B) C5450.2(B) C6000.2(B) C6001.2(B) C6002.2(B) C6010.2(B) C6011.2(B) C6016.2(B) C6017.2(B) C6018.2(B) C6020.2(B) C6021.2(B) C6022.2(B) C6024.2(B) C6025.2(B) C6027.2(B) C6029.1(A) C6030.2(B) C6031.2(B) C6032.2(B) C6049.2(B) C6100.2(B) C6101.2(B) C6109.2(B) C6110.2(B) C6111.2(B) C6120.2(B) C6121.2(B) C6150.2(B) C6151.2(B) C6152.2(B) C6158.2(B) C6159.2(B) C6160.2(B) C6161.2(B) C6169.2(B) C6200.2(B) C6201.2(B) C6202.2(B) C6203.2(B) C6204.2(B) C6210.2(B) C6211.2(B) C6216.1(A) C6217.1(A) C6240.2(B) C6241.2(B) C6242.2(B) C6243.2(B) C6300.2(B) C6301.2(B) C6302.2(B) C6303.2(B) C6304.2(B) C6310.2(B) C6311.2(B) C6316.1(A) C6317.1(A) C6350.2(B) C6360.2(B) C6450.2(B) C6460.2(B) C6610.2(B) C6611.2(B) C6613.2(B) C6614.2(B) C6616.2(B) C6641.2(B) C6642.2(B) C6643.2(B) C6644.2(B) C6645.2(B) C6646.1(A) C6699.2(B) C6900.2(B) C6902.2(B) C6906.2(B) C6998.2(B) C6999.2(B) C7001.2(B) C7035.2(B) C7036.2(B) C7037.2(B) C7050.2(B) C7100.2(B) C7110.2(B) C7152.2(B) C7153.2(B) C7352.2(B) C7355.2(B) C7400.2(B) C7401.2(B) C7402.1(A) C7403.2(B) C7455.1(A) C7456.1(A) C7457.1(A) C7458.1(A) C7459.1(A) C7460.1(A) C7461.1(A) C7462.1(A) C7463.1(A) C7464.1(A) C7465.1(A) C7466.1(A) C7467.1(A) C7468.1(A) C7469.1(A) C7470.1(A) C7471.1(A) C7472.1(A) C7473.1(A) C7474.1(A) C7475.1(A) C7476.1(A) C7478.1(A) C7485.2(B) C7486.2(B) C7487.1(A) C7488.1(A) C7490.1(A) C7491.1(A) C7494.1(A) C7495.1(A) C7500.1(A) C7501.1(A) C7502.2(B) C7503.2(B) C7520.2(B) C7521.2(B) C7578.2(B) C7579.2(B) C7581.2(B) C7582.2(B) C7583.2(B) C7584.2(B) C7585.2(B) C7586.2(B) C7587.2(B) C7588.2(B) C7589.2(B) C7591.2(B) C7592.2(B) C7593.2(B) C7594.2(B) C7595.2(B) C7596.2(B) C7597.2(B) C7598.2(B) C7599.2(B) C7600.2(B) C7601.2(B) C7602.2(B) C7603.2(B) C7604.2(B) C7605.2(B) C7606.2(B) C7607.2(B) C7608.2(B) C7609.2(B) C7610.2(B) C7611.2(B) C7612.2(B) C7613.2(B) C7614.2(B) C7615.2(B) C7616.2(B) C7617.2(B) C7618.2(B) C7619.2(B) C7620.2(B) C7621.2(B) C7622.2(B) C7623.2(B) C7625.2(B) C7627.2(B) C7628.2(B) C7629.2(B) C7630.2(B) C7631.2(B) C7632.2(B) C7633.2(B) C7634.2(B) C7635.2(B) C7636.2(B) C7637.2(B) C7638.2(B) C7639.2(B) C7640.2(B) C7641.2(B) C7642.2(B) C7643.2(B) C7650.2(B) C7654.2(B) C7661.2(B) C9114.2(B) CN200.3 CN200.6 CN200.14 CN200.15 CN200.37 CN200.38 CN200.39 CN200.40 CN200.G1 CN200.G2 CN202.3 CN202.G1 CN202.G2 CN290.6 CN290.G1 CN290.G2 CN300.6 CN300.G1 CN300.G2 CN301.3 CN301.4 CN301.5 CN301.G1 CN301.G2 CN365.4(VSS) CN375.1 CN375.24 CN375.G1(25) CN375.G2(26) CN640.G1 CN640.G2 CN820.3 CN820.6 CN820.12 CN820.G1 CN820.G2 CN1300.1 CN1300.7 CN1300.18 CN1300.33 CN1300.39 CN1300.45 CN1300.51 CN1300.57 CN1300.63 CN1300.69 CN1300.75 CN1300.G1 CN1300.G2 CN1400.3(GND3) CN1400.5(GND5) CN1400.11(GND11) CN1400.27(GND_27) CN1400.33(GND_33) CN1400.39(GND_39) CN1400.45(GND_45) CN1400.51(GND_51) CN1400.57(GND_57) CN1400.71(GND_71) CN1400.73(GND_73) CN1400.G1(GND_G1) CN1400.G2(GND_G2) CN1451.G1 CN1451.G2 CN1451.P5(GND) CN1700.G1 CN1700.G2 CN1700.P4 CN1700.P5 CN1700.P6 CN1700.P10 CN1700.P12 CN1700.S1 CN1700.S4 CN1700.S7 CN1951.1(GND1) CN1951.3(GND2) CN1951.9(GND3) CN1951.15(GND4) CN1951.21(GND5) CN1951.27(GND6) CN1951.33(GND7) CN1951.39(GND8) CN1951.45(GND9) CN1951.51(GND10) CN1951.57(GND11) CN1951.71(GND12) CN1951.73(GND13) CN1951.G1(GND15) CN1951.G2(GND16) CN2200.4 CN2200.G1 CN2200.G2 CN2400.4 CN2400.7 CN2401.4 CN2401.7 CN2500.4 CN2500.7 CN2500.G1 CN2500.G2 CN2500.G3 CN2500.G4 CN3000.5 CN3000.9 CN3000.14 CN3000.17 CN3000.21 CN3000.25 CN3000.28 CN3000.31 CN3000.34 CN3000.37 CN3000.40 CN3000.G1 CN3000.G2 CN3000.G3 CN3000.G4 CN3050.5 CN3050.6 CN3050.7 CN3050.8 CN3050.10 CN3050.G1 CN3300.2 CN3300.5 CN3300.8 CN3300.11 CN3300.16 CN3300.19 CN3300.G1 CN3300.G2 CN3601.4 CN3601.7 CN3601.10 CN3601.25 CN3601.28 CN3601.31 CN3601.50 CN3601.53 CN3601.56 CN3601.59 CN3601.62 CN3601.65 CN3601.68 CN3601.71 CN3601.74 CN3601.77 CN3601.80 CN3601.83 CN3601.86 CN3601.89 CN3601.G1 CN3601.G2 CN3601.G3 CN3601.G4 CN3601.G5 CN4100.2(VSS1) CN4100.3(VSS2) CN4100.8(VSS3) CN4100.9(VSS4) CN4100.11(DM0) CN4100.13(VSS5) CN4100.14(VSS6) CN4100.19(VSS7) CN4100.20(VSS8) CN4100.25(VSS9) CN4100.26(VSS10) CN4100.28(DM1) CN4100.31(VSS11) CN4100.32(VSS12) CN4100.37(VSS13) CN4100.38(VSS14) CN4100.43(VSS15) CN4100.44(VSS16) CN4100.46(DM2) CN4100.48(VSS17) CN4100.49(VSS18) CN4100.54(VSS19) CN4100.55(VSS20) CN4100.60(VSS21) CN4100.61(VSS22) CN4100.63(DM3) CN4100.65(VSS23) CN4100.66(VSS24) CN4100.71(VSS25) CN4100.72(VSS26) CN4100.127(VSS27) CN4100.128(VSS28) CN4100.133(VSS29) CN4100.134(VSS30) CN4100.136(DM4) CN4100.138(VSS31) CN4100.139(VSS32) CN4100.144(VSS33) CN4100.145(VSS34) CN4100.150(VSS35) CN4100.151(VSS36) CN4100.153(DM5) CN4100.155(VSS37) CN4100.156(VSS38) CN4100.161(VSS39) CN4100.162(VSS40) CN4100.167(VSS41) CN4100.168(VSS42) CN4100.170(DM6) CN4100.172(VSS43) CN4100.173(VSS44) CN4100.178(VSS45) CN4100.179(VSS46) CN4100.184(VSS47) CN4100.185(VSS48) CN4100.187(DM7) CN4100.189(VSS49) CN4100.190(VSS50) CN4100.195(VSS51) CN4100.196(VSS52) CN4100.G1 CN4100.G2 CN4125.2(VSS1) CN4125.3(VSS2) CN4125.8(VSS3) CN4125.9(VSS4) CN4125.11(DM0) CN4125.13(VSS5) CN4125.14(VSS6) CN4125.19(VSS7) CN4125.20(VSS8) CN4125.25(VSS9) CN4125.26(VSS10) CN4125.28(DM1) CN4125.31(VSS11) CN4125.32(VSS12) CN4125.37(VSS13) CN4125.38(VSS14) CN4125.43(VSS15) CN4125.44(VSS16) CN4125.46(DM2) CN4125.48(VSS17) CN4125.49(VSS18) CN4125.54(VSS19) CN4125.55(VSS20) CN4125.60(VSS21) CN4125.61(VSS22) CN4125.63(DM3) CN4125.65(VSS23) CN4125.66(VSS24) CN4125.71(VSS25) CN4125.72(VSS26) CN4125.127(VSS27) CN4125.128(VSS28) CN4125.133(VSS29) CN4125.134(VSS30) CN4125.136(DM4) CN4125.138(VSS31) CN4125.139(VSS32) CN4125.144(VSS33) CN4125.145(VSS34) CN4125.150(VSS35) CN4125.151(VSS36) CN4125.153(DM5) CN4125.155(VSS37) CN4125.156(VSS38) CN4125.161(VSS39) CN4125.162(VSS40) CN4125.167(VSS41) CN4125.168(VSS42) CN4125.170(DM6) CN4125.172(VSS43) CN4125.173(VSS44) CN4125.178(VSS45) CN4125.179(VSS46) CN4125.184(VSS47) CN4125.185(VSS48) CN4125.187(DM7) CN4125.189(VSS49) CN4125.190(VSS50) CN4125.195(VSS51) CN4125.196(VSS52) CN4125.G1 CN4125.G2 CN4300.2 CN4300.G1 CN4300.G2 CN4750.2 CN4750.G1 CN4750.G2 CN4920.1(GND0) CN4920.2(GND1) CN4920.7(GND2) CN4920.8(GND3) CN4920.13(GND4) CN4920.14(GND5) CN4920.19(GND6) CN4920.20(GND7) CN4920.25(GND8) CN4920.26(GND9) CN4920.31(GND10) CN4920.32(GND11) CN4920.37(GND12) CN4920.38(GND13) CN4920.49(GND14) CN4920.50(GND15) CN4920.59(GND16) CN4941.8 CN4941.10 CN4941.12 CN4941.14 CN4941.G1 CN6050.7 CN6050.8 CN6050.G1 CN6050.G2 D485.2 D486.2 D1451.2(A2) D2201.3 D4200.2 D4201.2 D4202.2 D4203.2 D4204.2 D4205.2 D6015.3 D6019.2(A2) D6901.2(A2) D7504.1 D7505.1 D7506.1 D7600.1 D7601.1 D7602.1 D7603.1 D7604.1 D7605.1 D7606.1 D7607.1 D7608.1 D7609.1 D7610.1 D7611.1 D7612.1 D7613.1 D7614.1 D7615.1 D7616.1 D7617.1 D7618.1 D7619.1 D7620.1 D7621.1 JACK485.G1 JACK485.G2 JACK6000.4 JACK6000.5 JACK6000.6 JACK6000.7 JACK6000.8 JACK6000.9 L6035.3 L6035.4 PAD310.1 Q110.2(S) Q113.2(S) Q125.1(S1) Q125.4(S2) Q301.2(S) Q320.4(S2) Q486.2(E) Q501.2(S) Q800.2(S) Q1001.2(S) Q1002.2(S) Q1302.1(S1) Q1302.4(S2) Q1401.2(S) Q1402.2(S) Q1950.2(S) Q4101.2(S) Q4102.E Q4300.4(S2) Q4501.2(S) Q4700.2(S) Q4831.2(S) Q4926.1(S1) Q4926.4(S2) Q4942.1(S1) Q4942.4(S2) Q5301.2(S) Q5401.2(S) Q6001.1(S0) Q6001.2(S1) Q6001.3(S2) Q6900.3(C) Q6901.2(E) Q6903.3(C) Q6998.2(S) Q7002.2(S) Q7051.1(S1) Q7051.4(S2) Q7056.1(S1) Q7056.4(S2) Q7101.2(S) Q7150.1(S1) Q7150.4(S2) Q7152.2(S) Q7154.2(S) Q7155.2(S) Q7350.1(S1) Q7350.4(S2) Q7352.2(S) Q7355.2(S) R124.2(B) R304.2(B) R305.2(B) R321.2(B) R329.2(B) R342.2(B) R345.2(B) R356.2(B) R370.2(B) R371.2(B) R383.1(A) R391.2(B) R401.2(B) R404.2(B) R405.2(B) R487.2(B) R499.1(A) R510.2(B) R520.1(A) R521.1(A) R534.2(B) R535.2(B) R536.2(B) R537.2(B) R801.1(A) R810.2(B) R811.2(B) R1000.2(B) R1952.2(B) R2200.2(B) R2511.2(B) R2512.1(A) R2514.1(A) R2553.1(A) R2554.2(B) R2555.2(B) R2557.1(A) R2558.1(A) R2567.2(B) R2572.1(A) R2573.1(A) R2574.2(B) R2576.2(B) R2585.2(B) R2591.2(B) R2951.1(A) R2960.1(A) R3003.2(B) R3008.2(B) R3021.2(B) R3051.2(B) R3052.2(B) R3053.2(B) R3061.1(A) R3068.1(A) R3071.1(A) R3076.1(A) R3092.1(A) R3094.2(B) R3095.2(B) R3302.2(B) R3303.2(B) R3304.2(B) R3502.2(B) R4100.2(B) R4101.2(B) R4109.1(A) R4110.1(A) R4111.1(A) R4115.2(B) R4122.1(A) R4123.2(B) R4125.2(B) R4131.1(A) R4136.1(A) R4411.2(B) R4509.1(A) R4516.2(B) R4518.1(A) R4519.1(A) R4520.2(B) R4522.2(B) R4523.2(B) R4526.2(B) R4527.1(A) R4534.2(B) R4540.1(A) R4541.1(A) R4572.1(A) R4574.1(A) R4576.1(A) R4578.1(A) R4713.2(B) R4724.1(A) R4731.2(B) R4748.2(B) R4756.2(B) R4758.2(B) R4759.2(B) R4771.1(A) R4775.2(B) R4791.2(B) R4800.2(B) R4801.2(B) R4803.2(B) R4804.2(B) R4805.2(B) R4808.2(B) R4824.2(B) R4841.1(A) R4876.1(A) R4919.2(B) R5302.2(B) R5304.2(B) R5306.2(B) R5308.2(B) R5312.1(A) R5314.1(A) R5315.2(B) R5319.2(B) R5320.2(B) R5415.2(B) R5417.2(B) R5420.2(B) R5422.2(B) R5425.1(A) R5426.1(A) R6005.2(B) R6023.2(B) R6030.2(B) R6149.1(A) R6199.1(A) R6201.2(B) R6209.1(A) R6301.2(B) R6309.1(A) R6351.2(B) R6451.2(B) R6612.2(B) R6647.2(B) R6650.2(B) R6653.2(B) R6654.2(B) R6658.1(A) R6660.1(A) R6903.2(B) R6904.2(B) R6916.2(B) R6930.2(B) R6936.1(A) R6990.1(A) R6994.2(B) R6999.2(B) R7115.2(B) R7401.2(B) R7412.1(A) R7418.2(B) R7627.2(B) R7629.2(B) R7631.2(B) S0.1 S1.1 S2.1 S4.1 S13.1 S14.1 S15.1 S16.1 S17.1 S25.1 S26.1 S37.1 S38.1 S39.1 S41.1 S42.1 ST1.1 ST3.1 ST4.1 ST5.1 SW152.G1 SW154.G1 TP294.1 U300.11(VSS<6>) U300.36(VSS<4>) U300.47(VSS<5>) U300.56(VSS<3>) U300.70(VSS_VBAT) U300.82(VSS<2>) U300.104(VSS<0>) U300.117(VSS<1>) U302.2(GND) U365.4 U366.4 U400.49 U501.49 U800.33(GND) U1000.5 U1000.10 U1000.12(GND) U1000.13(RES) U1000.15 U1000.16 U2400.1 U2401.1 U2402.3 U2403.3 U2511.14 U2511.17 U2550.65(GND<0>) U2551.4(GND) U2950.2(GND) U3000.2 U3051.1 U3065.41 U3300.2 U3500.4 U3500.11 U3500.18 U3500.25 U4411.2(GND) U4411.4(HYST) U4555.A11(VSS_A11) U4555.A14(VSS_A14) U4555.A18(VSS_A18) U4555.A24(VSS_A24) U4555.A28(VSS_A28) U4555.A32(VSS_A32) U4555.A36(VSS_A36) U4555.A40(VSS_A40) U4555.A44(VSS_A44) U4555.A48(VSS_A48) U4555.A52(VSS_A52) U4555.A56(VSS_A56) U4555.AA1(VSS_AA1) U4555.AA58(VSS_AA58) U4555.AB7(VSS_AB7) U4555.AB10(VSS_AB10) U4555.AB20(VSS_AB20) U4555.AB22(VSS_AB22) U4555.AC61(VSS_AC61) U4555.AD3(VSS_AD3) U4555.AD21(VSS_AD21) U4555.AD63(VSS_AD63) U4555.AE5(VSS_AE5) U4555.AE10(VSS_AE10) U4555.AE58(VSS_AE58) U4555.AF11(VSS_AF11) U4555.AF12(VSS_AF12) U4555.AF14(VSS_AF14) U4555.AF15(VSS_AF15) U4555.AF17(VSS_AF17) U4555.AF18(VSS_AF18) U4555.AG1(VSS_AG1) U4555.AG11(VSS_AG11) U4555.AG21(VSS_AG21) U4555.AG23(VSS_AG23) U4555.AG60(VSS_AG60) U4555.AG61(VSS_AG61) U4555.AG62(VSS_AG62) U4555.AG63(VSS_AG63) U4555.AH16(VSS_AH16) U4555.AH17(VSS_AH17) U4555.AH19(VSS_AH19) U4555.AH20(VSS_AH20) U4555.AH22(VSS_AH22) U4555.AH24(VSS_AH24) U4555.AH28(VSS_AH28) U4555.AH30(VSS_AH30) U4555.AH32(VSS_AH32) U4555.AH34(VSS_AH34) U4555.AH36(VSS_AH36) U4555.AH38(VSS_AH38) U4555.AH40(VSS_AH40) U4555.AH42(VSS_AH42) U4555.AH44(VSS_AH44) U4555.AH46(VSS_AH46) U4555.AH49(VSS_AH49) U4555.AH51(VSS_AH51) U4555.AH53(VSS_AH53) U4555.AH55(VSS_AH55) U4555.AH57(VSS_AH57) U4555.AJ13(VSS_AJ13) U4555.AJ14(VSS_AJ14) U4555.AJ23(VSS_AJ23) U4555.AJ25(VSS_AJ25) U4555.AJ27(VSS_AJ27) U4555.AJ29(VSS_AJ29) U4555.AJ35(VSS_AJ35) U4555.AJ39(VSS_AJ39) U4555.AJ41(VSS_AJ41) U4555.AJ43(VSS_AJ43) U4555.AJ45(VSS_AJ45) U4555.AJ47(VSS_AJ47) U4555.AJ50(VSS_AJ50) U4555.AJ52(VSS_AJ52) U4555.AJ54(VSS_AJ54) U4555.AJ56(VSS_AJ56) U4555.AJ58(VSS_AJ58) U4555.AJ60(VSS_AJ60) U4555.AJ63(VSS_AJ63) U4555.AK3(VSS_AK3) U4555.AK23(VSS_AK23) U4555.AK52(VSS_AK52) U4555.AL10(VSS_AL10) U4555.AL13(VSS_AL13) U4555.AL17(VSS_AL17) U4555.AL20(VSS_AL20) U4555.AL22(VSS_AL22) U4555.AL23(VSS_AL23) U4555.AL26(VSS_AL26) U4555.AL29(VSS_AL29) U4555.AL31(VSS_AL31) U4555.AL33(VSS_AL33) U4555.AL36(VSS_AL36) U4555.AL39(VSS_AL39) U4555.AL40(VSS_AL40) U4555.AL45(VSS_AL45) U4555.AL46(VSS_AL46) U4555.AL51(VSS_AL51) U4555.AL52(VSS_AL52) U4555.AL54(VSS_AL54) U4555.AL57(VSS_AL57) U4555.AL60(VSS_AL60) U4555.AL61(VSS_AL61) U4555.AM1(VSS_AM1) U4555.AM17(VSS_AM17) U4555.AM23(VSS_AM23) U4555.AM31(VSS_AM31) U4555.AM52(VSS_AM52) U4555.AN7(VSS_AN7) U4555.AN17(VSS_AN17) U4555.AN23(VSS_AN23) U4555.AN31(VSS_AN31) U4555.AN32(VSS_AN32) U4555.AN35(VSS_AN35) U4555.AN36(VSS_AN36) U4555.AN39(VSS_AN39) U4555.AN40(VSS_AN40) U4555.AN42(VSS_AN42) U4555.AN43(VSS_AN43) U4555.AN45(VSS_AN45) U4555.AN46(VSS_AN46) U4555.AN48(VSS_AN48) U4555.AN49(VSS_AN49) U4555.AN51(VSS_AN51) U4555.AN52(VSS_AN52) U4555.AN60(VSS_AN60) U4555.AN63(VSS_AN63) U4555.AP3(VSS_AP3) U4555.AP10(VSS_AP10) U4555.AP17(VSS_AP17) U4555.AP20(VSS_AP20) U4555.AP22(VSS_AP22) U4555.AP23(VSS_AP23) U4555.AP26(VSS_AP26) U4555.AP29(VSS_AP29) U4555.AP31(VSS_AP31) U4555.AP38(VSS_AP38) U4555.AP39(VSS_AP39) U4555.AP48(VSS_AP48) U4555.AP52(VSS_AP52) U4555.AP54(VSS_AP54) U4555.AP57(VSS_AP57) U4555.AR5(VSS_AR5) U4555.AR11(VSS_AR11) U4555.AR15(VSS_AR15) U4555.AR17(VSS_AR17) U4555.AR23(VSS_AR23) U4555.AR31(VSS_AR31) U4555.AR33(VSS_AR33) U4555.AR39(VSS_AR39) U4555.AR43(VSS_AR43) U4555.AR49(VSS_AR49) U4555.AR52(VSS_AR52) U4555.AT13(VSS_AT13) U4555.AT35(VSS_AT35) U4555.AT37(VSS_AT37) U4555.AT40(VSS_AT40) U4555.AT42(VSS_AT42) U4555.AT43(VSS_AT43) U4555.AT46(VSS_AT46) U4555.AT49(VSS_AT49) U4555.AT61(VSS_AT61) U4555.AT62(VSS_AT62) U4555.AT63(VSS_AT63) U4555.AU1(VSS_AU1) U4555.AU16(VSS_AU16) U4555.AU18(VSS_AU18) U4555.AU20(VSS_AU20) U4555.AU22(VSS_AU22) U4555.AU24(VSS_AU24) U4555.AU26(VSS_AU26) U4555.AU28(VSS_AU28) U4555.AU30(VSS_AU30) U4555.AU33(VSS_AU33) U4555.AU51(VSS_AU51) U4555.AU53(VSS_AU53) U4555.AU55(VSS_AU55) U4555.AU57(VSS_AU57) U4555.AU59(VSS_AU59) U4555.AV8(VSS_AV8) U4555.AV14(VSS_AV14) U4555.AV16(VSS_AV16) U4555.AV20(VSS_AV20) U4555.AV24(VSS_AV24) U4555.AV28(VSS_AV28) U4555.AV33(VSS_AV33) U4555.AV34(VSS_AV34) U4555.AV36(VSS_AV36) U4555.AV39(VSS_AV39) U4555.AV41(VSS_AV41) U4555.AV43(VSS_AV43) U4555.AV46(VSS_AV46) U4555.AV49(VSS_AV49) U4555.AV51(VSS_AV51) U4555.AV55(VSS_AV55) U4555.AV59(VSS_AV59) U4555.AW4(VSS_AW4) U4555.AW16(VSS_AW16) U4555.AW24(VSS_AW24) U4555.AW33(VSS_AW33) U4555.AW35(VSS_AW35) U4555.AW37(VSS_AW37) U4555.AW40(VSS_AW40) U4555.AW42(VSS_AW42) U4555.AW44(VSS_AW44) U4555.AW47(VSS_AW47) U4555.AW50(VSS_AW50) U4555.AW51(VSS_AW51) U4555.AW59(VSS_AW59) U4555.AW60(VSS_AW60) U4555.AY4(VSS_AY4) U4555.AY6(VSS_AY6) U4555.AY11(VSS_AY11) U4555.AY16(VSS_AY16) U4555.AY18(VSS_AY18) U4555.AY22(VSS_AY22) U4555.AY24(VSS_AY24) U4555.AY26(VSS_AY26) U4555.AY30(VSS_AY30) U4555.AY33(VSS_AY33) U4555.AY51(VSS_AY51) U4555.AY53(VSS_AY53) U4555.AY57(VSS_AY57) U4555.AY59(VSS_AY59) U4555.B4(VSS_B4) U4555.B20(VSS_B20) U4555.B24(VSS_B24) U4555.B26(VSS_B26) U4555.B28(VSS_B28) U4555.B32(VSS_B32) U4555.B36(VSS_B36) U4555.B40(VSS_B40) U4555.B44(VSS_B44) U4555.B48(VSS_B48) U4555.B52(VSS_B52) U4555.B56(VSS_B56) U4555.B60(VSS_B60) U4555.C11(VSS_C11) U4555.C14(VSS_C14) U4555.C18(VSS_C18) U4555.C20(VSS_C20) U4555.C25(VSS_C25) U4555.C27(VSS_C27) U4555.C38(VSS_C38) U4555.C39(VSS_C39) U4555.C57(VSS_C57) U4555.D2(VSS_D2) U4555.D5(VSS_D5) U4555.D8(VSS_D8) U4555.D12(VSS_D12) U4555.D14(VSS_D14) U4555.D18(VSS_D18) U4555.D21(VSS_D21) U4555.D23(VSS_D23) U4555.D25(VSS_D25) U4555.D26(VSS_D26) U4555.D27(VSS_D27) U4555.D29(VSS_D29) U4555.D30(VSS_D30) U4555.D31(VSS_D31) U4555.D33(VSS_D33) U4555.D34(VSS_D34) U4555.D35(VSS_D35) U4555.D37(VSS_D37) U4555.D38(VSS_D38) U4555.D39(VSS_D39) U4555.D41(VSS_D41) U4555.D42(VSS_D42) U4555.D43(VSS_D43) U4555.D45(VSS_D45) U4555.D46(VSS_D46) U4555.D47(VSS_D47) U4555.D49(VSS_D49) U4555.D50(VSS_D50) U4555.D51(VSS_D51) U4555.D53(VSS_D53) U4555.D54(VSS_D54) U4555.D55(VSS_D55) U4555.D57(VSS_D57) U4555.D59(VSS_D59) U4555.D62(VSS_D62) U4555.D63(VSS_D63) U4555.E11(VSS_E11) U4555.E17(VSS_E17) U4555.F20(VSS_F20) U4555.F26(VSS_F26) U4555.F30(VSS_F30) U4555.F34(VSS_F34) U4555.F38(VSS_F38) U4555.F42(VSS_F42) U4555.F46(VSS_F46) U4555.F50(VSS_F50) U4555.F54(VSS_F54) U4555.F58(VSS_F58) U4555.F61(VSS_F61) U4555.G3(VSS_G3) U4555.G5(VSS_G5) U4555.G6(VSS_G6) U4555.G8(VSS_G8) U4555.G18(VSS_G18) U4555.G22(VSS_G22) U4555.H13(VSS_H13) U4555.H17(VSS_H17) U4555.H57(VSS_H57) U4555.J10(VSS_J10) U4555.J22(VSS_J22) U4555.J59(VSS_J59) U4555.J63(VSS_J63) U4555.K1(VSS_K1) U4555.K12(VSS_K12) U4555.L7(VSS_L7) U4555.L13(VSS_L13) U4555.L15(VSS_L15) U4555.L17(VSS_L17) U4555.L18(VSS_L18) U4555.L20(VSS_L20) U4555.L58(VSS_L58) U4555.L61(VSS_L61) U4555.M22(VSS_M22) U4555.N3(VSS_N3) U4555.N10(VSS_N10) U4555.N21(VSS_N21) U4555.P22(VSS_P22) U4555.P59(VSS_P59) U4555.P62(VSS_P62) U4555.P63(VSS_P63) U4555.R8(VSS_R8) U4555.R10(VSS_R10) U4555.R22(VSS_R22) U4555.T1(VSS_T1) U4555.T58(VSS_T58) U4555.U9(VSS_U9) U4555.U20(VSS_U20) U4555.U22(VSS_U22) U4555.U61(VSS_U61) U4555.V3(VSS_V3) U4555.V7(VSS_V7) U4555.V10(VSS_V10) U4555.V23(VSS_V23) U4555.V58(VSS_V58) U4555.W20(VSS_W20) U4555.W22(VSS_W22) U4555.Y10(VSS_Y10) U4555.Y59(VSS_Y59) U4555.Y63(VSS_Y63) U4700.3(GND) U5000.5 U5301.2(I2C_CTL_EN) U5301.11 U5301.19 U5301.52 U5301.61(EPAD) U5401.2(I2C_CTL_EN) U5401.11 U5401.19 U5401.52 U5401.61(EPAD) U6000.14(GND) U6000.21(TML) U6100.2 U6150.2 U6200.4(AGND) U6200.12 U6200.13 U6200.14 U6200.15 U6200.19 U6240.4(PGND) U6240.8(GND) U6240.11(TML) U6300.4(AGND) U6300.12 U6300.13 U6300.14 U6300.15 U6300.19 U6350.11 U6450.11 U6600.29 U6600.33 U6610.3 U6610.9 U6903.2(GND) U7000.3(GND) U7400.4(V-)
DGND_CHASSIS1: C7629.1(A) CN2400.G3 CN2400.G4 JACK485.G3 JACK485.G4 R7629.1(A)
DGND_CHASSIS2: C7627.1(A) CN2400.G1 CN2400.G2 CN2401.G3 CN2401.G4 R7627.1(A) S3.1
DGND_CHASSIS3: C7631.1(A) CN2401.G1 CN2401.G2 CN3300.G3 CN3300.G4 R7631.1(A)
DGND_PBN: C9113.2(B) CN9100.1 CN9100.G1 CN9100.G2 S9101.1 S9102.1 SW9100.1 SW9100.G1 U9100.3
DGND_SM: C9000.2(B) C9001.2(B) C9002.2(B) C9003.2(B) C9004.2(B) C9005.2(B) C9006.2(B) C9007.2(B) C9009.2(B) C9010.2(B) C9011.2(B) C9015.2(B) C9021.2(B) C9035.2(B) C9036.2(B) CN9000.3 CN9000.6 CN9000.14 CN9000.15 CN9000.37 CN9000.38 CN9000.39 CN9000.40 CN9000.G1 CN9000.G2 CN9001.5(GND) CN9001.10(SW-CD-GND) CN9002.1 CN9002.7 CN9002.14 CN9002.G1 CN9002.G2 CN9021.5 CN9021.G1 CN9021.G2 Q9031.2(S) Q9032.4(S2) R9012.2(B) R9037.2(B) R9044.2(B) U9000.12(5VGND)
DGND_SYS1: C604.2(B) C650.2(B) C651.2(B) C652.2(B) C653.2(B) CN600.3 CN600.8 CN600.G1 CN600.G2 MIC600.5 MIC600.6 MIC600.7 MIC600.8 MIC601.5 MIC601.6 MIC601.7 MIC601.8 R640.1(A)
DGND_VGA: CN3050.G2
P0V675M_VREF: PAD6242.2 R4104.1(A) R4107.1(A) R4134.1(A)
P0V675M_VREF_H: C4124.1(A) R4503.2(B) U4555.AP49(SM_VREF_CA)
P0V675S: C4100.1(A) C4101.1(A) C4102.1(A) C4103.1(A) C4125.1(A) C4126.1(A) C4127.1(A) C4128.1(A) C4212.1(A) C4213.1(A) C4214.1(A) C7486.1(A) C7487.2(B) CN4100.203(VTT1) CN4100.204(VTT2) CN4125.203(VTT1) CN4125.204(VTT2) D4205.1 PAD6240.2 R7153.2(B)
P0V675S_DIMM0_VREF_CA: C4110.1(A) C4111.1(A) C4137.1(A) C4138.1(A) C4206.1(A) C4207.1(A) C4209.1(A) CN4100.126(VREF_CA) CN4125.126(VREF_CA) D4202.1 D4203.1 R4104.2(B) R4106.1(A) R4122.2(B) R4503.1(A)
P0V675S_DIMM0_VREF_DQ: C4119.1(A) C4120.1(A) C4200.1(A) C4201.1(A) C4202.1(A) CN4100.1(VREF_DQ) D4200.1 R4105.1(A) R4107.2(B) R4108.1(A) R4109.2(B)
P0V675S_DIMM1_VREF_DQ: C4144.1(A) C4145.1(A) C4203.1(A) C4204.1(A) C4205.1(A) CN4125.1(VREF_DQ) D4201.1 R4112.1(A) R4131.2(B) R4132.1(A) R4134.2(B)
P1V2_CR: C806.1(A) R800.1(A) U800.10(AV12)
P1V2_PHY_CR: C800.1(A) C801.1(A) R800.2(B) U800.14(DV12S)
P1V2A: C2551.1(A) C2557.1(A) C2558.1(A) C2559.1(A) C2560.1(A) C2561.1(A) C2562.1(A) C2563.1(A) C2564.1(A) PAD6450.2 U2550.5(VDD12<0>) U2550.8(VDD12<1>) U2550.13(VDD12<2>) U2550.21(VDD12<3>) U2550.28(VDD12<4>) U2550.31(VDD12<5>) U2550.51(VDD12<6>) U2550.57(VDD12<7>)
P1V05_LAN_M_PHY: C401.1(A) C403.1(A) C409.1(A) L400.2(INB) U400.8 U400.11 U400.16 U400.22 U400.37 U400.40 U400.43 U400.46 U400.47
P1V05_NIC: L400.1(INA) U400.7
P1V5_VDD: C3061.1(A) C3062.1(A) C3085.1(A) C3092.1(A) L3068.2(INB) R3077.2(B) R3081.2(B) U3065.8 U3065.36
P1V05A: PAD6300.2 Q4505.D Q7151.1(D0) Q7151.2(D1) Q7151.5(D2) Q7151.6(D3) Q7153.5(D3) Q7153.6(D2) Q7153.7(D1) Q7153.8(D0) R4807.1(A) R4850.1(A) R4855.2(B) R4875.1(A) R4877.2(B) R4886.1(A) R4891.1(A)
P1V05A_MODPHY: C4761.1(A) C4765.2(B) L4854.1(INA) L4865.1(INA) Q4505.S U4555.K9(VCCHSIO_K9) U4555.L10(VCCHSIO_L10) U4555.M9(VCCHSIO_M9)
P1V05A_SATA3PLL: C4790.1(A) C4792.1(A) L4865.2(INB) R4852.2(B) U4555.A12(SATA_IREF) U4555.B11(VCCSATA3PLL)
P1V05A_USB3PLL: C4785.1(A) C4786.1(A) L4854.2(INB) R4811.1(A) R4812.1(A) U4555.B18(VCCUSB3PLL)
P1V05M: C2990.1(A) C4716.1(A) C4729.1(A) C4758.2(B) PAD2990.1 Q7151.4(S0) R2958.1(A) R7150.1(A) U4555.AE9(VCCASW_AE9) U4555.AF9(VCCASW_AF9) U4555.AG8(VCCASW_AG8) U4555.AG13(VCCASW_AG13) U4555.AG14(VCCASW_AG14)
P1V05S: C2994.1(A) C2995.1(A) C4701.1(A) C4718.1(A) C4719.1(A) C4720.1(A) C4721.1(A) C4751.1(A) C4760.1(A) C7153.1(A) C7591.1(A) D7621.2 L4850.1(INA) L4851.1(INA) PAD2990.2 Q7153.1(S0) Q7153.2(S1) Q7153.3(S2) R4569.1(A) R4858.1(A) R4892.2(B) R7152.1(A) R7426.1(A) U4555.AE8(VCC1_05_AE8) U4555.AF22(VCC1_05_AF22) U4555.AG16(VCC1_05_AG16) U4555.AG17(VCC1_05_AG17) U4555.H11(VCC1_05_H11) U4555.H15(VCC1_05_H15) U4555.J11(VCC1_05_J11) U4555.J17(VCCCLK_J17) U4555.N8(VCC1_05_N8) U4555.P9(VCC1_05_P9) U4555.R21(VCCCLK_R21) U4555.T21(VCCCLK_T21)
P1V5S: C4763.1(A) C5309.1(A) C5311.1(A) C5312.1(A) C5314.1(A) C5409.1(A) C5411.1(A) C5412.1(A) C5414.1(A) C5450.1(A) PAD6350.2 U4555.J15(VCCTS1_5) U5301.5 U5301.17 U5301.30 U5301.51 U5401.5 U5401.17 U5401.30 U5401.51
P1V05S_APLLOPI: C4787.1(A) C4789.1(A) R4858.2(B) U4555.AA21(VCCAPLL_AA21) U4555.W21(VCCAPLL_W21)
P1V05S_AXCK_DCB: C4723.1(A) C4754.1(A) L4850.2(INB) U4555.J18(VCCCLK_J18) U4555.K19(VCCCLK_K19)
P1V05S_SSCF100: C4724.1(A) C4755.1(A) L4851.2(INB) U4555.A20(VCCACLKPLL)
P1V05S_VCCP: C4555.1(A) C4590.1(A) CN4920.43(VCC_OBS_AB) CN4920.44(VCC_OBS_CD) R4507.2(B) R4508.2(B) R4517.2(B) R4524.1(A) R4568.2(B) R4569.2(B) R4590.2(B) R4732.2(B) R4821.1(A) R4823.1(A) R4920.2(B) R4923.1(A) R7012.1(A) U300.79(VREF_PECI) U4555.AC22(VCCST_AC22) U4555.AE22(VCCST_AE22) U4555.AE23(VCCST_AE23)
P1V8S_SM: C9007.1(A) C9009.1(A) U9000.15(V18OUT) U9000.16(VDD) U9000.17(VDDP)
P1V35: C4106.1(A) C4107.1(A) C4108.1(A) C4109.1(A) C4112.1(A) C4113.1(A) C4114.1(A) C4115.1(A) C4116.1(A) C4117.1(A) C4118.1(A) C4131.1(A) C4132.1(A) C4133.1(A) C4134.1(A) C4135.1(A) C4136.1(A) C4139.1(A) C4140.1(A) C4141.1(A) C4142.1(A) C4143.1(A) C4146.1(A) C4147.1(A) C4200.2(B) C4201.2(B) C4203.2(B) C4204.2(B) C4206.2(B) C4210.2(B) C4212.2(B) C4213.2(B) C4515.1(A) C4516.1(A) C4525.1(A) C4526.1(A) C4527.1(A) C4528.1(A) C4990.1(A) C6241.1(A) C7597.1(A) C7598.1(A) C7604.1(A) C7605.1(A) C7606.1(A) C7632.1(A) C7633.1(A) C7634.1(A) C7635.1(A) C7636.1(A) C7637.1(A) C7638.1(A) C7639.1(A) C7640.1(A) CN4100.75(VDD1) CN4100.76(VDD2) CN4100.81(VDD3) CN4100.82(VDD4) CN4100.87(VDD5) CN4100.88(VDD6) CN4100.93(VDD7) CN4100.94(VDD8) CN4100.99(VDD9) CN4100.100(VDD10) CN4100.105(VDD11) CN4100.106(VDD12) CN4100.111(VDD13) CN4100.112(VDD14) CN4100.117(VDD15) CN4100.118(VDD16) CN4100.123(VDD17) CN4100.124(VDD18) CN4125.75(VDD1) CN4125.76(VDD2) CN4125.81(VDD3) CN4125.82(VDD4) CN4125.87(VDD5) CN4125.88(VDD6) CN4125.93(VDD7) CN4125.94(VDD8) CN4125.99(VDD9) CN4125.100(VDD10) CN4125.105(VDD11) CN4125.106(VDD12) CN4125.111(VDD13) CN4125.112(VDD14) CN4125.117(VDD15) CN4125.118(VDD16) CN4125.123(VDD17) CN4125.124(VDD18) D7611.2 D7612.2 D7613.2 D7614.2 D7615.2 D7616.2 PAD6200.2 Q4100.3(D) R4106.2(B) R4108.2(B) R4132.2(B) R4553.1(A) U4555.AH26(VDDQ_AH26) U4555.AJ31(VDDQ_AJ31) U4555.AJ33(VDDQ_AJ33) U4555.AJ37(VDDQ_AJ37) U4555.AN33(VDDQ_AN33) U4555.AP43(VDDQ_AP43) U4555.AR48(VDDQ_AR48) U4555.AY35(VDDQ_AY35) U4555.AY40(VDDQ_AY40) U4555.AY44(VDDQ_AY44) U4555.AY50(VDDQ_AY50) U6240.1(VDDQSNS) U6240.2(VLDOIN)
P3V3_CR: C804.1(A) C805.1(A) Q801.3 Q802.1(G) R808.1(A) R809.1(A) R810.1(A) U800.11(3V3_IN)
P3V3_RTC: C311.1(A) C312.1(A) C4709.1(A) C4710.1(A) C4766.1(A) D4750.3(C) R4742.1(A) R4831.1(A) R4833.1(A) R4834.1(A) R4842.1(A) R4845.1(A) U300.68(VBAT) U4555.AG10(VCCRTC)
P3V3_TPM: C3503.1(A) R3503.1(A) R3510.1(A) R3511.1(A) R3516.1(A) U3500.5
P3V3A: C321.1(A) C366.1(A) C2590.1(A) C4700.1(A) C4746.2(B) C4753.1(A) C7352.1(A) C7586.1(A) C7587.1(A) C7588.1(A) C7596.1(A) CN200.25 CN200.26 CN365.8(VDD) CN4941.1 L2550.1(INA) Q801.2 Q4753.2(G1) Q4753.5(G2) Q7353.1(S0) Q7353.2(S1) Q7353.3(S2) R331.1(A) R368.2(B) R369.2(B) R1306.1(A) R1307.1(A) R1315.2(B) R2201.2(B) R2203.1(A) R2556.2(B) R2559.2(B) R2560.1(A) R2561.1(A) R2562.2(B) R2563.2(B) R2564.1(A) R2565.1(A) R2566.1(A) R2568.1(A) R2569.1(A) R2570.1(A) R2575.1(A) R2580.1(A) R2581.1(A) R2590.1(A) R2954.1(A) R3510.2(B) R4116.1(A) R4714.1(A) R4720.1(A) R4725.1(A) R4733.1(A) R4734.1(A) R4736.1(A) R4737.2(B) R4741.1(A) R4746.1(A) R4778.2(B) R4792.1(A) R4797.1(A) R4827.1(A) R4830.1(A) R4839.2(B) R4840.2(B) R4856.2(B) R4857.1(A) R4861.1(A) R4884.1(A) R4900.1(A) R4904.1(A) R4908.1(A) R4911.1(A) R4914.1(A) R4915.1(A) R4916.1(A) R4917.1(A) R4918.1(A) R4931.1(A) R4960.1(A) R4961.1(A) R6645.2(B) R6663.1(A) R6666.1(A) R7353.1(A) U365.8 U2402.5 U2403.5 U2551.8(VCC) U4555.AA9(VCCSUS3_AA9) U4555.AC9(VCCSUS3_AC9) U4555.AE20(VCCSUS3_AE20) U4555.AE21(VCCSUS3_AE21) U4555.AH11(VCCSUS3_AH11) U4555.Y8(VCCSPI)
P3V3A_Q_WLAN: C1301.1(A) C1303.1(A) C1304.1(A) C1305.1(A) C1307.1(A) CN1300.2 CN1300.4 CN1300.72 CN1300.74 Q1300.1(D) Q1300.2(D1) Q1300.5(D3) Q1300.6(D2) Q1301.1(G) R1300.1(A) R1304.1(A)
P3V3A_SM: CN9000.25 CN9000.26 R9045.1(A)
P3V3AL_KBC: C131.1(A) C303.1(A) C308.1(A) C310.1(A) C314.1(A) C315.1(A) PAD300.2 U300.14(VCC1<0>) U300.37(VCC1<1>) U300.58(VCC1<2>) U300.84(VCC1<3>) U300.106(VCC1<4>) U300.119(VCC1<5>)
P3V3AL_PB: C9113.1(A) CN9100.6 R9100.2(B) U9100.1
P3V3AL_RTC_BAT: CN4750.1 R4832.2(B)
P3V3AL_SM: CN9000.22 R9031.2(B) R9032.2(B) R9047.1(A)
P3V3D_P1V8D: C802.1(A) U800.18(DV33_18)
P3V3DS: C305.1(A) C313.2(B) C316.1(A) C320.1(A) C335.1(A) C1000.1(A) C1001.1(A) C1308.1(A) C1402.1(A) C2970.1(A) C7581.1(A) C7582.1(A) CN200.22 CN290.1 CN300.4 CN4941.3 CN4941.7 D7603.2 D7604.2 D7605.2 PAD300.1 PAD1411.2 PAD6100.2 PAD6241.1 PAD6360.1 Q1300.4(S) Q1400.4(S) Q2971.4(S) Q6009.5(G2) Q6900.1(B) Q6903.1(B) Q7050.1(D0) Q7050.2(D1) Q7050.5(D2) Q7050.6(D3) Q7353.5(D3) Q7353.6(D2) Q7353.7(D1) Q7353.8(D0) R101.1(A) R103.1(A) R135.1(A) R303.2(B) R306.2(B) R307.2(B) R309.2(B) R310.2(B) R311.2(B) R312.2(B) R313.2(B) R314.2(B) R317.2(B) R318.2(B) R320.2(B) R322.2(B) R324.2(B) R325.2(B) R326.2(B) R327.2(B) R332.2(B) R340.2(B) R341.2(B) R343.1(A) R344.2(B) R346.2(B) R355.1(A) R363.1(A) R373.2(B) R1001.1(A) R1007.1(A) R1302.1(A) R1404.1(A) R2971.1(A) R3516.2(B) R4535.1(A) R4717.1(A) R4721.1(A) R4743.1(A) R4744.1(A) R4747.1(A) R4829.2(B) R4838.2(B) R4909.1(A) R6024.2(B) R6058.1(A) R6074.2(B) R6914.2(B) R6935.2(B) R7001.1(A) R7005.1(A) R7017.1(A) R7154.1(A) RS340.5 RS340.10 TP290.1 U300.40(AVCC) U302.5(VCC) U366.8 U1000.1(VDD_IO) U1000.8(CS) U1000.14(VDD)
P3V3M: C402.1(A) C2971.1(A) Q485.2(S) Q2971.1(D) Q2971.2(D1) Q2971.5(D3) Q2971.6(D2) R407.1(A) R485.1(A) R489.1(A) R2959.1(A) R2972.1(A) U400.4 U400.5 U400.15 U400.19 U400.29
P3V3M_R_RSVD: R407.2(B) U400.1
P3V3S: C502.1(A) C503.1(A) C505.1(A) C803.1(A) C807.1(A) C2255.1(A) C3006.1(A) C3311.1(A) C3502.1(A) C3504.1(A) C3506.1(A) C4104.1(A) C4105.1(A) C4129.1(A) C4130.1(A) C4210.1(A) C4211.1(A) C4717.1(A) C4730.2(B) C4935.1(A) C5009.1(A) C5310.1(A) C5313.1(A) C5410.1(A) C5413.1(A) C7050.1(A) C7485.1(A) C7583.1(A) C7584.1(A) C7585.1(A) C7593.1(A) C7628.1(A) CN200.23 CN200.24 CN202.1 CN3000.13 CN3000.22 CN4100.199(VDDSPD) CN4125.199(VDDSPD) D4204.1 L3065.1(INA) PAD1950.2 Q114.3 Q4752.2(G1) Q4752.5(G2) Q4759.2(G1) Q4759.5(G2) Q5314.2(G1) Q5314.5(G2) Q7050.4(S0) R113.2(B) R118.2(B) R127.1(A) R385.2(B) R386.2(B) R387.2(B) R388.2(B) R517.1(A) R570.2(B) R802.2(B) R1008.1(A) R1955.1(A) R2202.2(B) R3301.1(A) R3501.1(A) R3511.2(B) R4103.1(A) R4126.1(A) R4200.1(A) R4301.2(B) R4303.2(B) R4571.1(A) R4573.1(A) R4575.1(A) R4577.1(A) R4701.2(B) R4705.1(A) R4706.1(A) R4707.1(A) R4708.2(B) R4709.1(A) R4711.1(A) R4712.1(A) R4715.1(A) R4726.1(A) R4727.2(B) R4728.1(A) R4729.1(A) R4730.2(B) R4735.2(B) R4738.2(B) R4745.2(B) R4749.2(B) R4750.2(B) R4751.1(A) R4752.2(B) R4753.1(A) R4754.2(B) R4755.2(B) R4757.2(B) R4760.2(B) R4761.2(B) R4762.2(B) R4763.2(B) R4764.2(B) R4765.2(B) R4767.1(A) R4769.1(A) R4770.1(A) R4776.2(B) R4780.2(B) R4781.1(A) R4782.2(B) R4783.2(B) R4785.2(B) R4786.2(B) R4787.2(B) R4788.2(B) R4789.2(B) R4798.1(A) R4806.2(B) R4809.2(B) R4810.2(B) R4813.2(B) R4814.2(B) R4816.1(A) R4817.2(B) R4818.1(A) R4820.2(B) R4825.2(B) R4828.1(A) R4859.2(B) R4880.1(A) R4906.2(B) R4907.1(A) R4912.2(B) R4913.1(A) R4922.1(A) R4924.1(A) R4929.1(A) R5032.1(A) R5039.1(A) R5043.1(A) R5044.1(A) R5301.2(B) R5303.2(B) R5305.2(B) R5307.2(B) R5309.1(A) R5310.1(A) R5311.1(A) R5313.1(A) R5316.2(B) R5317.2(B) R5318.1(A) R5403.2(B) R5407.2(B) R5409.1(A) R5410.1(A) R5416.1(A) R5418.1(A) R5419.2(B) R5421.2(B) R5423.2(B) R5424.2(B) R7050.1(A) R7404.1(A) R7425.1(A) U501.3(DVDD-IO) U501.9(DVDD) U800.27(3V3AUX) U3000.5 U3300.5 U3500.10 U3500.19 U3500.24 U4555.AH14(VCCHDA) U4555.K14(VCC3_K14) U4555.K16(VCC3_K16) U4555.V8(VCC3_V8) U4555.W9(VCC3_W9) U4700.5(VCC) U5000.1 U5301.21 U5301.57 U5401.21 U5401.57
P3V3S_AVDD33: C3088.1(A) C3089.1(A) L3067.2(INB) U3065.1
P3V3S_CAM: C604.1(A) C650.1(A) C651.1(A) C652.1(A) C653.1(A) L603.2(INB) MIC600.1 MIC601.1 R641.2(B)
P3V3S_DP: C3308.1(A) C3310.1(A) CN3300.20 R3305.1(A) U3300.1(OUT)
P3V3S_DVDD33: C3065.1(A) C3066.1(A) C3093.1(A) L3065.2(INB) L3066.2(INB) L3067.1(INA) R3063.1(A) R3064.1(A) R3067.2(B) R3074.1(A) R3075.1(A) R3077.1(A) R3078.2(B) R3093.2(B) U3065.21
P3V3S_ISCT: CN200.7 Q114.2 R115.2(B) R126.2(B) R127.2(B) R130.1(A)
P3V3S_ISCT_SM: CN9000.7 R9033.2(B) R9034.2(B) R9038.2(B)
P3V3S_LCDVDD: C3003.1(A) CN3000.23 CN3000.24 R3001.2(B) U3000.1(OUT)
P3V3S_SM: CN9000.23 CN9000.24 R9035.1(A) R9036.1(A) R9040.2(B) R9046.2(B)
P3V3S_SM_AB: C9000.1(A) C9001.1(A) C9005.1(A) C9010.1(A) R9002.1(A) U9000.10(AV33) U9000.14(V33OUT) U9000.18(VDDH)
P3V3S_SSD: C1956.1(A) CN1951.2(3.3VAUX1) CN1951.4(3.3VAUX2) CN1951.14(3.3VAUX4) CN1951.16(3.3VAUX5) CN1951.18(3.3VAUX6) CN1951.70(3.3VAUX7) CN1951.72(3.3VAUX8) CN1951.74(3.3VAUX9) PAD1950.1 R1956.2(B)
P3V3S_VCC_READER: C808.1(A) C810.1(A) CN820.4 U800.12(CARD_3V3)
P3VA_D_L: C2552.1(A) C2553.1(A) C2554.1(A) C2555.1(A) C2556.1(A) L2550.2(INB) U2550.16(VDD33_1) U2550.34(VDD33_2) U2550.52(VDD33_3) U2550.63(VDD33_4)
P5V0A: C2412.1(A) C2413.1(A) C2414.1(A) C2415.1(A) C6616.1(A) C7355.1(A) C7400.1(A) C7592.1(A) C7613.1(A) C7614.1(A) Q7351.1(S0) Q7351.2(S1) Q7351.3(S2) R4114.1(A) R6665.2(B) R7355.2(B) U2400.2 U2400.3 U2401.2 U2401.3 U2950.5(VCC) U6610.2 U7400.8(V+)
P5V0A_USB2: C2401.1(A) C2402.1(A) CN2400.1 U2400.6 U2400.7 U2400.8
P5V0A_USB3: C2408.1(A) C2411.1(A) CN2401.1 U2401.6 U2401.7 U2401.8
P5V0A_USB_CHARGE: C2503.1(A) C2512.1(A) CN2500.1 U2511.12
P5V0DS: C2513.1(A) C2514.1(A) C7617.1(A) C7623.1(A) C7625.1(A) CN200.29 CN200.30 D7600.2 D7601.2 D7602.2 PAD6150.2 PAD6460.1 Q7100.1(D0) Q7100.2(D1) Q7100.5(D2) Q7100.6(D3) Q7351.5(D3) Q7351.6(D2) Q7351.7(D1) Q7351.8(D0) R2515.2(B) R4412.1(A) R7350.1(A) U2511.1 U2511.5 U6903.5(VCC)
P5V0DS_SM: CN9000.29 CN9000.30 R9049.1(A)
P5V0S: C508.1(A) C509.1(A) C510.1(A) C515.1(A) C532.1(A) C2250.1(A) C2251.1(A) C2256.1(A) C3357.1(A) C7100.1(A) C7494.2(B) C7589.1(A) C7607.1(A) C7608.1(A) CN200.27 CN200.28 CN3000.10 CN4300.1 L502.1(INA) PAD1700.1 Q300.3 Q7100.4(S0) R351.2(B) R803.1(A) R4899.2(B) R6029.1(A) R7100.1(A) R7405.1(A) U501.41(PVDD1) U501.46(PVDD2) U3051.2 U3051.3
P5V0S_AUDIO_AVDD: C501.1(A) C506.1(A) C507.1(A) C511.1(A) C512.1(A) C529.1(A) C550.1(A) C551.1(A) C554.1(A) C555.1(A) C562.1(A) C563.1(A) C566.1(A) C567.1(A) C615.1(A) L502.2(INB) R550.2(B) R551.2(B) R558.2(B) R559.2(B) R603.1(A) R618.2(B) U501.27(AVDD1) U501.38(AVDD2) U550.12 U550.20 U551.12 U551.20 U610.8(VDD+)
P5V0S_CRTVDD: C3058.1(A) CN3050.9 R3059.1(A) R3060.1(A) U3051.6 U3051.7 U3051.8
P5V0S_HDD: C1700.1(A) C1701.1(A) CN1700.P7 CN1700.P8 CN1700.P9 PAD1700.2
P5V0S_KBL: CN301.1 CN301.2 CN301.7 CN301.8 Q300.2
