# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VGA_B_L2: length 4.6
  TOP w0.114: CN3050.3 34.36,70.09 v1(36.1,70.09) 36.15,70.13 C3056.1 37.03,70.09 L3053.2
VGA_DEMUX_SW: length 5.8
  TOP w0.102: v2(263.1,76.39) 262.87,76.39 261.46,74.98 Q5401.3
  BOTTOM w0.102: U5401.18 263.23,76.52 v2(263.1,76.39) 262.49,76.39 v1(262.29,76.19) 261.44,75.34 R5418.2
VGA_G_L2: length 4.6
  TOP w0.114: CN3050.2 34.36,67.8 v1(36.1,67.8) 36.91,67.8 C3055.1 37.03,67.68 L3052.2
VGA_R_L2: length 4.6
  TOP w0.114: L3051.2 37.03,65.39 C3054.1 v1(36.1,65.44) 34.43,65.44 CN3050.1
VGAPC11: length 4.1
  BOTTOM w0.102: U5401.55 v1(266.8,65.9) 266.86,65.84 R5403.1
VGAPC21: length 4.3
  BOTTOM w0.102: U5401.53 267.61,68.41 267.24,68.05 267.24,67.52 267.67,67.09 R5407.1 269.57,67.09 v1(269.68,67.19)
VOLTAGE_ADC: length 42.3
  TOP w0.102: v2(292.16,119.32) 292.16,123.45 v1(293.4,124.7) 293.91,125.21 293.91,126.73 294.57,127.39 294.57,128.73 294.24,129.06 R6994.1 C6998.1 293.02,129.35 R6995.2 ; v2(283.12,96.12) R302.1
  L3 w0.102: v2(283.12,96.12) 283.98,96.99 283.98,103.74 284.39,104.15 284.39,107.66 285.55,108.83 285.55,110.29 288.82,113.55 288.82,115.18 289.59,115.95 289.59,117.97 290.94,119.32 v2(292.16,119.32)
VR_SVID_ALERT#: length 29.1
  TOP w0.254: v3(214.97,80.22) 214.97,78.95 214.31,78.29 213.19,78.29 212.98,78.09 R4524.2 212.55,78.3 212.24,78.61 R4525.2
  L3 w0.254: v4(229.21,85.61) 229.21,85.89 228.36,86.74 225.97,86.74 222.65,83.42 216.31,83.42 214.97,82.08 v3(214.97,80.22)
  BOTTOM w0.203: v4(229.21,85.61) 229.21,85.52 229.62,85.11 231,85.11 231.92,84.19 231.92,82.69 231.81,82.58 U6600.32
VR_SVID_CLK: length 25.5
  L3 w0.254: v4(228.55,85.61) 228.55,85.79 228.15,86.19 226.13,86.19 222.86,82.92 216.57,82.92 215.53,81.87 v3(215.53,81.62)
  BOTTOM w0.203: v4(228.55,85.61) 228.55,85.54 229.48,84.61 230.79,84.61 231.41,83.98 U6600.31
  BOTTOM w0.254: R6641.2 229.22,86.43 228.55,85.76 v4(228.55,85.61) ; v3(215.53,81.62) 214.97,81.07 U4555.N63
VR_SVID_DATA: length 31.4
  TOP w0.254: v2(213.11,80.24) 213.04,80.24 212.55,80.73 R4821.2 213.39,80.88 v1(213.52,81.01)
  L3 w0.254: v2(213.11,80.24) 213.11,81.14 213.37,81.39 213.37,81.94 213.63,82.2 214.46,82.2 216.19,83.93 222.44,83.93 225.76,87.25 228.6,87.25 229.87,85.98 229.87,85.63 v4(229.87,85.63)
  BOTTOM w0.203: U4555.L63 212.16,80.32 213.03,80.32 v2(213.11,80.24)
  BOTTOM w0.254: R6640.2 231.43,85.37 232.43,84.37 232.43,81.67 U6600.1
  BOTTOM w0.381: R6640.2 230.63,85.63 v4(229.87,85.63)
VRA3V3A_LDO: length 359.3
  TOP w0.254: v2(251.06,106.92) 251.06,107.02 250.7,107.38 250.27,107.38 249.84,107.81 R2950.1 ; v2(286.19,135.52) 286.42,135.29 292.16,135.29 292.38,135.07 R6934.2 293.83,135.07 294.55,134.35 294.93,134.35 295.31,133.97 295.31,131.43 296.58,130.16 298.99,130.16 299.86,131.03 U7000.5 ; v2(240.71,99.4) 240.52,99.59 R7410.1
  L3 w0.254: v2(266.66,140.61) 266.66,142.12 260.52,148.26 256,148.26 252.64,151.62 252.64,157.08 250.86,158.86 218.6,158.86 215.93,156.2 215.93,154.04 214.28,152.39 v2(213.01,152.39)
  L5 w0.254: v3(109.96,145.93) 111.16,144.74 111.16,139.2 110,138.04 110,132.05 114.27,127.78 114.27,125.25 115.42,124.09 115.42,117.42 115.42,116.71 126.55,105.58 140.06,105.58 141.31,104.32 v2(141.31,103.55)
  L6 w0.254: v2(202.98,150.73) 202.98,150.61 202.55,150.18 185.98,150.18 185.17,150.99 139.94,150.99 137.78,153.15 111.89,153.15 109.46,150.72 109.46,146.44 v3(109.96,145.93) ; v2(240.71,99.4) 240.71,99.65 241.08,100.01 241.54,100.01 242.48,100.95 244.51,100.95 244.81,101.25 244.81,101.76 245.78,102.73 248.19,102.73 250.7,105.23 250.7,106.35 251.06,106.72 v2(251.06,106.92) 251.88,106.92 261.35,116.4 261.35,118.39 268.43,125.48 268.43,139.22 267.04,140.61 v2(266.66,140.61)
  BOTTOM w0.254: v2(286.19,135.52) 286.19,144.23 282.1,148.32 277.4,148.32 271.56,142.48 268.53,142.48 v2(266.66,140.61) ; D4750.2 v2(141.31,103.55) ; R7111.2 209.75,150.4 211.11,151.75 212.42,151.75 213.01,152.34 v2(213.01,152.39)
  BOTTOM w0.292: U6100.6 203.68,152.07
  BOTTOM w0.381: 203.68,152.07 203.87,151.88 C6121.1 ; C6121.1 204.26,151.11 205.26,150.1 208.31,150.1 208.61,150.4 R7111.2 ; C6121.1 203.35,151.11 v2(202.98,150.73)
VRA3V3A_SNB: length 1.9
  BOTTOM w0.381: C7610.1 197.82,160.01 v1(198.51,160.01) 199.33,160.01 R7610.2
VRA3V3A_VCC: length 4.5
  BOTTOM w0.254: U6100.11 203.68,158.21 C6122.1 204.5,159.03 v1(204.5,159.88)
VRA5V0A_LDO: length 4
  BOTTOM w0.254: U6150.6 235.24,149.22 234.86,148.83 234.86,147.82 C6120.1 v1(233.59,147.52)
VRA5V0A_SNB: length 2.2
  BOTTOM w0.381: R7615.2 240.22,159.37 v1(239.55,159.37) 238.96,159.37 C7615.1
VRA5V0A_VCC: length 2.3
  BOTTOM w0.254: U6150.11 239.71,149.22 240.09,149.59 240.78,149.59 C6172.1
VRACPU_BST1: length 2.3
  BOTTOM w0.254: U6610.7 239.41,66.2 239.96,65.64 C6615.2 239.76,65.38 v1(239.76,64.76)
VRACPU_BST11: length 2.2
  BOTTOM w0.381: R6615.2 241.25,66.45 240.87,66.07 C6615.1 241.31,65.64 v1(241.66,65.29)
VRACPU_BST12: length 1.1
  BOTTOM w0.254: R6615.1 239.91,66.6 U6610.6
VRACPU_COMP: length 10.2
  BOTTOM w0.254: C6640.2 229.24,82.94 229.41,82.77 U6600.26
  BOTTOM w0.381: v1(227.15,89.86) R6633.2 227.36,88.67 227.36,87.86 227.09,87.58 226.88,87.58 226.41,87.11 226.41,87.1 226.3,86.99 R6651.1 226.3,86.71 226.68,86.32 226.68,85.07 227.66,84.09 R6656.2 227.66,83.63 228.19,83.1 C6640.2
VRACPU_COMP1: length 3.9
  BOTTOM w0.381: R6633.1 225.97,88.89 225.33,88.25 v1(225.33,87.36) 225.33,86.6 225.92,86.01 C6639.1
VRACPU_CSN1: length 26.5
  BOTTOM w0.254: L6610.4 229.21,67.75 229.73,68.28 229.73,69.75 228.21,71.27 227.69,71.27 227.25,71.72 R6617.2 227.2,71.86 R6619.2 226.23,71.86 226.03,72.06 225.61,72.06 225.39,71.84 223.68,71.84 222.91,72.61 222.91,73.33 v1(222.45,73.78) 222.91,74.24 222.91,75.81 221.9,76.82 221.9,78.85 222.37,79.33 223.08,79.33 C6614.1 223.52,79.33 225.51,79.33 225.58,79.4 C6618.2 C6617.2 227.32,79.4 227.47,79.25 U6600.18
VRACPU_CSP1: length 20.1
  BOTTOM w0.254: U6600.17 227.53,78.85 227.24,78.55 C6617.1 C6618.1 225.88,78.55 225.49,78.95 223.5,78.95 C6613.1 223.1,78.95 222.63,78.95 222.28,78.6 222.28,76.95 223.26,75.97 223.26,74.24 v1(223.72,73.78) 223.26,73.33 223.26,72.76 223.82,72.2 225.24,72.2 225.46,72.42 225.93,72.42 226.22,72.71 R6619.1 227.16,72.71 R6618.1 227.25,72.95 227.62,73.32 228.46,73.32 228.95,72.84 R6616.2
VRACPU_CSP2: length 5.7
  BOTTOM w0.254: R6663.2 225.23,81.39 225,81.16 v1(225,80.73) 225,80.33 225.44,79.88 227.36,79.88 227.37,79.87 227.54,80.05 U6600.20
VRACPU_CSP3: length 1.5
  BOTTOM w0.254: R6666.2 226.91,80.46 228.4,80.46 U6600.21
VRACPU_DROOP: length 5.6
  BOTTOM w0.254: v1(225.2,85.16) C6639.2 226.09,85.07 226.81,84.35 R6656.1 ; U6600.25 227.93,82.25 227.34,82.84 C6640.1
  BOTTOM w0.381: R6656.1 226.81,83.57 227.34,83.04 C6640.1
VRACPU_IMAX: length 3.6
  BOTTOM w0.254: R6650.1 232.16,76.89 232.16,77.15 231.76,77.56 231.58,77.56 231.41,77.73 U6600.10
  BOTTOM w0.381: R6650.1 232.83,76.23 R6649.2
VRACPU_IMON: length 4.5
  BOTTOM w0.254: U6600.13 230.21,77.2 v1(230,77) 229.83,77 229.44,76.61 229.44,75.76 229.82,75.38 R6655.1 229.97,74.78 C6645.1
VRACPU_OCP: length 4.3
  BOTTOM w0.254: 230.11,76.23 230.2,76.23 230.61,76.64 U6600.12 ; 230.11,76.23 230.52,75.82 230.52,74.73 R6654.1 ; 230.11,76.23 R6655.2
VRACPU_PWM1: length 21.8
  L6 w0.254: v2(235.85,79.66) 235.62,79.66 235.24,79.28 235.24,78.38 235.8,77.81 236.41,77.81 239.78,74.44 239.78,66.05 v3(239.02,65.29)
  BOTTOM w0.254: U6610.8 239.02,65.75 v3(239.02,65.29) ; U6600.6 232.99,79.65 233.46,80.12 233.46,80.12 233.56,80.22 233.99,80.22 234.65,79.56 235.74,79.56 v2(235.85,79.66)
VRACPU_PWM3: length 5.5
  BOTTOM w0.254: R6612.1 236.71,79.35 v1(236.71,80.12) 236.68,80.15 234.75,80.15 234.26,80.63 233.46,80.63 233.28,80.45 U6600.4
VRACPU_RAMP: length 3.3
  BOTTOM w0.254: U6600.11 231.01,77.46 v1(231.48,77) 231.93,76.54 R6653.1 231.93,76.23 R6652.2
VRACPU_SKIP#: length 25.7
  L6 w0.254: v4(238.4,64.96) 238.55,64.81 239.24,64.81 240.19,65.75 240.19,74.74 236.46,78.47 235.84,78.47 235.84,78.46 v2(235.83,78.46)
  BOTTOM w0.254: v2(235.83,78.46) 235.84,78.46 235.85,78.47 235.79,78.52 233.53,78.52 233.2,78.85 233.2,79.03 232.98,79.25 U6600.7 ; U6610.1 235.87,65.54 235.87,64.5 236.25,64.12 v1(238.03,64.12) 238.4,64.49 v4(238.4,64.96)
VRACPU_SLEWA: length 4.5
  BOTTOM w0.254: R6659.2 R6660.2 227.88,76.95 v1(228.43,76.95) 228.61,76.95 229.39,77.72 229.39,77.73 229.41,77.76 U6600.15
VRACPU_SNB1: length 2.4
  TOP w0.381: v1(233.99,67.7) 233.93,67.64 R7661.2 232.62,67.64 C7661.1
VRACPU_THERM: length 12.2
  BOTTOM w0.254: U6600.14 229.81,77.59 229.39,77.18 229.39,77.07 228.93,76.61 C6646.2 R6658.2 228.93,73.94 v1(228.89,73.9) 228.89,73.82 230.84,71.87 233.08,71.87 233.59,71.36 233.59,70.47 233.88,70.17 R6661.2
VRACPU_USR: length 4.6
  BOTTOM w0.254: U6600.9 231.81,78.11 232.69,77.24 v1(232.74,77.24) 232.74,77.19 232.91,77.01 232.91,77.01 233.21,76.71 234.12,76.71 R6646.2
  BOTTOM w0.381: R6646.2 234.6,76.23 R6647.1
VRACPU_V5A: length 9.3
  BOTTOM w0.178: 227.71,86.08 227.45,85.82 227.45,85.42 229.11,83.77 229.37,83.77 230.21,82.93 U6600.28
  BOTTOM w0.254: v1(229.01,88.63) 228.97,88.59 R6665.1 228.12,88 227.85,87.72 227.85,86.62 228.04,86.43 228.06,86.43 ; 227.71,86.08 228.06,86.43 ; 228.06,86.43 C6643.1
VRACPU_VBAT: length 3
  BOTTOM w0.254: R6657.2 227.59,77.77 v1(227.59,77.9) 227.76,77.73 228.83,77.73 229.01,77.91 U6600.16
VRACPU_VDD: length 3.5
  BOTTOM w0.254: U6600.2 232.95,81.25 233.22,81.52 C6642.1 R6645.1 233.39,82.47 234.22,83.3 v1(234.47,83.3)
VRACPU_VREF: length 39.6
  TOP w0.381: C6644.1 228.29,83.39 v3(228.54,83.64)
  L6 w0.254: v2(226.56,74.29) 226.56,73.98 227.08,73.47 228.73,73.47 229.77,74.51 232.47,74.51 232.92,74.05 233.71,74.05 234.08,74.42 v2(234.08,74.66) ; v3(228.54,83.64) 227.99,83.09 227.99,80.54 227.42,79.98 225.37,79.98 224.44,79.06 v2(224.44,78.06)
  BOTTOM w0.254: R6661.1 234.22,74.51 v2(234.08,74.66) ; v2(234.08,74.66) 233.47,74.05 233,74.05 232.21,74.84 231.58,74.84 R6652.1 ; v2(234.08,74.66) 234.08,74.88 233.71,75.25 R6649.1 R6646.1 ; v2(226.56,74.29) 226.56,74.37 226.09,74.84 R6659.1 225.3,75.2 223.93,76.57 223.93,77.77 224.23,78.06 v2(224.44,78.06) ; R6651.2 227.1,86.8 227.1,85.3 228.24,84.16 228.24,83.93 v3(228.54,83.64) 228.83,83.35 229.34,83.35 229.81,82.88 U6600.27
VRANB669GQ_VCLK: length 25.2
  BOTTOM w0.254: C6157.1 v1(217.34,149.34) 217.34,148.97 218.15,148.17 221.77,148.17 C6156.1 222.95,148.17 225.23,148.17 225.71,147.69 230.92,147.69 233.15,145.46 234.91,145.46 235.24,145.78 235.24,148.45 235.6,148.82 U6150.5
VRANB669GQ_VCLK1: length 5.6
  BOTTOM w0.254: C6156.2 222.95,150.2 D6150.3 226.93,149.38 v1(226.93,148.93)
VRANB669GQ_VCLK2: length 2.6
  BOTTOM w0.254: C6157.2 217.34,151.81 v1(217.18,151.98) 218.02,151.98 D6151.3
VRANB669GQ_VCLK3: length 5.3
  BOTTOM w0.254: D6150.1 223.42,150.76 C6158.1 222.24,150.76 221.77,151.22 221.77,151.49 D6151.2 220.89,152.38 v1(220.89,153.76)
VRAVR_ON: length 1.5
  BOTTOM w0.254: R6643.1 233.4,78.02 232.57,78.85 U6600.8
VRB3V3A_BST: length 2.3
  BOTTOM w0.254: R6115.1 203.11,157.63 v1(203.11,156.88) 203.11,156.2 203.28,156.02 U6100.10
VRB3V3A_BST1: length 2.3
  BOTTOM w0.381: C6115.1 202.26,159.08 R6115.2
  BOTTOM w0.508: R6115.2 203.16,159.39 v1(203.16,160.06)
VRB5V0A_BST: length 1.9
  BOTTOM w0.254: 239.25,149.9 239.25,149.65 U6150.10
  BOTTOM w0.381: R6165.1 239.52,150.23 239.25,149.95 239.25,149.9
VRB5V0A_BST1: length 2.3
  BOTTOM w0.381: R6165.2 243.16,150.23 C6165.1 243.24,149.72 v1(242.98,149.46)
VRB_VDD5: length 183.1
  TOP w0.381: R6310.2 122.93,94.3 121.49,95.74 121.49,95.97 v3(121.57,96.05)
  L3 w0.254: v3(121.57,96.05) 120.45,97.17 120.45,98.64 118.09,101 118.09,104.94 117.13,105.9 117.13,116.06 120.43,119.37 120.43,130.16 117.99,132.6 117.99,140.17 120.83,143.01 137.85,143.01 v4(139.35,144.51) ; v4(225.08,148.88) 225.08,148.95 223.93,150.1 212.5,150.1 211.36,148.96 196.63,148.96 191.42,154.16 180.88,154.16 177.83,151.12 165.64,151.12 165.51,150.99 148.24,150.99 v2(147.48,151.75)
  BOTTOM w0.254: R6210.2 154.08,152.13 152.88,150.92 148.3,150.92 v2(147.48,151.75)
  BOTTOM w0.381: v4(139.35,144.51) 139.35,144.77 143.35,148.77 146.4,148.77 147.48,149.85 v2(147.48,151.75) ; D6150.2 224.73,149.24 v4(225.08,148.88) 225.53,148.88 226.17,148.24 228.06,148.24 R6161.2
VREF_EQ: length 7.2
  BOTTOM w0.254: C616.1 286.52,54.29 U610.3 288,54.29 288.14,54.14 290.58,54.14 ; U610.6 290.73,54.29 290.58,54.14 ; 290.58,54.14 290.58,53.86 290.81,53.63 U610.7
VRP1V2A: length 10
  TOP w0.381: R6450.2 v4(247.43,81.77) 246.87,81.77 C6452.1
  BOTTOM w0.508: v4(247.43,81.77) 247.43,82.15 248.3,83.03 v4(254.67,83.03)
  vias: v1(256.06,86.09)
VRP1V2A_PH:
  vias: v1(248.57,89.77)
VRP1V05A: length 37.3
  BOTTOM w0.254: 137.04,100.42 137.95,101.33 137.95,103.24 v1(137.45,103.74) 136.68,104.51 124.49,104.51 124.11,104.13 118.52,104.13 117.51,103.11 117.51,99.93 116.62,99.05 116.62,97.39 117.38,96.63 118.27,96.63 118.78,97.14 119.25,97.14 119.46,97.35 R6300.1
  BOTTOM w0.381: C7471.2 136.68,99.89 C6304.1 135.67,100.38 C7474.2
VRP1V05A_PH: length 4.5
  BOTTOM w0.381: C6315.2 127.67,95.82
  BOTTOM w0.508: v1(130.62,102.83) R7630.1 130.62,100.99 129.98,100.34 129.04,100.34
VRP1V5S: length 6.4
  TOP w0.381: v5(103.28,137.56) 103.28,139.3 104.34,140.36 v1(104.34,141.55) R6350.2 104.34,142.61 C6352.1
VRP1V5S_PH:
  vias: v1(97.06,148.45) v5(96.3,147.43) v5(96.3,146.16) v5(97.57,147.43) v5(97.57,146.16)
VRP3V3A: length 20.5
  BOTTOM w0.254: 190.28,150.73 189.9,150.73 189.64,150.48 189.64,147.97 190.25,147.36 194.48,147.36 196.08,148.96 201.2,148.96 202.34,150.1 202.34,150.99 202.9,151.54 C6109.1 202.9,152.19 203.28,152.57 U6100.7
  vias: v1(191.9,152.63)
VRP3V3A_PH: length 9.2
  BOTTOM w0.381: C6115.2 201.84,157.08 200.66,155.91 200.66,155.03
  BOTTOM w0.508: v1(201.71,160.01) 201.58,159.88 R7610.1 200.66,155.04 200.66,155.03
VRP5V0A: length 12.2
  BOTTOM w0.254: C6152.1 229.9,150.45 229.9,149.34 230.21,149.03 233.61,149.03 234.07,149.49 C6169.1 234.42,149.62 U6150.7
  BOTTOM w0.381: D7619.2 229.23,148.57 R6161.1 ; 232.74,152.74 R6150.2 ; C6166.2 232.21,150.46
  BOTTOM w0.508: C6152.1 229.23,150.41 D7619.2
  vias: v1(232.2,155.51)
VRP5V0A_PH: length 9
  BOTTOM w0.381: C6165.2 243.24,151.62 242.67,152.19 ; v1(242.86,159.37) 242.19,159.37 R7615.1 241.8,154.57 241.65,154.42 ; 237.17,151.24 236.53,151.24 235.75,150.46 R6166.1
VRPPM_SLP_S0_N: length 51.9
  TOP w0.102: v2(166.55,87.87) v1(166.55,86.48) 166.99,86.05 R4799.1 ; CN4941.15 129.76,81.08 129.33,81.5 v2(129.33,85.56)
  L3 w0.102: v2(166.55,87.87) 166.55,87.86 165.51,86.82 163.62,86.82 162.39,85.6 161.64,85.6 160.65,84.61 159.55,84.61 158.02,83.08 152.2,83.08 148.6,79.49 144.05,79.49 143.16,80.38 143.16,81.01 142.78,81.39 139.1,81.39 134.93,85.56 v2(129.33,85.56)
VRPPM_SLP_S0_N_R: length 9.7
  TOP w0.102: R4799.2 167.67,87.43 v3(167.22,87.88)
  BOTTOM w0.076: U4555.AF3 174.84,87.89 174.58,88.14 174.06,88.14 173.83,87.91 173.83,87.73 173.66,87.56 173.14,87.56 173.14,87.56 171.62,87.56 171.49,87.69
  BOTTOM w0.102: v3(167.22,87.88) 167.41,87.69 169.24,87.69 169.54,87.39 170.43,87.39 170.8,87.75 171.42,87.75 171.49,87.69
VRPVDDQ: length 28.1
  TOP w0.381: v2(166.31,151.9) 166.31,151.79 165.16,150.63 150.63,150.63 v3(149.38,151.88)
  BOTTOM w0.381: C7470.2 167.29,150.61 ; v3(149.38,151.88) 147.99,153.27 147.99,156.96 149.64,158.61 R6200.1 ; C7469.2 163.61,158.86
VRPVDDQ_PG: length 3.3
  BOTTOM w0.254: R7416.1 152.18,156.7 v1(153.07,157.59) 153.07,157.72 153.64,158.29 153.64,158.54 153.76,158.66 U6200.1
VRPVDDQ_PH: length 6.7
  BOTTOM w0.381: v1(158.91,149.34) 158.87,149.37 R7620.1 158.93,150.41 L6200.1 158.49,153.87 C6215.2
VRPVPACK_HG: length 18.5
  TOP w0.254: v5(287.56,124.57) 287.68,124.69 287.68,124.71 287.81,124.84 U6000.18
  TOP w0.508: v1(273.38,122.8) 272.83,122.8 272.7,122.67 272.69,122.67 v5(272.56,122.53)
  L3 w0.635: v5(272.56,122.53) 272.72,122.69 276.62,122.69 276.63,122.68 278.02,124.06 279.43,124.06 280.58,125.21 283.37,125.21 284,124.57 v5(287.56,124.57)
VRPVPACK_LG: length 14
  TOP w0.762: 285.15,125.33 280.96,125.33 278.92,123.3 278.92,120 v1(278.16,119.24) 278.08,119.15 v5(276.39,119.15)
  BOTTOM w0.254: Q6001.4 276.39,119.75
  BOTTOM w0.508: 276.39,119.75 v5(276.39,119.15)
VRPVPACK_PH: length 24.5
  TOP w0.254: U6000.19 288.31,123.35 C6015.2 288.62,123.35 288.96,123.68 v5(288.96,124.7)
  BOTTOM w0.508: 270.11,125.02 269.15,125.99 R7600.1 ; L6000.1 273.41,123.89 273.62,123.68 v1(279.31,123.68) 279.43,123.81 288.07,123.81 v5(288.96,124.7)
VRPVTT:
  vias: v1(172.16,155.31)
VRPVTT_REF: length 9.4
  BOTTOM w0.356: U6240.6 176.7,154.03 176.1,154.63 C6243.1 176.82,155.05 177.45,154.42 181.9,154.42 182.28,154.04 v1(182.28,153.53) PAD6242.1
WL_LED_ALL#: length 360.2
  TOP w0.102: v2(305.64,149.21) 308.34,149.21 Q110.1 307.36,150.41 307.36,155.3 306.88,155.78 D110.1 ; v2(312.33,114.41) 312.2,114.41 310.61,112.83 310.61,112.07 v2(308.01,109.46) ; CN200.16 107.05,89.53 106.41,88.89 104.55,88.89 102.78,87.11 102.78,85.63 v2(103.08,85.33)
  L3 w0.102: v2(312.33,114.41) 312.96,115.05 312.96,116.57 310.8,118.73 301.28,118.73 v2(300.64,119.37) ; v2(103.08,85.33) 103.13,85.38 103.87,85.38 104.76,84.48 112.13,84.48 113.7,82.92 v2(114.66,82.92)
  L5 w0.102: v2(275.32,68.01) 274.87,68.46 273.5,68.46 271.82,66.77 269.91,66.77 269.73,66.58 268.53,66.58 267.69,65.74 267.69,64.43 267.22,63.97 267.22,63.96 266.81,63.55 266.17,62.92 266.17,61.9 265.45,61.17 265.45,58.69 264.9,58.14 261.29,58.14 260.54,57.4 252.08,57.4 251.89,57.2 251.37,56.68 250.34,55.65 241.5,55.65 239.69,57.46 231.36,57.46 230.64,56.73 223.6,56.73 222.27,55.4 195.26,55.4 194.52,56.14 188.07,56.14 187.75,55.83 180.95,55.83 180.37,56.4 177.29,56.4 170.66,63.03 167.26,63.03 166.67,63.63 165.11,63.63 163.24,65.51 142.54,65.51 139.49,68.56 136.88,68.56 133.76,71.67 133.76,74.66 134.14,75.04 134.14,76.44 129.19,81.39 116.19,81.39 v2(114.66,82.92)
  BOTTOM w0.102: v2(275.32,68.01) 272.83,70.5 272.83,71.36 273.47,72 273.47,81.87 279.15,87.54 279.15,89.36 279.56,89.77 285.02,89.77 285.78,90.54 285.78,94.73 286.54,95.49 288.07,95.49 288.7,96.12 291.49,96.12 293.15,97.78 293.15,100.95 293.53,101.33 293.53,102.09 296.17,104.73 300.36,104.73 301.53,105.9 305.33,105.9 308.01,108.58 v2(308.01,109.46) ; 308.77,113.9 308.77,112.13 308.54,111.9 CN1300.6 ; 308.77,113.9 308.77,114.23 308.6,114.4 CN1300.16 ; 308.77,113.9 311.82,113.9 v2(312.33,114.41) ; v2(114.66,82.92) 115.93,81.65 120.17,81.65 v1(120.76,82.23) 121.76,83.23 123.54,83.23 124.82,81.95 R118.1 126.62,81.95 Q112.3 ; v2(305.64,149.21) 305.64,148.5 301.53,144.38 301.53,131.43 301.78,131.18 301.78,129.53 300.58,128.32 300.58,119.43 v2(300.64,119.37)
WL_LED_SM_ALL#: length 109.9
  TOP w0.102: v2(80.55,138.53) v1(74.84,138.53) Q9031.1 ; v4(26.77,158.23) D9033.2 ; v2(79.53,106.28) 79,106.82 CN9000.16
  L3 w0.102: v2(79.53,106.28) 80.17,105.65 82.58,105.65 83.98,107.05 83.98,134.99 80.55,138.42 v2(80.55,138.53)
  L6 w0.102: v2(80.55,138.53) 79.52,139.56 72.17,139.56 70.52,141.21 69.5,141.21 54.52,156.2 36.35,156.2 34.96,157.59 27.41,157.59 v4(26.77,158.23)
WLAN_OFF: length 51.8
  TOP w0.102: v2(273.72,96.51) 274.53,96.51 275.28,95.76 U300.30 ; R1311.1 302.42,127.7 302.42,126.1 v3(301.66,125.33)
  L3 w0.102: v3(301.66,125.33) 300.64,124.32 299.25,124.32 296.42,121.49 292.09,121.49 288.7,118.1 288.7,116.13 288.44,115.87 288.24,115.66 288.24,115.66 288.07,115.5 288.07,113.81 284.79,110.52 284.79,109.07 283.17,107.45 279.84,107.45 277.53,105.14 277.53,100.32 v2(273.72,96.51)
WLAN_TRANSMIT_OFF#: length 192.5
  TOP w0.076: v2(175.47,104.67) 174.91,104.11 174.91,99.05 174.53,98.66 v1(174.53,97.9) 174.53,97.01 176.5,95.04 176.5,94.69 177.43,93.76 177.43,90.88 178.16,90.15 178.16,88.98 178.22,88.93 178.22,88.17 177.9,87.85 176.96,87.85 v2(176.54,88.28)
  TOP w0.102: R1315.1 311.68,125.08 311.26,125.5 310.01,125.5 v2(309.78,125.27) 309.62,125.12 309.62,122.72 310.26,122.08 D1300.3
  L5 w0.102: v2(309.78,125.27) 309.78,125.27 309.78,126.13 309.43,126.48 306.05,126.48 303.71,124.14 303.71,123.25 304.1,122.87 304.1,120.74 304.86,119.98 304.86,116.9 303.51,115.56 303.51,111.57 303.16,111.21 303.16,109.64 302.04,108.52 299.81,108.52 299.12,107.82 299.12,106.28 296.93,104.1 295.99,104.1 294.34,102.45 294.34,101.84 293.41,100.91 292.55,100.91 v2(292.01,101.46)
  BOTTOM w0.076: U4555.AG6 176.54,88.51 v2(176.54,88.28)
  BOTTOM w0.102: v2(175.47,104.67) 178,107.2 237.41,107.2 237.99,106.63 243.21,106.63 243.58,107 248.86,107 249.19,107.33 252.35,107.33 252.63,107.05 258.22,107.05 258.3,107.12 264.82,107.12 267.04,104.91 274.1,104.91 274.5,105.31 277.37,105.31 277.91,105.86 284.05,105.86 285.25,104.66 285.25,101.61 285.58,101.28 291.83,101.28 v2(292.01,101.46)
WLAN_WAKE#: length 101.3
  TOP w0.102: v4(302.17,132.32) 301.25,133.23 299.1,133.23 R363.2 ; U300.103 262.04,106.49 260.41,106.49 259.65,107.25 258.91,107.25 258.63,106.97 v1(258.05,106.97) 257.41,106.97 v2(256.83,107.55)
  L6 w0.102: v2(277.78,115.81) 275.11,115.81 274.83,115.53 274.83,114.39 273.84,113.4 270.16,113.4 267.77,111.01 259.82,111.01 256.83,108.01 v2(256.83,107.55)
  BOTTOM w0.102: v2(277.78,115.81) 278.61,114.98 284.96,114.98 291.29,121.32 295.89,121.32 298.74,118.48 302.04,118.48 302.55,118.98 302.55,131.94 v4(302.17,132.32) 302.17,133.46 303.99,135.29 309.66,135.29 312.2,132.75 312.2,128.51 313.72,126.99 313.72,124.45 314.02,124.15 CN1300.55
WWAN_CONFIG_1: length 135.6
  TOP w0.102: v2(250.88,66.15) 250.88,69.68 249.71,70.85 246.97,70.85 v2(246.29,71.54) ; R4914.2 159.42,88.46 159.42,89.17 v3(160.26,90.01)
  L5 w0.076: v2(175.89,88.28) 175.89,88.16 176.26,87.79 178.08,87.79 180.1,85.77 v2(180.1,85.56)
  L5 w0.102: v2(220.94,79.44) 220.94,81.71 226.11,86.88 238.76,86.88 238.82,86.94 239.24,86.94 239.81,86.38 v2(239.81,83.6)
  L6 w0.102: v2(220.94,79.44) 220.53,79.84 215.47,79.84 215.3,79.66 212.35,79.66 212.05,79.36 209.91,79.36 209.38,78.83 206.36,78.83 205.37,79.82 190.07,79.82 187.87,82.03 186.95,82.03 186.05,82.93 184,82.93 183.18,83.75 181.17,83.75 180.55,84.37 180.55,85.12 v2(180.1,85.56) ; v2(175.89,88.28) 175.86,88.24 174.17,88.24 173.04,88.24 172.99,88.18 172.64,88.18 172.35,88.47 172.35,88.53 171.85,89.04 170.53,89.04 170.46,89.11 169.48,89.11 169.03,88.67 168.17,88.67 167.72,89.11 164.41,89.11 163.04,90.49 160.73,90.49 v3(160.26,90.01) ; v2(246.29,71.54) 244.46,73.37 244.46,82.79 242.58,84.67 240.54,84.67 239.81,83.93 v2(239.81,83.6)
  BOTTOM w0.076: v2(175.89,88.28) 175.89,88.52 U4555.AG5
  BOTTOM w0.102: CN1400.69 250.14,58.25 251.57,59.68 251.57,65.47 v2(250.88,66.15)
WWAN_CONFIG_2: length 139.4
  TOP w0.102: v2(159.57,90.03) 159.19,90.03 v1(158.83,89.67) 158.81,89.65 R4915.2 ; v2(247.15,71.56) 249.71,71.56 251.35,69.92 251.35,65.02 249.28,62.95 v2(249.28,57.49)
  L5 w0.076: v2(174.54,88.98) 174.54,88.94 174,88.4 174,87.28 174.35,86.93 178.02,86.93 178.9,86.05 178.9,85.5 179.35,85.05 179.66,85.05 v2(180.12,84.59)
  L5 w0.102: v2(220.33,79.39) 220.33,79.4 220.71,79.78 220.71,81.76 226.07,87.13 238.72,87.13 238.74,87.15 239.33,87.15 240.19,86.29 240.19,83.84 v2(240.4,83.63)
  L6 w0.102: v2(180.12,84.59) 180.12,84.07 180.83,83.36 182.96,83.36 184.19,82.12 186.32,82.12 186.8,81.65 187.69,81.65 189.74,79.59 205.21,79.59 206.2,78.6 209.43,78.6 209.99,79.16 212.11,79.16 212.43,79.47 215.38,79.47 215.49,79.59 220.12,79.59 v2(220.33,79.39) ; v2(247.15,71.56) 246.52,70.93 245.74,70.93 243.75,72.92 243.75,82.59 242.14,84.19 240.96,84.19 v2(240.4,83.63) ; v2(159.57,90.03) 160.15,90.61 160.15,91.96 160.35,92.16 163.05,92.16 164.14,91.07 169.32,91.07 170.82,89.57 173.41,89.57 174,88.98 v2(174.54,88.98)
  BOTTOM w0.076: U4555.AG3 174.84,88.56 174.54,88.86 v2(174.54,88.98)
  BOTTOM w0.102: v2(249.28,57.49) 248.54,56.75 CN1400.75
WWAN_DET#: length 135.9
  TOP w0.102: v3(148.37,99.12) 148.75,98.74 148.75,91.21 148.39,90.85 148.39,87.77 148.6,87.56 148.6,85.79 148.39,85.58 148.39,78.09 150.27,76.21 v2(150.4,76.21)
  L5 w0.102: v2(248.57,74.89) 247.91,74.23 233,74.23 232.54,74.69 229.69,74.69 227.94,72.93 225.38,72.93 224.14,71.69 217.02,71.69 216.57,72.15 207.32,72.15 206.04,73.43 203.64,73.43 203.11,73.96 186.13,73.96 185.7,73.53 184.53,73.53 183.53,74.53 182.07,74.53 182.07,74.53 178.94,74.53 178.01,73.6 174.83,73.6 172.82,75.61 170.88,75.61 169.48,77.02 167.42,77.02 166.22,75.83 162.82,75.83 160.86,77.79 158.32,77.79 158.16,77.95 155.22,77.95 155.15,77.89 152.08,77.89 v2(150.4,76.21)
  BOTTOM w0.102: v2(248.57,74.89) 248.21,75.25 CN1400.1 245.74,75.25 R1405.1 ; R4831.2 145.76,99.28 Q4831.1 146.51,99.12 v3(148.37,99.12)
WWAN_NGFF_DPR: length 23.9
  BOTTOM w0.102: CN1400.25 248.93,69.25 252.2,65.98 252.2,59.4 250.45,57.64 250.45,54.47 251.59,53.33 v1(254.03,53.33) 255.22,53.33 R1408.2
WWAN_OFF#: length 55.9
  TOP w0.102: U300.33 277.07,96.48 276.66,96.07 276.66,90.76 276.41,90.51 276.41,90.1 276.16,89.85 v1(276.16,89.27) 276.16,88.61 276.73,88.03 276.73,87.55 277.35,86.93 277.35,84.31 276.79,83.75 269.35,83.75 v2(268.76,83.17) 268,83.93 263.93,83.93 263.42,84.44 v2(262.54,84.44) ; v2(258.43,75.7) 258.96,75.7 261.35,73.31 261.35,72.42 261.72,72.04 Q1401.1
  L6 w0.102: v2(258.43,75.7) 258.96,75.7 259.42,76.16 259.42,80.3 262.54,83.42 v2(262.54,84.44)
  BOTTOM w0.102: v2(268.76,83.17) 267.65,84.29 265.06,84.29 262.41,81.64 R1403.2 261.61,80.93 R1404.2 ; R1417.2 258.73,75.4 v2(258.43,75.7)
WWAN_TRANSMIT_OFF#: length 273.8
  TOP w0.102: v2(260.48,82.1) 260.74,82.36 262.64,82.36 263.53,81.47 263.53,77.69 263.28,77.43 262.9,77.43 262.54,77.07 262.54,76.57 261.91,75.93 260.89,75.93 260.3,75.34 260.3,74.74 261.65,73.39 261.65,73.07 262.41,72.3 262.41,70.72 261.65,69.96 261.65,69.14 261.33,68.82 260.51,68.82 260.3,68.61 260.3,65.82 260.69,65.43 262.24,65.43 D1410.3
  L5 w0.102: v2(260.43,121.02) 260.43,120.56 258.81,118.93 258.81,115.86 258.53,115.58 258.53,98.56 257.67,97.7 252.69,97.7 251.11,96.12 251.11,93.71 252.76,92.06 254.79,92.06 258.65,88.2 258.65,84.64 260.48,82.81 v2(260.48,82.1) ; v2(146.59,89.65) 148.34,91.4 151.5,91.4 152.69,92.58 v2(152.69,93.2) 152.94,92.95 157.51,92.95 159.34,91.12 161.94,91.12 167.38,96.56 v2(169.86,96.56)
  L6 w0.102: v2(129.95,92.5) 142.91,92.5 145.26,90.16 146.08,90.16 v2(146.59,89.65)
  BOTTOM w0.076: R4714.2 169.78,96.63 v2(169.86,96.56) 169.86,96.35 171.99,94.21 173.71,94.21 174.03,94.53 U4555.AU2
  BOTTOM w0.102: Q112.1 126.06,83.76 127.01,82.81 128.33,82.81 128.56,83.04 128.56,90.03 129.95,91.43 v2(129.95,92.5) ; v2(260.43,121.02) 260,121.02 258.86,122.15 252.26,122.15 251.52,122.9 241.59,122.9 240.45,121.75 208.93,121.75 207.76,120.58 167.04,120.58 157.68,111.22 154.37,111.22 152.05,108.9 152.05,104.61 151.12,103.67 151.12,99.09 152.48,97.72 152.48,96.07 152.69,95.87 v2(152.69,93.2)
WWANSSD_M12DET: length 259.2
  TOP w0.102: v2(154.34,99.78) 153.21,99.78 152.43,98.99 152.43,97.01 152.81,96.63 152.81,94.94 R4918.2
  L3 w0.102: v2(260.76,123.12) 259.96,123.12 256.24,119.41 256.24,113.36 256.45,113.15 258.1,111.5 258.1,109.46 257.59,108.95 256.45,108.95 v2(255.68,108.19)
  L5 w0.102: v2(154.34,99.78) 145.86,99.78 v3(144.3,101.33) ; v2(244.18,67.8) 244.2,67.78 245.36,67.78 245.84,68.26 245.84,69.04 248.28,71.48 248.86,71.48 249.52,71.48 250.14,71.48 253.75,75.09 258.92,75.09 260.15,76.32 260.15,77.34 260.15,78.87 257.51,81.5 257.51,88.98 254.81,91.68 252.76,91.68 250.86,93.58 250.86,96.25 252.53,97.93 257.41,97.93 258.2,98.71 258.2,105.32 255.68,107.83 v2(255.68,108.19)
  L6 w0.102: v2(175.95,94.79) 174.44,94.79 170.46,98.77 162.01,98.77 161.58,99.19 154.93,99.19 v2(154.34,99.78)
  BOTTOM w0.076: U4555.AT5 175.95,94.41 v2(175.95,94.79)
  BOTTOM w0.102: v2(260.76,123.12) 258.06,125.82 240.53,125.82 239.12,124.42 237.35,124.42 235.24,124.42 235.24,124.42 235.18,124.42 229.65,124.42 229.64,124.42 226.43,124.42 208.08,124.42 206.46,122.79 165.55,122.79 158.89,116.14 157.62,114.86 157.01,114.86 153.36,114.86 147.56,109.05 147.56,105.24 146.82,104.51 144.69,104.51 144.3,104.13 v3(144.3,101.33) ; R1409.1 244.72,67.26 v2(244.18,67.8)
XCLK_BIASREF: length 7.1
  BOTTOM w0.076: R4892.1 190.07,70.85 v1(189.26,70.85)
  BOTTOM w0.102: v1(189.26,70.85) 188.65,70.85 188.2,71.3 188.2,72.96 188.66,73.42 188.66,74.28 189.12,74.74 189.12,74.99 188.81,75.29 188.81,75.51 U4555.C26
XDP_DBRESET#: length 196.9
  TOP w0.102: CN4941.13 131.28,80.08 131.28,80.08 131.39,80.08 133.28,78.19 v4(133.28,76.19) ; v4(171.92,86.66) 173.32,88.06 173.32,95.24 172.25,96.32 172.25,97.15 172.24,97.15 172.24,97.47 172.25,97.47 172.25,99.73 172.24,99.73 172.24,100.05 172.25,100.05 172.25,100.76 172.65,101.16 172.65,101.8 171.68,102.76 171.68,104.94 169.21,107.41 v2(169.21,109.27) ; v2(229.65,93.97) 230.03,94.35 232.48,94.35 232.86,93.97 234.03,92.8 234.03,89.31 233.28,88.56 233.28,87.66 233.14,87.52 CN4920.48 229.83,87.52 229.21,88.14 229.21,88.45 R4922.2
  L3 w0.102: v2(229.65,93.97) 228.51,95.11 228.51,96.25 229.65,97.39 229.65,103.29 240.51,114.15 v2(241.41,114.15)
  L5 w0.102: v2(145.5,83.52) 145.52,83.54 148.47,83.54 150.61,85.68 151.95,85.68 152.31,85.33 158.02,85.33 158.53,84.82 160.33,84.82 160.95,85.44 169.36,85.44 169.44,85.52 170.91,85.52 171.92,86.54 v4(171.92,86.66)
  BOTTOM w0.076: U4555.AC3 174.58,86.65 172.01,86.65 172,86.66 v4(171.92,86.66)
  BOTTOM w0.102: v4(133.28,76.19) 133.78,76.68 v1(133.78,77.38) 135.99,79.59 139.2,79.59 139.25,79.64 139.36,79.75 139.5,79.89 142.12,79.89 142.65,79.36 144.41,79.36 144.84,79.79 144.84,82.86 v2(145.5,83.52) ; v2(169.21,109.27) 173.51,113.57 212.09,113.57 212.67,114.15 v2(241.41,114.15)
XDP_RST_R_N: length 3.6
  TOP w0.102: CN4920.46 229.48,87.03 v1(229.14,87.36) 228.64,87.86 R4921.1
XDP_TRST#: length 13.7
  TOP w0.102: CN4920.54 233.16,89.02 233.62,89.48 233.62,91.47 233.16,91.92 231.64,91.92 230.13,93.43 228.78,93.43 v1(228,94.22) 226.72,94.22 226.03,93.52 Q4920.3
XTAL24_IN: length 8.9
  BOTTOM w0.102: X4751.3 189.63,66.95 189.18,67.4 C4828.1 189.18,68.27 R4898.2 189.25,68.49 188.9,68.84 188.9,69.47 v1(189.01,69.58) 189.01,69.71 188.01,70.71 188.01,73.07 188.25,73.31 188.25,73.88 U4555.A25
XTAL24_OUT: length 12.6
  BOTTOM w0.102: X4751.1 187.93,63.78 187.15,64.55 187.15,66.63 187.44,66.91 187.97,66.91 188.43,67.38 C4826.1 188.43,68.29 R4898.1 188.45,68.39 188.45,69.46 v1(187.75,70.15) 187.82,70.22 187.82,73.32 187.88,73.39 187.88,74.17 188.25,74.53 U4555.B25

## Copper pours and planes (outline as drawn)
AGND_AUDIO on TOP: 324.01,117.33 324.64,116.7 324.64,114.41 324.01,113.78 321.98,113.78 320.96,114.79 319.44,114.79 318.93,115.3 318.93,116.44 319.82,117.33
AGND_AUDIO on L2: 291.12,51.04 291.12,56.25 292.39,57.52 293.53,57.52 294.55,56.5 297.97,56.5 299.12,57.64 303.82,57.64 303.82,62.47 302.29,62.47 302.29,63.87 303.31,64.88 304.2,64.88 304.58,65.26 304.58,67.3 303.05,68.82 300.51,68.82 300.39,68.95 300.39,69.96 300.51,70.09 301.78,70.09 302.04,70.34 302.04,71.61 303.44,73.01 309.28,73.01 309.4,72.88 309.4,71.61 309.91,71.11 309.91,67.3 310.29,66.91 311.44,66.91 311.69,66.66 311.69,65.9 311.18,65.39 311.18,63.61 311.31,63.49 311.31,51.04
AGND_AUDIO on L2: 319.82,117.33 324.01,117.33 324.9,116.44 324.9,114.67 324.01,113.78 321.98,113.78 320.96,114.79 319.44,114.79 318.93,115.3 318.93,116.44
AGND_AUDIO on L5: 313.18,64.77 314.24,63.7 311.06,60.51 311.06,59.68 310.8,59.42 309.79,59.42 309.53,59.68 309.53,61.12
AGND_AUDIO on L7: 314.08,12.46 314.08,48.45 311.49,51.04 301.66,51.04 301.66,54.98 301.4,55.23 300.51,55.23 300.39,55.36 300.39,56.37 300.51,56.5 303.44,56.5 304.71,57.77 304.71,62.85 304.2,63.36 304.2,64.88 304.58,65.26 304.58,65.64 304.71,65.77 308.39,65.77 312.96,61.2 312.96,56.5 314.99,54.47 314.99,52.82 315.88,51.93 315.88,16.37 317.66,14.59 328.07,14.59 328.07,3.67 326.3,1.89 314.74,1.89 314.74,11.8
AGND_AUDIO on L7: 285.02,52.69 285.02,56.12 285.78,56.88 286.42,56.88 287.31,57.77 287.31,58.02 287.56,58.28 292.64,58.28 294.42,56.5 295.05,56.5 295.56,55.99 295.56,53.45 295.94,53.07 295.94,51.8 288.58,51.8 288.32,52.06 287.56,52.06 287.31,51.8 287.31,51.04 285.78,51.04 285.78,51.93
AGND_KBC on TOP (solid shape): 284.38,101.71 284.38,100.96 284.77,100.74 284.77,99.81 284,99.81 282.73,101.08 282.73,101.71 282.99,101.97 284.13,101.97
DGND on TOP (solid shape): 270.8,152.89 270.8,151.88 270.54,151.62 268.51,151.62 268.51,153.15 270.54,153.15
DGND on TOP (solid shape): 43.97,82.15 43.97,80.63 43.21,79.87 41.18,79.87 40.93,80.12 40.93,82.15 41.18,82.41 43.72,82.41
DGND on TOP (solid shape): 100.87,135.49 100.87,132.57 100.62,132.32 98.58,132.32 98.33,132.57 98.33,135.49 98.58,135.75 100.62,135.75
DGND on TOP (solid shape): 110.01,136 110.01,133.08 109.76,132.83 108.62,132.83 108.36,133.08 108.36,135.88 108.62,136.13 109.89,136.13
DGND on TOP (solid shape): 121.83,88 121.83,85.84 121.57,85.58 120.56,85.58 120.3,85.84 120.3,87.87 120.68,88.25 121.57,88.25
DGND on TOP (solid shape): 196.25,56.88 196.25,54.6 195.99,54.34 193.07,54.34 192.95,54.47 192.95,56.88 193.2,57.14 195.99,57.14
DGND on TOP (solid shape): 209.33,153.81 209.33,151.88 209.07,151.62 205.32,151.62 205.07,151.88 205.07,153.81 205.32,154.06 209.07,154.06
DGND on TOP (solid shape): 225.26,156.4 225.26,153.12 225,152.86 223.37,152.86 223.12,153.12 223.12,156.65 223.43,156.96 224.7,156.96
DGND on TOP (solid shape): 261.4,57.77 261.4,52.82 261.14,52.56 259.11,52.56 258.86,52.82 258.86,57.77 259.11,58.02 261.14,58.02
DGND on TOP (solid shape): 263.05,80.76 263.05,78.47 262.67,78.09 260.13,78.09 259.75,78.47 259.75,80.38 260.51,81.14 262.67,81.14
DGND on TOP (solid shape): 272.07,149.46 272.07,147.69 271.69,147.31 265.21,147.31 264.83,147.69 264.83,149.46 265.08,149.72 271.81,149.72
DGND on TOP (solid shape): 283.88,76.06 283.88,71.61 283.62,71.36 282.1,71.36 281.85,71.61 281.85,76.06 282.1,76.31 283.62,76.31
DGND on TOP (solid shape): 286.67,62.85 286.67,61.33 286.42,61.07 284.64,61.07 284.39,61.33 284.39,62.85 284.64,63.1 286.42,63.1
DGND on TOP (solid shape): 305.72,83.93 305.72,81.9 305.47,81.65 302.8,81.65 302.55,81.9 302.55,83.93 302.8,84.19 305.47,84.19
DGND on TOP (solid shape): 134.65,73.14 134.65,71.23 134.27,70.85 133.13,70.85 132.87,71.11 132.87,73.39 133,73.52 134.27,73.52
DGND on TOP (solid shape): 188.88,56.88 188.88,55.1 188.63,54.85 185.96,54.85 185.71,55.1 185.71,56.88 185.96,57.14 188.63,57.14
DGND on TOP (solid shape): 287.05,52.31 287.05,51.17 286.93,51.04 284.64,51.04 284.51,51.17 284.51,52.31 285.15,52.94 286.42,52.94
DGND on TOP (solid shape): 290.23,90.92 290.23,89.65 290.1,89.52 289.34,89.52 289.21,89.65 289.21,90.92 289.34,91.04 290.1,91.04
DGND on TOP (solid shape): 37.24,84.57 37.24,79.74 36.99,79.49 35.97,79.49 35.72,79.74 35.72,81.9 35.47,82.15 35.47,84.57 35.72,84.82 36.99,84.82
DGND on TOP (solid shape): 99.47,87.87 99.47,85.71 99.22,85.46 97.31,85.46 97.06,85.71 97.06,88.63 97.44,89.01 98.33,89.01
DGND on TOP (solid shape): 101.12,148.58 101.12,144.26 99.6,144.26 99.6,146.92 99.35,147.18 99.35,148.58 99.6,148.83 100.87,148.83
DGND on TOP (solid shape): 228.76,144.64 228.76,144.26 229.14,143.88 229.14,142.99 229.01,142.86 228.25,142.86 228.12,142.99 228.12,144.64 228.25,144.77 228.63,144.77
DGND on TOP (solid shape): 241.59,57.64 241.59,53.2 241.33,52.94 239.17,52.94 238.92,53.2 238.92,53.83 238.41,54.34 238.41,57.52 238.79,57.9 241.33,57.9
DGND on TOP (solid shape): 267.75,76.06 267.75,73.26 267.24,72.76 267.24,71.23 266.86,70.85 265.84,70.85 265.59,71.11 265.59,76.06 265.84,76.31 267.49,76.31
DGND on TOP (solid shape): 294.55,123.81 294.55,123.43 293.78,122.67 293.78,122.29 293.66,122.16 292.64,122.16 292.51,122.29 292.51,123.43 293.15,124.06 294.29,124.06
DGND on TOP (solid shape): 328.94,24.95 328.94,14.72 320.83,14.72 319.56,15.99 319.56,21.7 319.95,22.08 325.79,22.08 325.79,25 326.1,25.31 328.58,25.31
DGND on TOP (solid shape): 226.73,144.64 226.73,142.99 226.6,142.86 225.71,142.86 225.58,142.99 225.58,144.64 225.71,144.77 226.6,144.77
DGND on TOP (solid shape): 316.64,76.06 316.64,74.41 316.39,74.15 315.25,74.15 314.99,73.9 313.47,73.9 313.21,74.15 313.21,75.93 313.6,76.31 316.39,76.31
DGND on TOP (solid shape): 230.28,81.52 230.28,78.47 230.03,78.22 229.14,78.22 228.38,78.98 228.38,80.38 228.63,80.63 228.76,80.63 229.01,80.88 229.01,81.52 229.27,81.77 230.03,81.77
DGND on TOP (solid shape): 297.97,84.57 297.97,82.66 298.48,82.15 298.48,81.77 297.97,81.27 295.56,81.27 294.93,81.9 294.93,84.57 295.18,84.82 297.72,84.82
DGND on TOP (solid shape): 307.88,117.46 307.88,116.19 307.75,116.06 306.74,116.06 306.48,116.32 306.48,116.7 305.72,117.46 304.07,117.46 303.82,117.71 303.82,118.35 304.2,118.73 306.61,118.73
DGND on TOP (solid shape): 253.4,84.95 253.91,84.95 254.03,84.82 254.03,83.17 253.91,83.04 253.14,83.04 252.51,83.68 252.51,84.44 252.13,84.82 252.13,85.08 252.38,85.33 253.02,85.33
DGND on TOP (solid shape): 286.04,102.09 286.04,100.44 285.78,100.19 285.28,100.19 285.15,100.32 285.15,100.7 285.15,100.81 284.64,101.11 284.64,102.09 284.89,102.35 285.78,102.35
DGND on TOP (solid shape): 227.24,70.09 227.24,68.44 228.76,66.91 229.01,66.91 229.27,66.66 231.05,66.66 231.43,66.28 231.43,62.47 230.16,61.2 226.47,61.2 226.09,61.58 226.09,68.06 225.46,68.69 224.57,68.69 224.44,68.82 224.44,69.33 224.31,69.45 223.17,69.45 223.17,69.71 223.55,70.09 225.2,70.09 225.6,70.49 226.84,70.49
DGND on TOP (solid shape): 205.9,87.36 205.9,79.23 205.52,78.85 201.96,78.85 201.33,78.22 199.8,78.22 199.68,78.34 199.68,79.74 199.17,80.25 197.26,80.25 196.76,79.74 196.76,78.6 196.5,78.34 194.98,78.34 194.85,78.47 194.85,81.01 194.6,81.27 192.31,81.27 192.06,81.52 192.06,84.44 192.69,85.08 196.88,85.08 197.52,85.71 197.52,87.36 197.9,87.74 205.52,87.74
DGND on TOP (solid shape): 50.83,77.81 46.15,77.81 44.73,77.22 44.14,75.8 44.14,64.88 43.47,64.88 43.47,76.69 45.24,78.47 50.83,78.47
DGND on TOP (solid shape): 327.83,156.07 327.96,155.66 327.85,155.66 326.19,154 327.85,152.34 328.02,152.34 328.21,152.3 328.36,152.19 326.37,152.19 326.27,152.09 325.49,154.76 327.69,156.47
DGND on TOP (solid shape): 327.64,156.58 327.81,156.12 327.96,155.66 327.85,155.66 326.19,154 327.85,152.34 328.35,152.34 328.7,151.73 329.35,151.49 329.44,151.49 329.44,150.66 325.93,150.66 325.93,150.85 325.64,151.56 324.93,151.86 323.88,151.86 323.16,151.56 322.87,150.85 322.87,150.66 318.2,150.66 317.79,150.6 317.41,150.43 316.88,149.88 316.69,149.15 316.69,148.7 315.63,148.7 315.63,150.23 317.02,151.62 322.23,151.62 322.99,152.39 323.88,152.39 324.52,153.02 324.52,155.18 325.91,156.58
DGND on TOP (solid shape): outline of 259 points within 30.37,49.65 41.04,64.36
DGND on BOTTOM (solid shape): 138.97,77.58 138.84,77.46 136.94,77.46 136.81,77.58 136.81,78.98 138.97,78.98
DGND on BOTTOM (solid shape): 249.59,54.47 249.21,54.09 246.54,54.09 246.29,54.34 246.29,55.99 246.54,56.25 249.59,56.25
DGND on BOTTOM (solid shape): 299.88,52.06 299.88,51.42 299.75,51.29 296.7,51.29 296.7,51.93 296.96,52.18 299.75,52.18
DGND on BOTTOM (solid shape): 101.89,147.94 101.89,144.13 101.63,143.88 99.09,143.88 98.84,144.13 98.84,147.94 99.09,148.19 101.63,148.19
DGND on BOTTOM (solid shape): 104.3,135.11 104.3,133.72 104.05,133.46 102.9,133.46 102.39,133.97 102.39,135.11 102.65,135.37 104.05,135.37
DGND on BOTTOM (solid shape): 111.03,152.13 111.03,148.96 110.78,148.7 107.47,148.7 107.09,149.08 107.09,152.13 107.35,152.39 110.78,152.39
DGND on BOTTOM (solid shape): 111.28,161.15 111.28,158.86 111.03,158.61 107.47,158.61 107.22,158.86 107.22,161.02 107.6,161.4 111.03,161.4
DGND on BOTTOM (solid shape): 112.81,129.02 112.81,127.62 112.43,127.24 108.49,127.24 108.11,127.62 108.11,129.14 108.36,129.4 112.43,129.4
DGND on BOTTOM (solid shape): 119.41,83.3 119.41,82.28 119.16,82.03 117,82.03 116.75,82.28 116.75,83.42 116.87,83.55 119.16,83.55
DGND on BOTTOM (solid shape): 251.24,161.15 251.24,158.86 250.86,158.48 246.54,158.48 246.16,158.86 246.16,161.15 246.54,161.53 250.86,161.53
DGND on BOTTOM (solid shape): 289.72,129.02 289.72,125.72 289.47,125.46 286.16,125.46 285.91,125.72 285.91,129.02 286.16,129.27 289.47,129.27
DGND on BOTTOM (solid shape): 294.29,111.49 294.29,109.21 293.91,108.82 291.62,108.82 291.24,109.21 291.24,111.49 291.62,111.87 293.91,111.87
DGND on BOTTOM (solid shape): 316.01,139.94 316.01,137.4 315.75,137.15 312.71,137.15 312.07,137.78 312.07,140.7 312.45,141.08 314.87,141.08
DGND on BOTTOM (solid shape): 316.9,131.43 316.9,129.91 316.64,129.65 312.83,129.65 312.58,129.91 312.58,131.43 312.83,131.68 316.64,131.68
DGND on BOTTOM (solid shape): 173.51,149.72 173.51,149.21 173.26,148.96 171.74,148.96 171.61,149.08 171.61,149.85 171.74,149.97 173.26,149.97
DGND on BOTTOM (solid shape): 205.9,68.95 205.9,62.98 205.65,62.72 204.12,62.72 203.87,62.98 203.87,68.95 203.99,69.07 205.77,69.07
DGND on BOTTOM (solid shape): 303.56,62.22 303.56,58.15 303.31,57.9 299.5,57.9 299.37,58.02 299.37,62.22 299.63,62.47 303.31,62.47
DGND on BOTTOM (solid shape): 321.47,41.77 321.47,39.99 321.22,39.74 319.18,39.74 318.93,39.99 318.93,41.64 319.18,41.9 321.34,41.9
DGND on BOTTOM (solid shape): 37.24,83.17 37.24,79.74 36.99,79.49 36.1,79.49 35.72,79.87 35.72,83.17 35.97,83.42 36.99,83.42
DGND on BOTTOM (solid shape): 109.76,124.57 109.76,120.51 109.38,120.13 107.47,120.13 106.46,121.14 106.46,124.57 106.71,124.83 109.51,124.83
DGND on BOTTOM (solid shape): 112.55,104.51 112.55,103.11 112.17,102.73 108.74,102.73 108.49,102.98 108.49,104.51 108.74,104.76 112.3,104.76
DGND on BOTTOM (solid shape): 139.48,65.64 139.48,63.36 139.1,62.98 136.68,62.98 136.3,63.36 136.3,65.64 136.56,65.9 139.22,65.9
DGND on BOTTOM (solid shape): 171.74,157.59 171.74,156.2 171.61,156.07 170.59,156.07 170.47,156.2 170.47,157.59 170.72,157.85 171.23,157.85 171.48,157.85
DGND on BOTTOM (solid shape): 249.33,87.74 249.33,85.2 249.08,84.95 246.54,84.95 246.29,85.2 246.29,87.11 246.54,87.36 247.56,87.36 248.19,88 249.08,88
DGND on BOTTOM (solid shape): 249.46,77.71 249.46,75.68 249.21,75.42 248.83,75.42 248.57,75.68 246.79,75.68 246.67,75.8 246.67,77.71 246.92,77.96 249.21,77.96
DGND on BOTTOM (solid shape): 328.94,25.07 328.94,14.72 320.83,14.72 319.56,15.99 319.56,21.7 319.95,22.08 325.79,22.08 325.79,25 326.1,25.31 328.69,25.31
DGND on BOTTOM (solid shape): 140.37,92.06 140.37,91.04 140.11,90.79 137.57,90.79 137.07,91.3 136.05,91.3 135.8,91.43 135.8,92.19 135.92,92.31 140.11,92.31
DGND on BOTTOM (solid shape): 201.07,68.95 201.07,62.98 200.82,62.72 199.3,62.72 199.04,62.98 199.04,68.95 199.17,69.07 200.95,69.07
DGND on BOTTOM (solid shape): 246.79,80 246.79,78.22 246.41,77.84 246.41,76.57 246.16,76.31 244.89,76.31 244.63,76.57 244.63,80 245.02,80.38 246.41,80.38
DGND on BOTTOM (solid shape): 305.85,104.51 305.85,103.24 305.72,103.11 303.18,103.11 302.67,102.6 301.66,102.6 301.4,102.86 301.4,104.51 301.66,104.76 305.59,104.76
DGND on BOTTOM (solid shape): 110.14,84.31 110.14,82.92 109.89,82.66 107.22,82.66 106.97,82.92 106.97,84.44 107.09,84.57 109.89,84.57
DGND on BOTTOM (solid shape): 140.11,82.54 140.11,82.28 139.48,81.65 138.72,81.65 138.46,81.39 137.57,81.39 137.45,81.52 137.45,82.28 137.57,82.41 139.1,82.41 139.48,82.79 139.86,82.79
DGND on BOTTOM (solid shape): 191.04,127.24 194.72,127.24 196.25,128.76 201.33,128.76 204.5,125.59 204.5,124.57 204.12,124.19 168.82,124.19 168.43,124.57 168.43,126.6 170.72,128.89 189.39,128.89
DGND on BOTTOM (solid shape): 210.73,68.18 210.73,62.98 210.47,62.72 208.95,62.72 208.69,62.98 208.69,68.44 208.82,68.57 210.34,68.57
DGND on BOTTOM (solid shape): 251.24,152.26 251.24,150.23 250.73,149.72 247.56,149.72 247.17,150.1 247.17,152.26 247.43,152.51 250.98,152.51
DGND on BOTTOM (solid shape): 303.05,83.55 304.83,83.55 304.96,83.42 304.96,81.39 304.71,81.14 300.13,81.14 299.88,81.39 299.88,82.54 300.13,82.79 300.51,82.79 301.66,83.93 302.67,83.93
DGND on BOTTOM (solid shape): 325.28,38.21 325.28,37.7 325.66,37.32 325.91,37.32 326.3,36.94 326.3,36.43 325.91,36.05 324.64,36.05 323.76,36.94 323.76,38.21 323.88,38.34 325.15,38.34
DGND on BOTTOM (solid shape): 110.01,111.87 110.01,109.59 110.27,109.33 110.27,107.05 110.14,106.92 107.86,106.92 107.6,107.17 107.6,111.87 107.86,112.13 109.76,112.13
DGND on BOTTOM (solid shape): 140.37,100.32 140.37,92.82 140.11,92.57 137.83,92.57 137.7,92.7 137.7,100.32 137.95,100.57 140.11,100.57
DGND on BOTTOM (solid shape): 317.53,110.98 317.53,109.46 316.26,108.19 312.58,108.19 312.45,108.32 312.45,109.97 312.71,110.22 316.14,110.22 316.39,110.48 316.39,110.98 316.64,111.24 317.28,111.24
DGND on BOTTOM (solid shape): 267.49,136.64 267.49,124.06 266.48,123.05 264.57,123.05 263.43,124.19 261.65,124.19 261.65,128.76 262.29,128.76 262.67,129.14 262.67,129.4 262.92,129.65 264.19,129.65 264.57,130.03 264.57,136.64 264.95,137.02 267.11,137.02
DGND on BOTTOM (solid shape): 278.42,122.41 278.42,118.98 278.54,118.86 278.54,117.21 277.02,115.68 274.99,115.68 274.86,115.81 274.86,118.73 274.99,118.86 275.75,118.86 276,118.6 276.77,118.6 277.27,119.11 277.27,120.25 277.02,120.51 276,120.51 276,122.41 276.26,122.67 278.16,122.67
DGND on BOTTOM (solid shape): 49.94,77.81 46.15,77.81 44.73,77.22 44.14,75.8 44.14,64.88 42.58,64.88 42.58,76.06 44.99,78.47 49.94,78.47
DGND on BOTTOM (solid shape): 327.83,156.07 327.96,155.66 327.85,155.66 326.19,154 327.85,152.34 328.02,152.34 328.21,152.3 328.36,152.19 326.37,152.19 326.27,152.09 325.49,154.76 327.69,156.47
DGND on BOTTOM (solid shape): 327.64,156.58 327.81,156.12 327.96,155.66 327.85,155.66 326.19,154 327.85,152.34 328.35,152.34 328.7,151.73 329.35,151.49 329.44,151.49 329.44,150.66 325.93,150.66 325.93,150.85 325.64,151.56 324.93,151.86 323.88,151.86 323.16,151.56 322.87,150.85 322.87,150.66 318.2,150.66 317.79,150.6 317.41,150.43 316.88,149.88 316.69,149.15 316.69,148.7 314.99,148.7 314.99,150.99 317.41,153.4 319.31,153.4 320.33,152.39 323.88,152.39 324.52,153.02 324.52,155.18 325.91,156.58
DGND on BOTTOM (solid shape): outline of 261 points within 30.37,49.65 41.04,64.36
DGND on L2 (solid shape): 236.89,54.09 233.97,54.09 232.44,52.56 231.68,52.56 231.68,54.98 236.89,54.98
DGND on L3 (solid shape): 43.97,82.15 43.97,80.76 43.59,80.38 41.43,80.38 41.05,80.76 41.05,82.15 41.31,82.41 43.72,82.41
DGND on L3 (solid shape): 87.04,88.12 87.04,85.47 86.14,84.57 82.96,84.57 82.69,84.84 82.69,88.12 83.07,88.5 86.66,88.5
DGND on L3 (solid shape): 101.89,147.94 101.89,144.13 101.63,143.88 99.09,143.88 98.84,144.13 98.84,147.94 99.09,148.19 101.63,148.19
DGND on L3 (solid shape): 209.33,153.81 209.33,151.88 209.07,151.62 205.32,151.62 205.07,151.88 205.07,153.81 205.32,154.06 209.07,154.06
DGND on L3 (solid shape): 225.26,156.4 225.26,153.12 225,152.86 223.37,152.86 223.12,153.12 223.12,156.65 223.43,156.96 224.7,156.96
DGND on L3 (solid shape): 249.33,87.74 249.33,85.84 249.08,85.58 246.54,85.58 246.29,85.84 246.29,87.74 246.54,88 249.08,88
DGND on L3 (solid shape): 267.75,76.06 267.75,72.12 267.49,71.87 265.59,71.87 265.34,72.12 265.34,76.06 265.59,76.31 267.49,76.31
DGND on L3 (solid shape): 283.88,76.06 283.88,71.11 283.5,70.72 282.1,70.72 281.85,70.98 281.85,76.06 282.1,76.31 283.62,76.31
DGND on L3 (solid shape): 289.72,129.02 289.72,125.72 289.47,125.46 286.16,125.46 285.91,125.72 285.91,129.02 286.16,129.27 289.47,129.27
DGND on L3 (solid shape): 294.16,111.62 294.16,109.08 293.91,108.82 291.62,108.82 291.24,109.21 291.24,111.49 291.62,111.87 293.91,111.87
DGND on L3 (solid shape): 302.04,62.22 303.56,62.22 303.56,57.9 299.24,57.9 299.01,58.13 299.01,62.25 299.26,62.5 302.04,62.5
DGND on L3 (solid shape): 232.44,82.03 232.44,81.01 230.28,78.85 229.27,78.85 229.01,79.11 229.01,81.9 229.39,82.28 232.19,82.28
DGND on L3 (solid shape): 322.99,41.26 322.99,39.86 322.61,39.48 319.82,39.48 319.56,39.23 318.29,39.23 318.04,39.48 318.04,41.13 318.55,41.64 318.8,41.64 319.06,41.9 322.36,41.9
DGND on L3 (solid shape): 44.5,76.94 44.23,76.4 44.14,75.8 44.14,64.88 41.94,64.88 41.94,77.71 44.5,77.71
DGND on L4 (solid shape): 303.69,62.09 303.69,58.02 303.44,57.77 299.37,57.77 299.12,58.02 299.12,62.09 299.37,62.34 303.44,62.34
DGND on L5 (solid shape): 43.97,82.15 43.97,80.38 43.34,79.74 41.31,79.74 40.93,80.12 40.93,82.15 41.18,82.41 43.72,82.41
DGND on L5 (solid shape): 87.04,88.6 87.04,85.47 86.14,84.57 82.96,84.57 82.69,84.84 82.69,88.62 82.95,88.89 86.75,88.89
DGND on L5 (solid shape): 101.89,147.94 101.89,144.13 101.63,143.88 99.09,143.88 98.84,144.13 98.84,147.94 99.09,148.19 101.63,148.19
DGND on L5 (solid shape): 209.33,153.81 209.33,151.88 209.07,151.62 205.32,151.62 205.07,151.88 205.07,153.81 205.32,154.06 209.07,154.06
DGND on L5 (solid shape): 225.26,156.4 225.26,153.12 225,152.86 223.37,152.86 223.12,153.12 223.12,156.65 223.43,156.96 224.7,156.96
DGND on L5 (solid shape): 232.44,81.27 232.44,78.47 232.19,78.22 229.14,78.22 228.63,78.73 228.63,82.03 228.89,82.28 231.43,82.28
DGND on L5 (solid shape): 249.33,87.74 249.33,85.2 249.08,84.95 246.54,84.95 246.29,85.2 246.29,87.74 246.54,88 249.08,88
DGND on L5 (solid shape): 267.49,76.06 267.49,72.12 267.11,71.74 265.97,71.74 265.72,71.99 265.72,76.06 265.97,76.31 267.24,76.31
DGND on L5 (solid shape): 283.88,76.06 283.88,70.47 283.62,70.22 282.1,70.22 281.85,70.47 281.85,76.06 282.1,76.31 283.62,76.31
DGND on L5 (solid shape): 289.72,129.02 289.72,125.72 289.47,125.46 286.16,125.46 285.91,125.72 285.91,129.02 286.16,129.27 289.47,129.27
DGND on L5 (solid shape): 294.29,111.49 294.29,109.21 293.91,108.82 291.62,108.82 291.24,109.21 291.24,111.49 291.62,111.87 293.91,111.87
DGND on L5 (solid shape): 276,62.6 276,58.02 275.75,57.77 273.59,57.77 273.34,58.02 273.34,62.47 273.72,62.85 275.75,62.85
DGND on L5 (solid shape): 303.76,62.25 303.76,57.92 303.51,57.66 299.63,57.66 299.37,57.92 299.37,62.22 299.66,62.5 303.51,62.5
DGND on L5 (solid shape): 322.99,41.26 322.99,39.86 322.61,39.48 319.82,39.48 319.56,39.23 318.8,39.23 318.04,39.99 318.04,41.13 318.55,41.64 318.8,41.64 319.06,41.9 322.36,41.9
DGND on L6 (solid shape): 43.97,82.15 43.97,80.38 43.34,79.74 41.31,79.74 40.93,80.12 40.93,82.15 41.18,82.41 43.72,82.41
DGND on L6 (solid shape): 87.04,88.6 87.04,85.47 86.14,84.57 82.96,84.57 82.69,84.84 82.69,88.62 82.95,88.89 86.75,88.89
DGND on L6 (solid shape): 101.89,147.94 101.89,144.13 101.63,143.88 99.09,143.88 98.84,144.13 98.84,147.94 99.09,148.19 101.63,148.19
