# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SLP_S3#_3R_DOCK: length 18.1
  TOP w0.102: R3600.2 312.24,117.71 v1(312.58,117.71) 313.77,117.71 315.37,119.32 315.37,123.3 316.64,124.57 318.27,124.57 318.93,123.91 320.39,123.91 322.68,126.2 CN3601.40
SLP_S3#_3R_KBC: length 3.5
  TOP w0.102: U300.81 269.68,109.69 269.75,109.61 269.75,108.82 v2(269.31,108.38)
  BOTTOM w0.102: R398.2 269.7,107.99 v2(269.31,108.38)
SLP_S3_5R: length 450.3
  TOP w0.102: v2(305.93,121.31) 306.94,121.31 R7005.2 308.71,120.49 Q7002.3 ; Q7155.1 167.53,145.77 169.2,147.43 v2(169.2,147.94) ; v2(237.52,95.11) 241.19,95.11 241.87,94.44 241.87,91.91 Q1402.1 241.54,91.81 235.52,91.81 233.11,94.22 232.63,94.7 226.24,94.7 225.71,95.24 225.71,98.21 226.74,99.23 Q1003.1 ; Q1302.5 312.17,110.98 311.69,110.5 311.69,108.82 310.93,108.06 306.89,108.06 305.6,106.78 Q7101.1 305.77,108.04 305.77,111.74 v2(304.93,112.58)
  L3 w0.102: v2(169.2,147.94) 169.07,147.81 157.42,147.81 155.84,146.23 132.32,146.23 131.71,145.63 120.79,145.63 116.57,141.41 116.57,131.86 119.61,128.82 119.61,119.66 116.34,116.39 116.34,105.58 116.55,105.37 117.3,104.61 117.3,100.65 119.67,98.28 119.67,95.72 v3(119.79,95.59)
  L5 w0.102: v2(188.12,150.86) 187.36,150.86 185.58,149.08 176.92,149.08 176.54,148.7 169.96,148.7 v2(169.2,147.94) ; v2(304.93,112.58) 304.93,114.46 305.93,115.46 v2(305.93,121.31)
  L6 w0.102: v2(305.93,121.31) 304.92,121.31 294.68,131.55 287.83,131.55 287.21,132.16 287,132.37 284.76,132.37 284.11,133.03 282.98,133.03 280.06,135.94 280.06,137.21 274.05,143.22 274.05,143.22 273.84,143.43 265.69,143.43 262.78,146.34 255.18,146.34 253.28,148.24 246.7,148.24 245.12,149.82 245.12,158.68 242.81,161 233.75,161 232,159.24 221.77,159.24 217.96,155.43 214.79,155.43 210.73,151.37 202.72,151.37 201.96,150.61 188.37,150.61 v2(188.12,150.86) ; v2(237.52,95.11) 237.93,95.51 241.48,95.51 242.42,94.57 243.91,94.57 244.32,94.98 245.07,94.98 246.41,96.32 246.41,100.42 247.3,101.31 248.19,101.31 252.13,105.25 252.13,105.4 259.11,112.38 262.54,112.38 263.56,111.36 267.62,111.36 270.03,113.78 273.4,113.78 v2(274.31,114.69)
  BOTTOM w0.102: Q7051.5 118.9,86.96 119.43,86.43 120.05,86.43 ; 120.05,86.43 120.05,86.43 120.05,88.38 118.9,89.52 Q7051.2 ; 120.05,86.43 124.19,86.43 125.13,87.36 125.13,90.1 Q7154.1 126.7,90.03 127.67,90.03 128.81,91.17 128.81,92.97 128.23,93.56 126.93,93.56 126.19,92.82 122.97,92.82 122.08,93.71 122.08,94.51 121.72,94.87 121.49,94.87 120.78,95.59 v3(119.79,95.59) ; v2(274.31,114.69) 274.42,114.59 276.84,114.59 277.53,113.9 286.05,113.9 291,118.86 297.21,118.86 298.03,118.03 301.34,118.03 303.31,116.07 303.31,114.21 v2(304.93,112.58)
SLP_S4#_3R: length 347.5
  TOP w0.102: v2(211.36,148.19) 211.11,147.94 R7023.1 ; v2(143.42,96.73) 143.14,96.45 143.14,87.84 142.05,86.76 142.05,86.3 v2(142.38,85.97) ; CN4941.5 131.84,76.08 v2(131.86,76.06)
  L3 w0.102: v2(41.77,78.49) 42.18,78.08 43.8,78.08 43.96,78.24 50.48,78.24 54.44,82.2 68.8,82.2 70.29,80.71 71.34,80.71 72.51,79.54 104.67,79.54 104.96,79.54 105.7,80.27 105.7,81.69 106.2,82.2 110.6,82.2 112.73,80.08 113.72,79.08 124.18,79.08 124.81,78.46 128.26,78.46 128.65,78.06 129.85,78.06 v2(131.86,76.06) ; v2(143.42,96.73) 140.87,94.19 136.41,94.19 136.01,93.79 122.79,93.79 120.02,96.56 120.02,98.44 117.66,100.8 117.66,104.76 116.69,105.72 116.69,116.24 120,119.54 120,129.35 116.92,132.42 116.92,141.26 120.94,145.27 131.86,145.27 132.46,145.88 155.98,145.88 157.46,147.36 180.49,147.36 v2(181.17,148.03)
  L6 w0.102: v2(211.36,148.19) 210.47,147.31 205.65,147.31 205.39,147.56 187.99,147.56 187.52,148.03 v2(181.17,148.03) ; v2(176.52,90.14) 176.21,89.84 174.22,89.84 173.53,90.53 171.8,90.53 170.32,92.01 166.22,92.01 164.6,93.63 158.99,93.63 158.35,94.27 158.35,95.51 156.8,97.06 155.12,97.06 153.93,95.87 149.21,95.87 148.7,96.38 143.77,96.38 v2(143.42,96.73)
  BOTTOM w0.076: v2(176.52,90.14) 176.82,89.84 U4555.AJ6
  BOTTOM w0.102: v2(41.77,78.49) 41.77,78.51 42.23,78.96 U2511.7 ; v2(181.17,148.03) 180.67,148.53 R7118.1 ; v2(142.38,85.97) 142.02,85.61 142.02,83.85 140.7,82.53 140.7,81.91 139.75,80.96 139.05,80.96 138.76,80.66 135.16,80.66 131.91,77.4 131.91,76.11 v2(131.86,76.06) ; R4588.1 143.54,99.98 143.54,99.33 v1(143.33,99.13) 143.9,98.56 143.9,97.22 v2(143.42,96.73)
SLP_S4#_KBC: length 347.8
  TOP w0.102: v2(309.05,125.94) 309.71,126.6 311.44,126.6 312.35,125.69 315.4,125.69 316.16,124.93 319.92,124.93 v1(321.09,126.1) 321.13,126.14 C3602.1 322.1,126.99 322.39,126.7 CN3601.41 ; v2(291.67,99.01) 291.67,98.84 290.38,97.55 289.49,97.55 287.05,95.11 v2(282.86,95.11) R301.2 ; R2594.1 262.97,64.37 262.46,64.88 261.14,64.88 260.89,64.63 260.89,64.46 R2592.1 259.98,64.37 258.86,63.26 258.86,59.92 257.72,58.78 257.72,52.99 257.01,52.29 252.02,52.29 251.31,52.99 251.31,57.31 252.02,58.02 252.02,70.35 249.84,72.53 v2(249.84,73.21)
  L5 w0.102: v2(261.02,125.97) 261.55,125.44 261.55,120.1 260.19,118.75 260.19,115.58 260.19,112.88 261.27,111.8 261.27,111.17 262.83,109.62 262.83,108.41 264.07,107.17 265.27,107.17 269.81,102.64 269.87,102.64 274.23,98.28 v2(274.48,98.28) 275.82,96.94 281.03,96.94 v2(282.86,95.11) ; v2(309.05,125.94) 308.9,126.1 306.17,126.1 304.07,123.99 304.07,123.39 304.45,123.01 304.45,120.89 305.22,120.12 305.22,116.45 303.89,115.12 303.89,109.26 299.29,104.66 298.22,104.66 297.48,103.92 297.48,102.81 297.71,102.58 297.71,99.05 296.95,98.28 292.4,98.28 v2(291.67,99.01)
  L6 w0.102: v2(274.48,98.28) 274.48,96.63 273.34,95.49 270.67,95.49 269.02,97.14 262.03,97.14 261.14,96.25 261.14,92.21 257.01,88.08 257.01,77.12 252.4,72.5 250.35,72.5 249.84,73.01 v2(249.84,73.21)
  BOTTOM w0.102: R4588.2 142.48,100.53 143.03,101.08 143.03,102.35 142.4,102.98 142.4,107.05 152.4,117.04 156.71,117.04 170.02,130.36 189.96,130.36 191.62,128.7 193.81,128.7 193.81,128.7 194.11,128.7 195.64,130.23 201.85,130.23 205.47,126.6 228.45,126.6 236.15,126.6 238.03,126.6 240.01,128.59 244.25,128.59 245.21,127.62 259.2,127.62 260.85,125.97 v2(261.02,125.97)
SLP_S5#_3R: length 63.6
  TOP w0.102: v2(131.1,72.88) 131.13,72.88 131.93,73.68 131.93,75.35 131.7,75.58 CN4941.4
  L5 w0.076: v2(175.96,92.75) 174.59,92.75 174.15,92.31 174.15,91.3 172.37,89.52 172.37,89.01
  L5 w0.102: v2(141.76,82.38) 141.76,83.93 142.47,84.64 144.18,84.64 144.9,83.92 145.67,83.92 145.69,83.9 148.32,83.9 151.02,86.6 153.27,86.6 153.52,86.35 155.79,86.35 156.45,85.68 158.39,85.68 158.5,85.8 169.36,85.8 169.53,85.97 170.51,85.97 172.37,87.83 172.37,89.01
  BOTTOM w0.076: U4555.AP5 176.3,92.75 v2(175.96,92.75)
  BOTTOM w0.102: v2(131.1,72.88) v1(131.86,73.65) 132.85,74.64 132.85,76.61 133.26,77.01 133.26,77.58 135.62,79.94 139.05,79.94 139.35,80.25 140.36,80.25 141.76,81.65 v2(141.76,82.38)
SLP_SUS#: length 17.4
  BOTTOM w0.076: U4555.AP4 175.19,92.77 174.72,92.77 174.68,92.8 173.21,92.8 173.12,92.89 173.08,92.89
  BOTTOM w0.102: 173.08,92.89 169.67,92.89 169.28,93.28 168.61,93.28 v1(168.43,93.46) 168.31,93.33 166.4,93.33 164.88,94.85 162.08,94.85 161.45,95.49 161.45,96.25 161.7,96.51 R4860.1
SLPSUS#_EC: length 4.5
  TOP w0.102: R352.1 258.99,109.5 258.99,108.78 R326.1 259.52,108.7 v1(259.67,108.54) 259.67,108.53 260.31,107.88 260.92,107.88 261.07,107.73 U300.100
SP_CLK: length 166.5
  TOP w0.114: R387.1 281.39,110.98 279.46,109.05 279.46,108.5 279.44,108.48 278.7,107.73 U300.61 274.04,107.73 272.59,106.28 272.59,105.6 269.43,102.44 269.43,100.98 268.51,100.06 268.51,99.47 v2(268.49,99.47) ; CN202.5 190.8,57.4 190.66,57.26 190.66,54.21 190.18,53.73 v1(184.06,53.73) 182.25,53.73 180.63,55.36 180.63,60.08 v2(181.34,60.79)
  L5 w0.114: v2(181.34,60.79) 185.47,60.79 186.69,59.57 197.05,59.57 198.35,58.27 221.01,58.27 222.55,59.8 229.07,59.8 229.38,59.8 229.83,60.25 250.8,60.25 251.31,60.76 251.44,60.89 254.11,60.89 257.54,64.32 260.15,64.32 263.61,67.78 264.25,67.78 268.56,72.1 268.56,77.07 269.45,77.96 269.45,78.55 270.59,79.68 270.59,86.47 267.44,89.62 267.44,98.38 268.51,99.45 268.51,99.47 v2(268.49,99.47)
SP_DATA: length 170.2
  TOP w0.114: R388.1 v1(282.23,111.87) 281.62,111.87 279.08,109.33 279.08,108.65 278.56,108.13 U300.62 273.92,108.13 272.22,106.43 272.22,105.75 269.02,102.55 269.02,101.09 267.86,99.93 v2(266.69,99.93) ; CN202.4 191.3,54.7 v2(191.17,54.57) ; v2(179.77,54.39) 180.25,54.87 180.25,60.34 v2(180.73,60.82)
  L5 w0.114: v2(266.69,99.93) 267.07,99.55 267.07,89.05 269.02,87.11 269.02,85.41 270.22,84.21 270.22,80.05 268.13,77.96 268.13,72.19 264.11,68.17 263.49,68.17 263.47,68.15 263.46,68.15 262.04,66.73 260.56,66.73 260,66.17 259.58,65.75 258.37,65.75 253.97,61.35 251.38,61.35 250.94,60.92 250.65,60.62 229.67,60.62 229.23,60.17 222.37,60.17 220.84,58.64 198.5,58.64 197.2,59.94 187.19,59.94 185.93,61.21 181.12,61.21 v2(180.73,60.82)
  BOTTOM w0.114: v2(191.17,54.57) 190.6,54 180.15,54 v2(179.77,54.39)
SPI_CLK_FLH: length 187.8
  TOP w0.114: v2(147.31,70.56) 148.37,71.61 148.37,73.14 150.91,75.68 150.91,78.2 150.56,78.55 150.56,78.56 150.32,78.8 150.31,78.8 149.57,79.55 v2(149.57,81.61) 149.57,85.33 149.99,85.75 149.99,88.97 150.23,89.21 150.23,91.09 150.88,91.75 150.88,95.78 150.53,96.14 v1(150.53,97.65) 150.53,101.28 v2(151.72,102.47) ; v2(253.13,96.96) 253.14,96.96 252.76,96.58 R366.1
  L3 w0.102: v2(149.57,81.61) 150.32,82.36 150.32,82.36 154.93,86.98 157.09,86.98 v2(157.27,87.15) ; v2(253.13,96.96) 253.14,96.96 253.52,97.34 253.52,100.34 253.27,100.59 253.27,109.28 251.52,111.03 251.52,121.75 v2(250.98,122.29)
  BOTTOM w0.114: v2(157.27,87.15) 156.63,87.15 C7475.2 156.62,87.49 156.88,87.74 157.91,87.74 R4794.1 ; v2(151.72,102.47) 152.56,103.31 152.56,108.83 154.58,110.86 157.75,110.86 167.22,120.32 207.87,120.32 208.97,121.42 240.68,121.42 241.55,122.29 v2(250.98,122.29) ; CN365.6 147.53,70.33 v2(147.31,70.56)
SPI_CLK_FLH_KR: length 19.3
  TOP w0.114: v3(253.65,94.52) 253.52,94.52 252.76,95.29 R366.2 ; U300.3 264.48,95.88 266.25,97.65 v2(266.61,97.65)
  L6 w0.114: v3(253.65,94.52) 255.61,94.52 258.73,97.65 v2(266.61,97.65)
SPI_CLK_FLH_R6_R: length 16.9
  TOP w0.114: v2(144.94,73.11) 144.94,75.63 144.42,76.15 144.42,78.93 143.71,79.64 143.71,81.19 v3(144.36,81.84)
  BOTTOM w0.114: v2(144.94,73.11) 144.94,72.5 142.91,70.47 142.91,69.33 142.52,68.94 142.04,68.94 141.69,69.3 CN375.17 ; v3(144.36,81.84) 144.17,81.65 R339.2
SPI_CS0#_FLH: length 194.9
  TOP w0.114: v2(175.63,107.22) 175.68,107.27 175.68,108.15 174.42,109.4 170.35,109.4 168.46,111.3 151.51,111.3 147.87,107.65 147.72,107.65 147.61,107.77 147.61,107.91 150.65,110.95 150.65,111.1 150.53,111.22 150.39,111.22 147,107.83 146.86,107.83 146.74,107.95 146.74,108.09 149.6,110.95 149.6,111.09 149.49,111.21 149.34,111.21 146.14,108.01 146,108.01 145.88,108.13 145.88,108.27 148.58,110.97 148.58,111.11 148.46,111.23 148.32,111.23 145.11,108.02 144.97,108.02 144.85,108.14 144.85,108.28 147.56,110.99 147.56,111.14 147.45,111.25 145.97,111.25 v1(145.32,110.6) 143.04,108.33 143.04,101.3 143.42,100.92 v2(143.42,98.28) ; U300.97 260.94,108.98 v2(260.66,108.7)
  BOTTOM w0.114: v2(260.66,108.7) 260.64,108.68 258.94,108.68 258.93,108.67 247.96,108.67 247.67,108.37 243.22,108.37 242.7,107.85 238.5,107.85 237.95,108.4 237.92,108.43 183,108.43 183,108.43 182.19,108.43 182.19,108.43 181.85,108.43 181.85,108.43 176.83,108.43 v2(175.63,107.22) ; v2(143.42,98.28) 142.91,97.78 142.91,96.33 143.03,96.2 143.03,92.44 141.76,91.17 141.76,90.66 143.16,89.27 143.16,84.44 143.47,84.13 144.46,84.13 144.66,83.93 145.83,83.93 146.08,83.68 146.08,82.57 R4790.1 146.08,82.4 146.08,82.13 145.62,81.67 145.62,80.03 R331.2 146.08,78.62 144.99,77.54 CN365.1
SPI_CS0#_FLH_R6_R: length 24.5
  TOP w0.114: v2(143.37,78.37) 143.37,79.21 143.07,79.5 143.07,82.34 v3(144.37,83.63)
  BOTTOM w0.114: CN375.18 136.08,69.3 136.68,68.69 137.94,68.69 138.34,69.09 138.34,72.9 139.14,73.71 139.14,77.49 139.14,78.52 139.48,78.86 139.49,78.86 139.64,79.02 139.8,79.17 141.74,79.17 142.55,78.37 v2(143.37,78.37) ; R338.2 144.16,83.42 v3(144.37,83.63)
SPI_HOLD#_DB: length 41
  TOP w0.114: v2(147.1,81.14) 147.1,71.84 146.51,71.26 146.51,70.6 v2(146.59,70.52)
  L3 w0.102: v2(147.1,81.14) 148.24,82.28 148.24,83.13 150.74,85.63 151.6,85.63 151.81,85.42 153.02,85.42 154.32,86.72 154.32,87.53 154.68,87.89 156.09,87.89 156.37,87.62 158.86,87.62 159.54,88.29 163.6,88.29 v3(165.26,89.95)
  BOTTOM w0.114: v2(146.59,70.52) 146.26,70.2 CN365.7 146.26,68.24 145.7,67.68 145.7,66.32 R368.1 ; R4795.1 166.14,89.02 165.26,89.9 v3(165.26,89.95)
SPI_HOLD#_DB_R6_R: length 16.7
  TOP w0.114: v2(145.85,72.2) 145.85,78.7 v1(145.07,79.49) 144.63,79.92 v2(144.39,79.92)
  BOTTOM w0.114: R335.2 144.34,79.87 v2(144.39,79.92) ; v2(145.85,72.2) 145.85,71.82 143.8,69.76 143.8,68.77 142.33,67.3 CN375.21
SPI_SI_FLH: length 183.2
  TOP w0.114: v2(146.46,81.77) 146.46,81.9 146.84,82.28 147.4,82.28 147.63,82.05 147.63,74.51 v1(147.73,74.41) 147.73,71.79 v2(146.97,71.03) ; v2(160.83,88.88) 160.83,89.19 161.3,89.66 161.3,90.68 161.2,90.79 161.2,93.58 161.45,93.84 161.45,96.51 159.89,98.07 159,98.07 159,98.07 158.4,98.07 156.69,99.77 156.12,100.35 156.12,103.29 158.74,105.91 v2(158.74,108.05) ; R365.2 v2(253.52,95.24)
  L3 w0.102: v2(253.52,95.24) 252.64,96.12 252.64,97.14 253.27,97.78 253.27,100.23 253.02,100.49 253.02,109.13 251.14,111.01 251.14,117.51 v2(248.77,119.87) ; v2(160.83,88.88) 160.6,88.65 157.15,88.65 156.65,88.15 154.57,88.15 154.06,87.64 154.06,86.82 152.92,85.68 151.91,85.68 151.71,85.88 150.61,85.88 146.51,81.77 v2(146.46,81.77)
  BOTTOM w0.114: v2(158.74,108.05) 158.74,108.33 168.55,118.14 209.18,118.14 210.2,118.14 211.22,119.16 234.98,119.16 235,119.17 242.13,119.17 242.83,119.87 v2(248.77,119.87) ; CN365.5 148.8,69.65 147.43,71.03 v2(146.97,71.03) ; v2(160.83,88.88) 160.83,88.74 161.4,88.17 162.07,88.17 R4796.1
SPI_SI_FLH_KR: length 8.5
  TOP w0.114: v1(254.95,94.35) 255.09,94.49 R365.1 255.63,95.24 256.76,96.37 261.03,96.37 261.14,96.48 U300.128
SPI_SI_FLH_R6_R: length 16.4
  TOP w0.114: v2(144.35,80.57) 143.98,80.2 143.98,79.75 145.07,78.66 v1(145.07,77.2) 145.38,76.89 145.38,72.08 v2(145.29,71.99)
  BOTTOM w0.114: v2(145.29,71.99) 143.39,70.09 143.39,69 142.69,68.3 CN375.19 ; v2(144.35,80.57) 144.17,80.76 R337.2
SPI_SO_FLH: length 178.4
  TOP w0.114: v2(175.19,85.98) 175.26,85.9 178.16,85.9 178.39,85.67 178.39,85.28 178.6,85.08 180.25,85.08 180.5,85.33 180.5,85.39 180.5,85.4 180.5,85.73 180.5,85.73 180.5,86.85 181.39,87.74 181.39,88.76 180.57,89.58 179.79,90.36 179.79,94.1 179.03,94.85 178.51,94.85 177.28,96.08 176.73,96.08 176.16,96.65 176.16,97.94 175.5,98.59 175.5,103.45 176.79,104.73 176.79,108.93 174.43,111.3 170.69,111.3 170.54,111.15 170.54,109.99 170.65,109.88 170.8,109.88 170.91,109.99 170.91,110.66 171.02,110.77 171.17,110.77 171.28,110.66 171.28,109.99 171.39,109.88 171.54,109.88 171.65,109.99 171.65,110.66 171.75,110.77 171.91,110.77 172.01,110.66 172.01,109.99 172.12,109.88 172.27,109.88 172.38,109.99 172.38,110.73 172.48,110.83 172.65,110.83 172.75,110.73 172.75,109.99 172.86,109.88 173.01,109.88 173.12,109.99 173.12,110.66 173.23,110.77 173.38,110.77 173.49,110.66 173.49,109.99 173.6,109.88 173.75,109.88 173.86,109.99 173.86,110.66 173.96,110.77 174.19,110.77 174.31,110.66 174.31,110.18 176.18,108.31 176.18,107.06 175.93,106.81 175.46,106.81 175.19,107.08 v2(175.19,107.64) ; v2(264.04,108.06) 264.08,108.11 U300.95
  L6 w0.076: v2(175.19,85.98) 175.07,85.98 174.69,85.6 173.44,85.6 172.94,85.11 172.03,85.11 171.73,85.41 169.28,85.41 169.22,85.47
  L6 w0.114: 169.22,85.47 169.12,85.57 169.11,85.57 168.75,85.93 159.33,85.93 158.96,85.55 158.96,84.87 157.77,83.68 155.87,83.68 155.04,82.84 154.65,82.84 v2(154.29,82.48)
  BOTTOM w0.076: v2(175.19,85.98) 175.49,85.68 175.49,85.68 U4555.AA4
  BOTTOM w0.114: v2(175.19,107.64) 176.24,108.7 181.74,108.7 182.89,108.7 238.03,108.7 238.06,108.67 238.06,108.67 238.61,108.12 242.59,108.12 243.11,108.64 247.56,108.64 247.85,108.93 258.63,108.93 258.81,109.11 261.76,109.11 262.77,108.1 264,108.1 v2(264.04,108.06) ; v2(154.29,82.48) 152.17,82.48 R367.1
SPI_SO_FLH_R: length 18.6
  BOTTOM w0.114: R367.2 150.76,82.15 149.89,81.29 149.89,80 v1(150.27,79.61) 150.91,78.98 150.91,75.17 150.65,74.92 150.65,72.93 149.97,72.25 147.35,72.25 146.26,73.34 CN365.2
SPI_SO_FLH_R6_R: length 24.8
  TOP w0.114: v3(143.89,77.84) 143.89,79.08 143.34,79.63 143.34,81.77 v2(144.43,82.86)
  BOTTOM w0.114: R336.2 144.11,82.54 v2(144.43,82.86) ; v3(143.89,77.84) 142.4,77.84 141.34,78.91 139.91,78.91 139.6,78.59 139.59,78.59 139.41,78.4 139.41,73.52 138.6,72.71 138.6,68.96 137.94,68.3 CN375.20
SPI_WP#: length 40.6
  TOP w0.114: v2(167.06,72.86) 166.51,73.41 166.51,75.96 167.09,76.55 167.09,79.81 165.7,81.21 165.7,82.7 v4(165.71,82.72)
  L3 w0.102: v3(149.71,76.09) 150.17,75.63 152.79,75.63 155.02,73.39 158.04,73.39 158.68,74.03 165.89,74.03 v2(167.06,72.86)
  BOTTOM w0.114: v3(149.71,76.09) 149.71,78.68 148.82,79.57 R370.1 ; R370.1 147.86,78.55 147.53,78.22 CN365.3 ; R370.1 R369.1 ; v4(165.71,82.72) 165.58,82.59 165.08,82.59 164.56,82.06 R4793.1
SPK_OUT_L_DN: length 176
  TOP w0.254: v5(301.33,65.01) 301.2,64.88 U501.43
  TOP w0.381: v5(301.33,65.01) 301.15,65.19 C642.1
  TOP w0.508: v5(310.23,148.29) 310.23,147.9 310.55,147.58 v1(310.57,147.55) ; TP642.1 248.44,154.42 v5(247.91,154.42)
  L5 w0.508: v5(301.33,65.01) 301.33,68.95 304.07,71.69 304.07,74.15 305.47,75.55 305.47,79.31 303.36,81.42 303.36,86.21 301.94,87.62 301.94,101.29 302.42,101.76 302.42,101.76 302.47,101.81 302.47,103.59 303.41,104.52 303.41,104.52 305.68,106.79 311.44,106.79 313.89,109.24 313.89,110.67 315.25,112.02 315.25,122.58 314.76,123.06 314.76,131.07 312.31,133.53 312.31,145.48 310.23,147.57 v5(310.23,148.29)
  L6 w0.508: v5(310.23,148.29) 310.23,147.86 308.35,145.98 301.56,145.98 296.01,140.43 288.38,140.43 279.43,149.38 256.56,149.38 254.36,151.57 254.35,151.57 251.51,154.42 v5(247.91,154.42)
  BOTTOM w0.508: CN640.3 247.06,154.88 247.52,154.42 v5(247.91,154.42)
SPK_OUT_L_DP: length 178.3
  TOP w0.254: v5(302.29,65.01) 301.6,64.32 U501.42
  TOP w0.381: C643.1 302.04,65.26 v5(302.29,65.01)
  TOP w0.508: v1(311.95,147.94) 311.94,147.94 311.65,147.94 v5(311.24,148.35) ; v5(247.81,153.15) 246.67,153.15 TP643.1
  L5 w0.508: v5(302.29,65.01) 302.37,65.09 302.37,65.98 302.42,66.03 302.42,68.59 305.09,71.26 305.09,73.65 306.48,75.04 306.48,79.73 304.37,81.84 304.37,86.63 303,88 303,100.9 303.49,101.39 303.49,103.16 306.1,105.78 311.94,105.78 314.9,108.74 314.9,110.23 316.26,111.59 316.26,123 315.78,123.48 315.78,131.53 313.33,133.98 313.33,145.9 311.24,147.99 v5(311.24,148.35)
  L6 w0.508: v5(247.81,153.15) 251.34,153.15 256.13,148.36 275.87,148.36 279.01,148.36 287.96,139.42 296.44,139.42 301.99,144.97 308.84,144.97 311.24,147.37 v5(311.24,148.35)
  BOTTOM w0.508: v5(247.81,153.15) 247.35,153.15 246.87,153.63 CN640.4
SPK_OUT_R_DN: length 172.9
  TOP w0.254: U501.44 300.8,64.52 v5(300.31,65.01)
  TOP w0.381: C641.1 300.26,65.06 v5(300.31,65.01)
  TOP w0.508: v5(309.08,148.34) 309.08,147.63 v1(309.28,147.43) ; TP641.1 247.68,155.69 v5(247.88,155.69)
  L5 w0.508: v5(300.31,65.01) 300.31,69.45 301.97,71.12 301.97,72.51 303.05,73.59 303.05,80.29 302.34,81 302.34,85.76 300.93,87.17 300.93,101.71 301.4,102.18 301.4,103.96 302.99,105.54 302.99,105.54 305.26,107.81 310.93,107.81 312.87,109.75 312.87,111.1 314.23,112.46 314.23,122.16 313.75,122.64 313.75,130.6 311.3,133.05 311.3,145.06 309.08,147.27 v5(309.08,148.34)
  L6 w0.508: v5(247.88,155.69) 248.01,155.55 251.99,155.55 257.15,150.39 279.9,150.39 288.64,141.65 294.95,141.65 295.79,141.65 301.14,147 307.75,147 v5(309.08,148.34)
  BOTTOM w0.508: CN640.2 247.02,156.13 247.26,155.89 247.48,155.89 247.68,155.69 v5(247.88,155.69)
SPK_OUT_R_DP: length 170.9
  TOP w0.254: v5(299.32,65.01) 299.42,65.01 300.4,64.03 U501.45
  TOP w0.381: v5(299.32,65.01) 299.32,65.8 C640.1
  TOP w0.508: v5(248,156.7) 248,156.7 248.57,156.7 TP640.1
  L5 w0.508: v5(307.61,148.34) 307.61,147.32 308.07,146.86 308.07,146.85 310.28,144.64 310.28,132.63 312.73,130.18 312.73,122.22 313.21,121.74 313.21,112.94 311.86,111.58 311.86,110.17 310.51,108.82 304.84,108.82 302.57,106.56 302.56,106.56 300.39,104.38 300.39,102.6 299.91,102.13 299.91,86.71 301.33,85.3 301.33,80.58 302.04,79.87 302.04,74.15 302.04,74.15 302.04,74.06 300.9,72.91 300.9,71.49 299.24,69.84 299.24,65.06 299.29,65.01 v5(299.32,65.01)
  L6 w0.508: v5(307.61,148.34) 307.34,148.07 300.77,148.07 295.37,142.67 289.15,142.67 280.41,151.41 257.66,151.41 252.37,156.7 v5(248,156.7)
  BOTTOM w0.508: CN640.1 247.64,157.38 248,157.02 v5(248,156.7)
SPKR_EN_AB: length 16.8
  TOP w0.114: U501.48 299.2,63.17 299.12,63.26 298.33,63.26 v2(298.28,63.21) ; C527.1 288.32,63.28 R517.2 ; C527.1 290.35,63.28 R509.2 289.72,62.64 289.72,61.45 v2(289.59,61.33) ; C527.1 289.21,64.14 D500.3
  L3 w0.102: v2(289.59,61.33) 289.97,60.95 292.26,60.95 292.51,61.2 292.51,61.58 294.37,63.43 298.05,63.43 v2(298.28,63.21)
SPWON: length 246.3
  TOP w0.102: v2(297.85,114.16) 297.85,113.78 298.56,113.07 298.56,110.91 298.8,110.67 Q7100.3
  L3 w0.102: v2(118.37,87.11) 118.47,87.01 121.97,87.01 v4(122.42,87.46) 122.84,87.05 125.65,87.05 125.94,87.05 126.65,86.34 136.64,86.34 v2(137.01,85.96)
  L5 w0.102: v2(137.01,85.96) 137.01,90.74 140.84,94.57 140.84,102.91 v3(140.65,103.11) ; v2(297.85,114.16) 297.85,113.47 297.59,113.22 297.21,113.22 296.98,112.99 296.98,110.18 296.73,109.93 296.1,109.93 294.47,108.29 291.78,108.29 290.71,109.35 286.29,109.35 285.6,108.67 273.64,108.67 271.3,111.01 269.36,111.01 267.46,112.91 267.46,115.4 264.95,117.91 264.95,126.49 v2(262.1,129.34)
  BOTTOM w0.102: v2(118.37,87.11) 118.27,87.21 118.27,87.79 Q7051.6 118.13,87.93 Q7050.3 ; v3(140.65,103.11) 140.65,103.13 C7152.1 140.16,105.32 152.24,117.4 156.56,117.4 169.88,130.71 190.11,130.71 190.32,130.5 191.77,129.06 193.96,129.06 195.32,130.41 195.49,130.59 201.99,130.59 205.62,126.96 237.88,126.96 239.86,128.94 244.4,128.94 245.34,128 259.32,128 260.85,126.47 261.19,126.47 261.42,126.71 261.42,128.99 261.78,129.34 v2(262.1,129.34)
  BOTTOM w0.254: v4(122.42,87.46) 122.42,87.6 122.05,87.97 121.09,87.97 120.68,88.38 R7101.2
  BOTTOM w0.381: v2(137.01,85.96) 136.97,86 Q7153.4
ST_LEFT: length 116
  TOP w0.102: CN200.2 100.05,88.56 101.38,87.23 101.38,85.08 102.44,84.01 v2(102.44,83.93) ; v2(190.15,54.57) 190.15,57.64 190.3,57.79 CN202.6
  L5 w0.102: v2(102.44,83.93) 102.68,83.7 106.9,83.7 107.64,84.44 111.46,84.44 116.13,79.77 124.16,79.77 125.1,78.83 128.81,78.83 130.97,76.66 130.97,75.85 131.74,75.08 131.74,70.7 139.32,63.12 152.84,63.12 153.45,63.73 160.44,63.73 162.69,61.48 170.67,61.48 171.85,60.3 171.85,59.35 176.18,55.02 180.21,55.02 180.5,54.73 188.2,54.73 188.45,54.98 189.74,54.98 v2(190.15,54.57)
ST_LEFT_SM: length 58.3
  TOP w0.102: v2(71.15,105.65) 72,106.5 CN9000.2 ; CN9021.2 74.69,150.35 77.11,147.93 77.11,142.85 v3(75.98,141.72)
  L3 w0.102: v3(75.98,141.72) 75.22,140.96 75.22,136.26 77.5,133.97 77.5,122.41 69.76,114.67 69.76,109.97 70.39,109.33 70.39,106.28 71.03,105.65 v2(71.15,105.65)
ST_RIGHT: length 117.5
  TOP w0.102: v1(98.97,91.3) 99.55,90.71 CN200.1 99.55,88.25 100.87,86.93 100.87,84.69 v2(101.63,83.93) ; CN202.8 189.3,54.73 v2(189.14,54.57)
  L5 w0.102: v2(189.14,54.57) 189.01,54.44 180.37,54.44 179.99,54.82 176.03,54.82 171.62,59.24 171.62,60.25 170.59,61.28 162.51,61.28 160.42,63.37 153.94,63.37 153.14,62.56 138.96,62.56 131.54,69.98 131.54,74.86 130.62,75.78 130.62,76.54 128.56,78.6 124.98,78.6 124.07,79.5 115.84,79.5 111.23,84.11 107.73,84.11 107.02,83.4 102.17,83.4 v2(101.63,83.93)
ST_RIGHT_SM: length 56.3
  TOP w0.102: v2(71.15,106.79) 71.5,107.14 CN9000.1 ; CN9021.1 75.1,150.85 77.71,148.24 77.71,142.18 v3(75.98,140.45)
  L3 w0.102: v2(71.15,106.79) 71.15,109.33 70.26,110.22 70.26,113.9 78.01,121.65 78.01,134.1 75.98,136.13 v3(75.98,140.45)
SUS_PWR_WARN#: length 5
  TOP w0.102: R347.1 260.3,109.46 v1(260.56,109.46) 260.2,109.1 260.2,108.37 260.38,108.19 260.89,108.19 261.23,108.53 U300.98
SUSCLK32_PCH: length 138.2
  TOP w0.102: v2(169.66,108.45) 169.64,108.43 169.64,107.62 171.1,106.16 v1(171.48,106.16) 171.99,105.65 171.99,102.86 172.88,101.97 172.88,101.12 172.44,100.68 172.44,99.97 172.44,99.97 172.44,99.81 172.44,97.23 172.44,96.4 173.57,95.26 173.57,88.84 174.55,87.87 176.07,87.87 v2(176.59,87.35) ; v2(274.48,116.7) 275.24,115.94 R382.2
  L6 w0.102: v2(274.48,116.7) 271.48,116.7 268.97,114.18 v2(263.66,114.18)
  BOTTOM w0.076: v2(176.59,87.35) 176.59,87.61 U4555.AE6
  BOTTOM w0.102: v2(263.66,114.18) 262.8,114.18 262.37,114.62 257.28,114.62 256.56,115.34 245.78,115.34 244.77,114.32 243.96,114.32 243.38,113.74 212.55,113.74 212.18,113.37 174.17,113.37 169.66,108.86 v2(169.66,108.45)
SUSWARN#: length 127.7
  TOP w0.102: v2(259.8,111.67) 259.42,111.67 258.43,110.69 R347.2 ; v2(168.01,99.17) 168.01,103.89 166.78,105.12 v2(166.78,106.87)
  L3 w0.102: v2(259.8,111.67) 258.1,113.37 v3(258.1,117.84)
  BOTTOM w0.076: U4555.AV4 175.51,95.2 175.2,95.51 175.2,96.09 175.13,96.16 175.13,96.65 174.9,96.89
  BOTTOM w0.102: v3(258.1,117.84) 258.01,117.93 252.83,117.93 252.09,117.19 250.4,117.19 243.66,117.19 243.45,116.98 242.82,116.36 212.33,116.36 211.35,115.38 208.04,115.38 208.04,115.38 171.56,115.38 166.78,110.6 v2(166.78,106.87) ; R4815.1 166.66,99.34 166.66,98.62 R4746.2 166.62,98.49 167.34,98.49 v2(168.01,99.17) 168.69,99.17 170.65,97.21 174.4,97.21 174.72,96.89 174.9,96.89
TACH_FAN_IN: length 219
  TOP w0.102: U300.101 260.97,107.33 260.77,107.53 260.36,107.53 260.01,107.88 v2(259.74,107.88)
  L3 w0.102: v2(259.74,107.88) 258.86,108.76 258.86,111.75 256.95,113.65 256.95,118.86 259.64,121.55 261.14,121.55 261.9,122.31 261.9,128.76 261.4,129.27 261.4,145.76 259.68,147.48 257.26,147.48 257.26,147.47 255.7,147.47 253.77,149.41 247.66,149.41 246.72,150.35 v3(246.72,151.24)
  L6 w0.102: v3(246.72,151.24) 246.29,151.67 246.29,159.2 243.32,162.16 189.67,162.16 184.06,156.55 175.38,156.55 169.06,162.88 115.83,162.88 114.05,161.1 v2(113.11,161.1)
  BOTTOM w0.102: R4301.1 113.29,161.28 v2(113.11,161.1) 113.15,161.06 113.15,159.97 111.03,157.85 111.03,156.38 111.28,156.13 CN4300.3
TD1_DN: length 11.5
  TOP w0.089: U400.14 296.02,108.55 296.37,108.19 296.6,108.19 297.06,107.73 297.85,107.73 300.62,104.97 301.92,104.97 302.41,104.48 302.41,103.24 302.08,102.91 301.15,102.91 U470.2
TD1_DP: length 11.5
  TOP w0.089: U470.1 301.38,103.87 301.61,103.64 301.61,103.29 301.75,103.15 301.98,103.15 302.17,103.34 302.17,104.38 301.82,104.73 300.33,104.73 300.17,104.88 300.17,105.07 300.02,105.22 299.83,105.22 299.68,105.37 299.68,105.56 299.53,105.71 299.34,105.71 299.19,105.87 299.19,106.05 299.03,106.21 298.85,106.21 298.69,106.36 298.69,106.55 297.75,107.49 296.96,107.49 296.5,107.95 296.27,107.95 296.07,108.15 U400.13
TD2_DN: length 18.3
  TOP w0.089: U470.6 300.46,97.52 300.08,97.91 299.43,97.91 v2(299.29,97.78) ; v2(297.67,109.77) 297.53,109.63 297.23,109.63 296.77,110.09 295.7,110.09 U400.18
  L3 w0.089: v2(297.67,109.77) 297.79,109.66 298.05,109.66 298.44,109.27 298.44,108.28 298.44,107.54 300.5,105.49 300.5,98.26 300.16,97.93 299.45,97.93 v2(299.29,97.78)
TD2_DP: length 18.3
  TOP w0.089: U400.17 295.74,109.85 296.67,109.85 297.13,109.39 297.55,109.39 297.65,109.29 v3(297.65,109.08) ; U470.5 300.46,98.79 299.82,98.15 299.5,98.15 299.29,98.36 v2(299.29,98.56)
  L3 w0.089: v3(297.65,109.08) 297.65,109.28 297.73,109.37 297.93,109.37 298.15,109.15 298.15,108.4 298.15,107.42 300.2,105.37 300.2,98.39 300.04,98.22 299.42,98.22 299.29,98.34 v2(299.29,98.56)
TD3_DN: length 23.3
  TOP w0.089: 300.84,94.98 300.49,94.98 299.9,95.57 299.32,95.57 v2(299.22,95.67) ; v2(297.84,111.22) 297.75,111.32 295.67,111.32 U400.21
  L3 w0.089: v2(299.22,95.67) 300.6,95.67 301.38,96.45 301.38,105.85 299.33,107.91 299.33,110.44 298.54,111.22 v2(297.84,111.22)
TD3_DP: length 23.2
  TOP w0.089: v2(299.22,96.33) 299.74,95.81 300.02,95.81 300.46,96.25 U470.7 ; U400.20 295.73,111.03 296.09,111.03 296.14,111.08 297.37,111.08 297.85,110.6 v3(297.85,110.53)
  L3 w0.089: v3(297.85,110.53) 297.85,110.66 298.12,110.93 298.42,110.93 299.03,110.32 299.03,108.03 299.03,107.79 301.09,105.73 301.09,96.58 300.48,95.96 299.49,95.96 299.22,96.23 v2(299.22,96.33)
TD4_DN: length 34.8
  TOP w0.089: v2(299.27,89.47) 299.27,89.55 299.78,90.05 300.69,90.05 300.84,89.9 ; v2(297.34,113.7) 297.16,113.52 296.9,113.52 296.62,113.24 296.62,112.59 296.5,112.47 295.72,112.47 U400.24
  L3 w0.089: v2(299.27,89.47) 299.42,89.62 300.02,89.62 302.27,91.87 302.27,107.75 303.01,108.48 303.01,111.08 301.88,112.21 299.4,112.21 298.1,113.5 297.53,113.5 v2(297.34,113.7)
TD4_DP: length 34.8
  TOP w0.089: v2(299.27,90.18) 299.57,90.18 299.87,90.48 299.87,90.6 300.44,91.17 U470.11 ; v3(297.39,112.79) 297.39,113.09 297.2,113.28 297,113.28 296.86,113.14 296.86,112.49 296.6,112.23 295.72,112.23 U400.23
  L3 w0.089: v3(297.39,112.79) 297.27,112.92 297.27,113.14 297.34,113.21 297.98,113.21 299.27,111.92 301.76,111.92 302.72,110.96 302.72,108.61 301.98,107.87 301.98,91.99 299.9,89.91 299.54,89.91 v2(299.27,90.18)
TD_DN: length 57.1
  TOP w0.089: U470.23 310.12,102.6 310.94,103.43 311.07,103.43 311.8,104.16 314.02,104.16 316.85,106.99 316.85,108.18 316.94,108.27 317.17,108.27 317.26,108.17 317.26,107.95 v1(317.41,107.81) 317.58,107.98 317.58,108.18 317.75,108.35 318.07,108.35 318.3,108.13 318.3,108.12 318.4,108.01 318.55,108.01 318.65,108.12 318.65,108.13 318.76,108.23 318.9,108.23 319.01,108.13 319.01,108.12 319.11,108.01 319.26,108.01 319.36,108.12 319.36,108.13 319.47,108.23 320.18,108.23 320.57,108.62 320.83,108.62 320.95,108.74 320.95,109.01 321.07,109.12 321.34,109.12 321.46,109.24 321.46,109.51 321.54,109.59 321.84,109.59 321.94,109.49 321.94,109.46 322.04,109.36 322.19,109.36 322.29,109.46 322.29,109.49 322.4,109.59 322.54,109.59 322.66,109.47 323.06,109.47 323.2,109.34 CN3601.6
  L6 w0.089: JACK485.2 316.1,85.55 315.26,85.55 314.67,86.13 314.67,101.93 316.8,104.06 318.87,104.06 318.98,104.06 320.29,102.75 324.12,102.75 325.51,104.15 325.51,108.64 324.95,109.2 323.2,109.2 CN3601.6
TD_DP: length 57.2
  TOP w0.089: CN3601.5 324.4,108.85 323.76,109.49 323.76,109.51 323.55,109.71 322.76,109.71 322.64,109.83 321.44,109.83 320.08,108.47 318.31,108.47 318.19,108.6 317.89,108.6 v1(317.41,109.08) 316.61,108.28 316.61,107.09 313.92,104.4 311.7,104.4 310.97,103.67 310.31,103.67 310.11,103.87 U470.24
  L6 w0.089: CN3601.5 324.4,108.81 324.53,108.94 324.84,108.94 325.25,108.53 325.25,104.26 324.01,103.02 320.4,103.02 319.09,104.33 318.76,104.33 318.76,104.33 316.69,104.33 314.41,102.04 314.41,86.02 315.15,85.28 316.87,85.28 317.02,85.43 317.5,85.43 JACK485.1
TD_IREF: length 3.5
  TOP w0.127: v2(181.14,73.14) 180.88,73.14 v1(180.25,73.77) R4841.2
  BOTTOM w0.127: U4555.B12 181,73.27 v2(181.14,73.14)
THERM#: length 70.1
  L3 w0.102: v3(112.91,97.83) 111.84,98.89 111.84,128.46 108.49,131.81 108.49,142.61 112.43,146.54 112.43,151.24 v2(110.78,152.89)
  BOTTOM w0.102: v3(112.91,97.83) 113.05,97.68 R5049.1 112.96,95.74 112.26,95.74 R5039.2 ; v2(110.78,152.89) 113.95,152.89 114.84,153.78 114.84,154.77 115.76,155.69 Q4300.5
THERM_CLK: length 231.6
  TOP w0.114: v2(145.83,105.37) 145.67,105.21 145.67,103.41 145.84,103.23 146.06,103.02 146.06,96.52 144.98,95.44 144.98,90.37 v2(145.7,89.65) ; v3(231.05,96.51) 229.97,97.58 229.97,102.01 229.64,102.35 229.64,108.8 231.52,110.68 237.27,110.68 244.21,117.63 244.21,127.09 v2(243.68,127.62) ; U1000.4 245.02,97.39 v1(245.9,96.51) v2(248.06,96.51)
  L3 w0.102: v2(117.91,90.87) 118.19,90.87 119.39,89.66 137.31,89.66 137.66,90.02 145.33,90.02 v2(145.7,89.65) ; v2(248.06,96.51) 248,96.51 247.43,95.93 247.43,94.35 246.54,93.46 243.55,93.46 241.54,95.47 239.35,95.47 238.08,94.19 236.15,94.19 235.21,95.13 231.53,95.13 231.05,95.62 v3(231.05,96.51)
  BOTTOM w0.102: v2(117.91,90.87) 118.01,90.97 R5044.2
  BOTTOM w0.114: v2(117.91,90.87) 117.18,90.87 116.35,91.7 U5000.8 ; Q5314.1 147.41,88.7 146.97,89.14 146.21,89.14 v2(145.7,89.65) ; v2(145.83,105.37) 145.59,105.6 145.59,108.71 152.85,115.96 157.16,115.96 157.8,116.59 170.47,129.27 189.51,129.27 190.95,127.83 191.17,127.61 193.36,127.61 193.36,127.61 194.56,127.61 196.09,129.14 201.4,129.14 204.26,126.28 205.02,125.52 205.96,125.52 226.88,125.52 227.99,125.52 228,125.52 229.19,125.52 234.73,125.52 236.89,125.52 236.89,125.52 238.67,125.52 240.21,127.06 243.18,127.06 243.68,127.56 v2(243.68,127.62)
THERM_DATA: length 241.8
  TOP w0.114: v2(145.07,105.52) 145.3,105.29 145.3,103.26 145.69,102.87 145.69,96.63 144.61,95.55 144.61,88.89 v2(146.13,87.36) ; v2(248.06,97.14) 246.67,97.14 v1(245.9,97.9) 245.9,98.44 245.56,98.79 244.63,98.79 243.99,98.15 U1000.6 ; v2(231.55,95.74) 231.05,95.74 229.6,97.18 229.6,99.98 v1(229.14,100.44) 229.27,100.57 229.27,108.95 231.37,111.05 237.12,111.05 243.55,117.48 243.55,127.05 v2(243.07,127.53)
  L3 w0.102: v2(248.06,97.14) 247.43,97.78 247.43,99.43 246.79,100.06 240.46,100.06 240.05,99.66 240.05,96.62 237.98,94.55 236.3,94.55 235.1,95.74 v2(231.55,95.74) ; v2(146.13,87.36) 146.13,87.89 147.1,88.86 147.1,89.9 146.57,90.42 137.48,90.42 137.1,90.05 119.52,90.05 118.22,91.35 v2(117.3,91.35)
  BOTTOM w0.114: U5000.7 116.58,92.35 117,91.93 117,91.65 v2(117.3,91.35) 117.3,91.74 R5032.2 ; Q5314.4 145.82,86.96 146.13,87.27 v2(146.13,87.36) ; v2(145.07,105.52) 145.07,108.7 152.69,116.33 157.01,116.33 157.43,116.75 170.32,129.64 189.67,129.64 189.88,129.42 191.32,127.98 193.51,127.98 194.4,127.98 194.4,127.98 195.93,129.51 201.55,129.51 205.17,125.89 206.11,125.89 227.03,125.89 228.15,125.89 229.04,125.89 229.04,125.89 233.98,125.89 235.85,125.89 235.85,125.89 236.74,125.89 238.52,125.89 240.16,127.53 v2(243.07,127.53)
THERM_SCI#: length 73.2
  L5 w0.102: v2(152.81,73.9) 154.79,73.9 155.18,73.52 159.09,73.52 159.34,73.26 167.95,73.26 v3(168.37,72.85)
  L6 w0.102: v2(152.81,73.9) 152.81,76.03 148.32,80.53 146.18,80.53 144.98,81.72 144.98,81.85 144.42,82.42 144.16,82.42 143.9,82.68 143.9,84.01 143.09,84.82 141.21,84.82 136.13,89.9 126.11,89.9 122.05,93.97 119.03,93.97 118.55,94.45 v2(117.72,94.45)
  BOTTOM w0.102: U5000.6 117.13,93 117.47,93.34 R5043.2 118.01,94.15 v2(117.72,94.45) ; U4555.F1 173.54,77.13 173.24,77.13 172.07,75.96 172.07,74.61 171.33,73.87 169.07,73.87 168.37,73.16 v3(168.37,72.85)
THRMTRIP#: length 16.1
  TOP w0.102: R4732.1 221.12,73.66 v1(220.25,74.53) 218.57,76.21 v2(216.97,76.21)
  L6 w0.102: v2(209.95,76.11) 211.71,74.35 214.96,74.35 216.82,76.21 v2(216.97,76.21)
  BOTTOM w0.076: v2(209.95,76.11) 209.95,75.95 210.21,75.69 U4555.D60
TLS_ENCRYTION: length 20.6
  L6 w0.076: v2(176.65,86.42) 176.28,86.78 175.33,86.78
  L6 w0.102: v4(161.58,87.46) 162.93,87.46 163.7,86.69 169.07,86.69 169.7,86.06 170.73,86.06 171.75,87.07 172.09,87.07 172.39,86.78 175.33,86.78
  BOTTOM w0.076: U4555.AD6 176.65,86.71 v2(176.65,86.42)
  BOTTOM w0.102: v4(161.58,87.46) 161.58,87.59 160.69,88.48 160.44,88.48 v1(159.66,89.26) 159.19,89.72 R4733.2
TRAVEL_BAT_DET#: length 5.9
  TOP w0.102: U300.65 276.13,111.11 276.23,111.21 278.39,111.21 v1(279.81,112.63) 280.19,113.01 R6074.1
UIM_CD: length 29.3
  TOP w0.102: R1452.2 v3(247.3,79.36) 246.92,78.98 246.03,78.98 245.51,78.46 CN1451.CD
  L6 w0.102: v3(247.3,79.36) 246.56,78.62 v2(246.56,72.18)
  BOTTOM w0.102: CN1400.66 253.18,59 252.41,59.78 252.41,66.07 248.7,69.78 248.7,70.85 247.37,72.18 v2(246.56,72.18)
UIM_CLK: length 16.9
  TOP w0.381: v2(250.45,73.15) 251.25,73.15 251.62,73.52 251.62,74.07 250.6,75.09 CN1451.P3 250.48,77.92 v1(250.48,79.36) 250.48,80.08 C1453.1
  BOTTOM w0.356: CN1400.32 253.44,67.5
  BOTTOM w0.381: 253.44,67.5 250.45,70.5 v2(250.45,73.15)
UIM_DATA: length 17.7
  TOP w0.381: v2(249.52,74.03) 249.55,74.06 249.55,74.83 249.32,75.05 CN1451.P7 249.2,77.93 v1(249.2,79.36) 249.2,80.07 R1451.2
  BOTTOM w0.356: CN1400.34 253.56,67
  BOTTOM w0.381: v2(249.52,74.03) 249.27,73.78 249.27,69.9 252.36,66.81 252.91,66.81 253.1,67 253.56,67
UIM_PWR: length 25.4
  TOP w0.381: 255.43,78.98 255.18,79.23 C1451.1 ; v1(248.32,80.88) 248.32,79.39 v2(248.34,79.36) ; v1(248.32,80.88) 248.14,81.06 R1452.1 ; v1(248.32,80.88) 248.49,81.06 R1451.1 ; v5(255.3,76.31) 253.22,74.23 v2(253.22,66.15)
  L3 w0.381: v2(248.34,79.36) 248.47,79.36 250.37,77.46 254.16,77.46 v5(255.3,76.31)
  BOTTOM w0.356: v2(253.22,66.15) 253.57,66.5 CN1400.36
UIM_RST: length 19
  TOP w0.381: CN1451.P2 253.14,78.34 253.14,78.34 C1405.1 252.18,80.2 251.42,79.44 v4(251.42,79.21)
  BOTTOM w0.356: CN1400.30 253.91,68
  BOTTOM w0.381: 253.91,68 253.65,68.26 253.65,68.56 251.09,71.13 251.09,73.86 250.22,74.73 250.22,77.97 251.42,79.16 v4(251.42,79.21)
UNNAMED_5_BQ24736RGRR_I30_ACDET: length 9
  TOP w0.254: U6000.6 288.81,130.25 288.15,130.92 287.81,130.92 287.56,131.18 C6022.1 287.76,131.26 288.61,132.11 R6022.1 R6023.1 289.72,132.91 R6021.2 290.69,132.91 290.98,133.2 D6018.1 v1(290.98,134.61)
UNNAMED_5_BQ24736RGRR_I30_ACDRV: length 17.6
  TOP w0.356: v2(290.23,128.89) 290.22,128.89 290.22,128.06 290.03,127.87 U6000.4
  TOP w0.381: R6018.2 291.28,143.29 v2(290.13,143.29)
  BOTTOM w0.381: v2(290.23,128.89) 290.23,130.14 290.58,130.49 v1(290.58,131.58) 290.58,142.84 v2(290.13,143.29)
UNNAMED_5_BQ24736RGRR_I30_ACN: length 24
  TOP w0.254: v3(291.57,136.76) 291.45,136.89 288.59,136.89 287.36,138.13 287.36,139.1 287.15,139.3 R6000.4 ; U6000.1 290.34,126.37 291.11,125.6 C6030.1 291.96,125.6 292.05,125.51 C6028.2 293.36,125.51 v4(293.4,125.55)
  BOTTOM w0.254: v3(291.57,136.76) 291.83,137.02 292.13,137.02 292.31,136.84 292.31,126.3 292.77,125.84 293.11,125.84 v4(293.4,125.55)
UNNAMED_5_BQ24736RGRR_I30_ACP: length 23.2
  TOP w0.254: U6000.2 290.98,126.87 291.24,126.6 C6029.2 292.14,126.6 292.38,126.36 C6028.1 v3(293.4,126.36) ; R6000.3 287.97,139.3 287.71,139.05 287.71,138.27 288.72,137.27 291.32,137.27 v4(291.57,137.53)
  BOTTOM w0.254: v4(291.57,137.53) 291.73,137.37 292.28,137.37 292.67,136.99 292.67,126.45 292.91,126.2 293.24,126.2 v3(293.4,126.36)
UNNAMED_5_BQ24736RGRR_I30_BTST: length 2.8
  TOP w0.254: U6000.17 287.31,125.22 286.84,124.75 v1(286.84,124.02) 287.43,123.42 R6015.1
UNNAMED_5_BQ24736RGRR_I30_CMSRC: length 23.2
  TOP w0.102: R6028.2 301.19,144 D6017.3 300.07,142.62 v2(300.34,142.35)
  TOP w0.254: v3(291,128.79) 290.74,128.53 290.74,127.87 290.23,127.37 U6000.3
  L3 w0.102: v2(300.34,142.35) 300.34,138.13 v3(291,128.79)
UNNAMED_5_BQ24736RGRR_I30_DLIM: length 4
  TOP w0.254: U6000.11 285.87,128.37 285.27,128.97 v1(285.27,129.4) 284.66,129.4 284.16,128.89 C6031.1 283.92,128.89 R6049.2
UNNAMED_5_BQ24736RGRR_I30_REGN: length 7.4
  TOP w0.254: D6016.2 D6016.1 284.32,123.88 284.85,123.35 C6025.1 286.16,123.56 285.6,124.11 v1(285.6,124.46) 285.79,124.46 286.81,125.48 U6000.16
UNNAMED_5_BQ24736RGRR_I30_SRN: length 2.3
  TOP w0.254: U6000.12 284.85,127.87 v1(284.84,127.85) 284.07,127.85 R6020.1
UNNAMED_5_BQ24736RGRR_I30_SRP: length 3.6
  TOP w0.254: U6000.13 285.27,127.37 285.02,127.11 284.77,127.11 284.06,126.41 v1(284.06,126.22) 284.06,126.22 283.92,126.36 R6025.1
UNNAMED_5_BQ24736RGRR_I30_VCC: length 4.5
  TOP w0.254: U6000.20 288.81,125.66 289.02,125.46 289.34,125.46 289.82,124.98 v1(289.82,124.23) C6027.1 289.82,123.19 R6027.2
UNNAMED_5_CHOKE2PIN_I90_INB:
  vias: v1(271.81,132.45)
UNNAMED_5_CSC0402_I48_B: length 9
  TOP w0.102: Q6009.6 302.85,146 302.85,144.71 303.05,144.51 303.05,143.67 C6019.2 R6017.2 301.57,143.41 301.15,142.99 301.15,142.35 300.47,141.68 v1(299.37,141.68) Q6010.4
UNNAMED_5_CSC0402_I59_A: length 6.8
  TOP w0.254: D6016.3 283.37,122.03 283.62,122.29 285.4,122.29 286.54,121.14 287.15,121.14 v1(287.28,121.27) 287.43,121.42 R6015.2 288.32,122.5 C6015.1
UNNAMED_5_CSC0402_I61_A: length 2.9
  BOTTOM w0.381: R7600.2 C7600.1 269.86,131.89 v1(270.03,132.07)
UNNAMED_5_CSC0402_I73_A: length 14.8
  TOP w0.254: v2(275.75,133.08) 276,133.34 278.8,133.34 280.45,131.68 280.45,127.75 281.13,127.07 C6023.1 281.76,127.07 281.85,127.16 C6024.1 282.7,127.16 282.75,127.11 R6025.2
  BOTTOM w0.254: R6001.3 274.23,132.95 274.48,133.21 275.62,133.21 v2(275.75,133.08)
UNNAMED_5_CSC0402_I74_B: length 14.4
  TOP w0.254: v3(275.75,133.84) 275.88,133.72 278.92,133.72 280.82,131.82 280.82,128.06 280.96,127.92 C6023.2 282.19,127.92 C6021.1 282.27,128 R6020.2
  BOTTOM w0.254: R6001.4 274.23,133.97 274.48,133.72 275.62,133.72 v3(275.75,133.84)
UNNAMED_5_DIODESCH_I86_A2: length 3.1
  TOP w0.254: D6018.2 292.22,131.05 R6030.1 292.39,131.22 v1(292.39,131.94) 292.39,132.66 R6029.2
UNNAMED_5_NMOS4D3S_I34_D0:
  vias: v1(290.35,138.29)
UNNAMED_5_NMOS4D3S_I34_G: length 2.7
  TOP w0.381: R6018.1 293.05,143.24 v1(293.1,143.29) 293.45,142.94 Q6011.4
UNNAMED_5_NMOSDUALC_I46_D2: length 3.6
  TOP w0.102: Q6009.3 305.99,147.45 v1(306.23,147.69) R6016.2 306.19,146.8 Q6009.2
UNNAMED_5_NMOSDUALC_I46_S1: length 2
  TOP w0.102: R6005.1 304.32,145.07 v1(305.06,145.07) 304.89,145.24 Q6009.1
UNNAMED_6_COMPARATOR_I63_1: length 12.9
  TOP w0.102: U6903.1 297.78,138.1 297.34,138.54 294.42,138.54 293.98,138.11 293.98,137.66 293.43,137.1 R6931.2 293.04,137.1 v1(292.49,137.65) ; U6903.1 297.78,137.08 296.96,136.26 295.86,136.26 R6930.1 ; U6903.1 298.06,137.95 R6933.1
UNNAMED_6_COMPARATOR_I63_3: length 4.7
  TOP w0.102: U6903.3 295.61,137.95 C6906.1 294.59,137.95 294.16,137.53 294.16,136.3 R6934.1 292.91,135.92 v1(292.89,135.9)
UNNAMED_6_NMOS_I73_D: length 3.6
  TOP w0.102: v1(286.29,97.24) 286.58,97.24 Q6998.3 288.34,98.1 R6998.2
UNNAMED_6_NPND_I54_B: length 2.5
  TOP w0.102: Q6901.1 62.84,90.14 63.35,90.66 v1(64.04,90.66) R6915.2
UNNAMED_6_PNPA_I55_E: length 6.2
  TOP w0.102: R6910.2 291.12,99.13 291.12,100.19 Q6900.2 291.44,101.11 290.93,101.62 290.06,101.62 v1(290,101.56) 290.02,101.54 R6909.1
UNNAMED_7_CSC0402_I44_A: length 3.3
  BOTTOM w0.254: C6166.1 233.92,150.18 v1(233.36,149.62)
  BOTTOM w0.381: C6166.1 234.72,150.46 R6166.2 234.72,150.99 234.99,151.25 R6167.2
UNNAMED_7_CSC0402_I51_B: length 6.6
  TOP w0.102: R6160.2 R6151.1 241.42,147.05 R6199.2 241.39,147.97 240.11,147.97 v3(240.04,147.89)
  BOTTOM w0.254: C6172.2 242.01,149 241.69,148.68 241.06,148.68 240.27,147.89 v3(240.04,147.89) 239.34,147.89 U6150.14
UNNAMED_7_CSC0402_I69_B: length 4.8
  BOTTOM w0.254: C6122.2 R6110.2 ; R6110.2 205.31,157.67 v1(205.7,157.28) 205.7,156.71 204.88,155.88 U6100.14 ; R6110.2 R6149.2
UNNAMED_7_CSC0805_I17_A:
  vias: v1(244.63,148.06)
UNNAMED_7_CSC0805_I24_A:
  vias: v1(210.22,154.04)
UNNAMED_8_CSC0402_I5_A: length 2.6
  TOP w0.102: R6996.2 293.78,132.78 C6999.1 v1(294.04,131.94) 294.04,131.22 R6995.1
UNNAMED_9_AOZ1268QI02_I10_22: length 4.6
  TOP w0.254: R6211.2 149.89,162.04 v2(149,161.15) R6207.2
  BOTTOM w0.381: v1(151.42,162.29) C6211.1
UNNAMED_9_AOZ1268QI02_I10_AIN: length 3.5
  TOP w0.254: v2(152.25,161.3) 152.1,161.15 R6207.1
  BOTTOM w0.254: U6200.7 154.47,161.78 152.56,161.78 152.25,161.48 v2(152.25,161.3)
UNNAMED_9_AOZ1268QI02_I10_BST: length 2.7
  BOTTOM w0.356: U6200.20 156.09,157.47 156.07,157.45 156.07,157.43 155.29,156.65 R6215.1
  BOTTOM w0.381: v1(155.23,155.56) 155.29,155.62 R6215.1
UNNAMED_9_AOZ1268QI02_I10_FB: length 5.7
  BOTTOM w0.254: U6200.5 153.44,160.66 153.34,160.77 152.43,160.77 152.03,160.36 152.03,159.17 v1(151.47,158.61) R6200.2 150.7,158.61 R6201.1
UNNAMED_9_AOZ1268QI02_I10_PFM: length 5.6
  BOTTOM w0.254: v1(150.53,155.94) 150.78,156.2 150.78,156.75 R6209.2 150.7,156.87 152.5,158.67 152.5,159.02 153.14,159.66 U6200.3
UNNAMED_9_AOZ1268QI02_I10_SS: length 4.4
  BOTTOM w0.102: C6217.2 153.06,156.75 152.72,156.41 152.72,154.91 152.94,154.7 v1(152.93,154.7)
  BOTTOM w0.254: C6217.2 154.14,157.69 154.48,157.69 154.59,157.8 U6200.23
UNNAMED_9_AOZ1268QI02_I10_TON: length 3
  TOP w0.254: R6211.1 152.53,162.04 152.94,161.63 v3(152.94,161.28)
  BOTTOM w0.254: U6200.6 153.7,161.31 152.95,161.31 152.94,161.3 v3(152.94,161.28)
UNNAMED_9_AOZ1268QI02_I10_VCC: length 6
  BOTTOM w0.254: v1(154.97,154.29) 154.67,154.59 R6210.1 154.61,155.12 154.61,156.3 154.17,156.75 C6216.2 154.08,156.96 154.41,157.29 155.35,157.29 155.59,157.52 U6200.21
UNNAMED_9_CSC0402_I20_A: length 2.1
  BOTTOM w0.381: C7620.1 155.78,150.35 v1(156.62,150.35) R7620.2
UNNAMED_9_CSC0402_I32_A: length 1.9
  BOTTOM w0.381: C6215.1 v1(156.5,155.56) 156.5,156.57 R6215.2
UNNAMED_9_CSC0402_I67_A: length 2.3
  BOTTOM w0.254: 176.86,151.75 U6240.10
  BOTTOM w0.381: v1(176.87,149.72) 176.86,149.72 C6242.1 176.86,151.75
UNNAMED_10_AOZ1268QI02_I13_22: length 4
  BOTTOM w0.254: 123.45,100.82 122.21,100.82 121.91,101.12 121.57,101.12 R6307.2 121.32,101.12 120.68,101.12 R6311.2
  BOTTOM w0.381: C6311.1 125,102.98
  vias: v1(125.64,103.87)
UNNAMED_10_AOZ1268QI02_I13_AIN: length 1.7
  BOTTOM w0.254: U6300.7 122.78,99.93 121.65,99.93 R6307.1
UNNAMED_10_AOZ1268QI02_I13_BST: length 3.3
  BOTTOM w0.356: R6315.1 125.38,94.6 124.49,95.49 U6300.20
  BOTTOM w0.508: v1(124.82,93.53) 125.42,94.13 R6315.1
UNNAMED_10_AOZ1268QI02_I13_FB: length 3.5
  BOTTOM w0.254: R6300.2 120.43,98.2 R6301.1 120.43,98.91 v1(120.56,99.03) 120.57,99.05 121.55,99.05 121.7,98.91 U6300.5
UNNAMED_10_AOZ1268QI02_I13_PFM: length 4.8
  TOP w0.381: v3(118.95,96.56) 119.63,96.56 R6309.2
  BOTTOM w0.254: U6300.3 121.7,97.91 121.04,97.24 121.04,97.19 120.68,96.84 119.66,96.84 119.46,96.63 119.03,96.63 v3(118.95,96.56)
UNNAMED_10_AOZ1268QI02_I13_SS: length 2.1
  BOTTOM w0.254: v1(121.88,95.41) 122.14,95.15 C6317.2 122.71,95.9 U6300.23
UNNAMED_10_AOZ1268QI02_I13_TON: length 2
  BOTTOM w0.254: U6300.6 121.29,99.41 R6311.1
UNNAMED_10_AOZ1268QI02_I13_VCC: length 3.1
  TOP w0.254: R6310.1 124.07,95.15 v3(124.37,94.85)
  BOTTOM w0.254: U6300.21 123.99,95.74 123.98,95.74 123.6,95.36 C6316.2 124.07,95.15 v3(124.37,94.85)
UNNAMED_10_CSC0402_I22_A: length 2.8
  BOTTOM w0.381: C7630.1 132.83,102.65 132.6,102.87 v1(132.35,102.87) 132.03,102.87 131.82,102.67 R7630.2
UNNAMED_10_CSC0402_I24_A: length 2.6
  BOTTOM w0.381: C6315.1 127.07,94.17 126.62,94.63
  BOTTOM w0.508: R6315.2 126.62,94.63 126.47,94.48 126.47,93.91 v1(126.09,93.53)
UNNAMED_11_CSC0402_I9_B: length 4.1
  TOP w0.356: U6350.6 R6351.1
  TOP w0.381: C6352.2 103.11,143.88 R6351.1 ; C6352.2 102.78,143.5 v1(102.65,143.37) ; C6352.2 103.49,142.61 R6350.1
UNNAMED_11_CSC0603_I5_A: length 1.3
  TOP w0.102: C6360.1 v1(103.16,147.69)
UNNAMED_12_CSC0402_I9_B: length 4
  TOP w0.305: v1(246.54,83.81) 246.79,84.06 U6450.6
  TOP w0.381: C6452.2 v1(246.54,83.81) 246.75,83.6 R6450.1 R6451.1
UNNAMED_12_CSC0603_I5_A: length 1.5
  TOP w0.508: v1(251.75,81.01) 251.11,81.65 251.11,82.28
UNNAMED_14_CSD97374CQ4M_I37_4: length 2.1
  TOP w0.381: v1(233.99,66.43) 233.98,66.44 R7661.1 232.95,65.57 v5(232.82,65.44)
UNNAMED_14_IDUT4PIN_I38_3: length 7.1
  BOTTOM w0.254: L6610.3 230.79,67.75 230.23,68.31 230.23,69.86 228.95,71.15 R6616.1
UNNAMED_14_RSC0402_I20_B: length 0.9
  BOTTOM w0.254: R6617.1 228.1,71.91 R6618.2
UNNAMED_15_CSC0402_I258_B: length 4.6
  TOP w0.102: Q2971.3 296.33,119.25 296.78,118.81 v1(297.62,118.81) 297.68,118.87 R2970.1 297.59,119.6 297.21,119.98 297.21,121 297.53,121.32 C2970.2
UNNAMED_15_CSC0402_I347_A: length 2.8
  BOTTOM w0.254: R7110.2 212.12,149.55 C7110.1 v1(210.21,149.55) R7111.1
UNNAMED_15_NMOS4D1S_I306_G: length 21.1
  L6 w0.381: v3(123.17,87.51) 123.78,86.9 125,86.9 126.18,85.73 127.51,85.73 127.89,86.11 135.38,86.11 136.8,84.69 v2(137.22,84.69)
  BOTTOM w0.381: v3(123.17,87.51) 123.17,87.69 122.83,88.04 Q7150.6 122.81,88.46 R7151.2 ; v2(137.22,84.69) 135.03,84.69 134.46,84.12 Q7151.3
UNNAMED_15_NMOS_I428_D: length 2.8
  TOP w0.381: R7100.2 301.57,106.72 v1(301.45,106.59) 302.43,106.59 302.61,106.77 Q7101.3
UNNAMED_15_NMOS_I430_D: length 2.8
  BOTTOM w0.381: R7152.2 126.57,87.06 v1(126.52,87.11) Q7154.3
UNNAMED_15_NMOS_I431_D: length 3.1
  TOP w0.381: Q7155.3 167.44,146.88 R7153.1 165.81,146.88 v1(165.51,147.18)
UNNAMED_15_NMOSDUALC_I182_D2: length 1.8
  BOTTOM w0.381: Q7051.3 119.84,89.99 R7050.2 120.61,90.61 v1(120.63,90.59)
UNNAMED_15_NMOSDUALC_I196_D2: length 2.1
  BOTTOM w0.381: Q7150.3 124.13,91.27 R7150.2 123.6,91.38 v1(123.35,91.63)
UNNAMED_15_NMOSDUALC_I254_D1: length 9.9
  TOP w0.254: Q7056.6 300.98,118.56 v1(301.2,118.35)
  TOP w0.381: Q7056.6 300.11,118.98 299.86,119.24 298.48,119.24 298.28,119.03 298.28,118.58 297.85,118.15 297.29,118.15 297.09,118.35 294.01,118.35 293.28,119.09 R2972.2
UNNAMED_15_NMOSDUALC_I254_D2: length 3.9
  TOP w0.102: Q7056.3 298.81,121.21 R2971.2 298.91,121.32 v1(299.63,122.03) ; Q7056.3 Q7056.2 ; Q7056.3 297.7,120.46 R2970.2
UNNAMED_15_RSC0402_I409_A: length 3.7
  TOP w0.102: R7115.1 209.84,155.86 209.84,155.13 R7117.1 ; R7114.1 210.47,155.86 210.47,155.13 R7116.1 R7117.1 ; R7117.1 209.84,154.97 209.84,154.29 v1(209.71,154.16)
UNNAMED_16_2DC3092000111F_I111_: length 3.8
  TOP w0.381: C6020.1 310.42,142.1 ; 310.97,141.97 D6015.1 ; D6015.1 312.21,141.97 ; D6015.1 311.59,141.41 ; D6015.1 311.59,142.54 ; C6016.1 309.4,142.1
  vias: v1(310.2,142.73)
UNNAMED_16_BP02083B24B19H_I11_1: length 25.8
  TOP w0.381: R6053.2 163.71,60.95 v1(162.08,62.57) 157.49,62.57 v2(157.13,62.22)
  BOTTOM w0.381: v2(157.13,62.22) 157.17,62.25 157.17,65.22 156.62,65.77 155.23,65.77 154.82,66.17 C7501.2 154.6,66.63 D7505.2 154.46,67.68 150.4,63.61 149.06,63.61 CN6050.4
UNNAMED_16_BP02083B24B19H_I11_2: length 30.7
  TOP w0.381: R6057.2 162.25,61.41 161.96,61.71 v1(158.66,61.71) v2(157.63,61.71)
  BOTTOM w0.381: v2(157.63,61.71) 157.68,61.75 157.68,65.52 157.39,65.81 157.39,68.18 157,68.57 155.48,68.57 154.72,69.33 D7506.2 154.21,69.33 149.72,64.84 C7503.1 147.23,64.78 145.17,62.72 144.17,62.72 CN6050.6
UNNAMED_16_BP02083B24B19H_I112_: length 23.5
  TOP w0.381: R6051.2 165.47,61.37 163.25,63.59 v1(157.97,63.59) 155.33,63.59 v2(154.34,62.6)
  BOTTOM w0.381: v2(154.34,62.6) 154.95,63.21 C7500.2 154.97,63.76 154.97,64.64 D7504.2 151.68,62.09 149.54,62.09 CN6050.3
UNNAMED_17_CSC0402_I437_A: length 118
  TOP w0.102: R7017.2 294.55,126.86 295.59,127.9 v2(295.59,128.23) 296.07,128.72 299.04,128.72 299.37,128.38 299.75,128.38 300.34,127.79 C7001.1 300.51,128.55 U7000.2
  L6 w0.102: v2(295.59,128.23) 293.03,130.78 287.51,130.78 286.69,131.61 284.9,131.61 284.9,131.61 284.78,131.61 284.61,131.61 284.45,131.61 283.79,132.26 282.66,132.26 282.22,132.71 282.22,132.71 279.3,135.63 279.3,135.96 279.3,135.96 279.3,136.89 273.53,142.66 265.37,142.66 263.05,144.99 251.26,144.99 251.2,144.92 246.27,144.92 244.02,147.16 244.02,147.33 244.02,158.36 242.35,160.03 234.15,160.03 232.35,158.23 223.17,158.23 218.73,153.78 v2(216.57,153.78)
  BOTTOM w0.102: v2(216.57,153.78) 216.1,153.32 R7000.1
