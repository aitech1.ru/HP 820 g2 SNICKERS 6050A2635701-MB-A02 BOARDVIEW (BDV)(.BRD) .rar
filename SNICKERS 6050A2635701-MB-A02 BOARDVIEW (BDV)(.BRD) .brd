# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Nets (continued)
UNNAMED_10_AOZ1268QI02_I13_22: C6310.1(A) C6311.1(A) PAD6310.2 R6307.2(B) R6311.2(B) U6300.8 U6300.9 U6300.22
UNNAMED_10_AOZ1268QI02_I13_AIN: R6307.1(A) U6300.7(AIN)
UNNAMED_10_AOZ1268QI02_I13_BST: R6315.1(A) U6300.20(BST)
UNNAMED_10_AOZ1268QI02_I13_FB: R6300.2(B) R6301.1(A) U6300.5(FB)
UNNAMED_10_AOZ1268QI02_I13_PFM: R6309.2(B) U6300.3(PFM)
UNNAMED_10_AOZ1268QI02_I13_SS: C6317.2(B) U6300.23(SS)
UNNAMED_10_AOZ1268QI02_I13_TON: R6311.1(A) U6300.6(TON)
UNNAMED_10_AOZ1268QI02_I13_VCC: C6316.2(B) R6310.1(A) U6300.21(VCC)
UNNAMED_10_CSC0402_I22_A: C7630.1(A) R7630.2(B)
UNNAMED_10_CSC0402_I24_A: C6315.1(A) R6315.2(B)
UNNAMED_11_CSC0402_I9_B: C6352.2(B) R6350.1(A) R6351.1(A) U6350.6
UNNAMED_11_CSC0603_I5_A: C6360.1(A) PAD6360.2 U6350.8 U6350.9 U6350.10
UNNAMED_12_CSC0402_I9_B: C6452.2(B) R6450.1(A) R6451.1(A) U6450.6
UNNAMED_12_CSC0603_I5_A: C6460.1(A) PAD6460.2 U6450.8 U6450.9 U6450.10
UNNAMED_14_CSD97374CQ4M_I37_4: L6610.1 R7661.1(A) U6610.4
UNNAMED_14_IDUT4PIN_I38_3: L6610.3 R6616.1(A)
UNNAMED_14_RSC0402_I20_B: R6617.1(A) R6618.2(B)
UNNAMED_15_CSC0402_I258_B: C2970.2(B) Q2971.3(G) R2970.1(A)
UNNAMED_15_CSC0402_I347_A: C7110.1(A) R7110.2(B) R7111.1(A)
UNNAMED_15_NMOS4D1S_I306_G: Q7150.6(D1) Q7151.3(G) R7151.2(B)
UNNAMED_15_NMOS_I428_D: Q7101.3(D) R7100.2(B)
UNNAMED_15_NMOS_I430_D: Q7154.3(D) R7152.2(B)
UNNAMED_15_NMOS_I431_D: Q7155.3(D) R7153.1(A)
UNNAMED_15_NMOSDUALC_I182_D2: Q7051.3(D2) R7050.2(B)
UNNAMED_15_NMOSDUALC_I196_D2: Q7150.3(D2) R7150.2(B)
UNNAMED_15_NMOSDUALC_I254_D1: Q7056.6(D1) R2972.2(B)
UNNAMED_15_NMOSDUALC_I254_D2: Q7056.2(G1) Q7056.3(D2) R2970.2(B) R2971.2(B)
UNNAMED_15_RSC0402_I409_A: R7114.1(A) R7115.1(A) R7116.1(A) R7117.1(A)
UNNAMED_16_2DC3092000111F_I111_: C6016.1(A) C6020.1(A) D6015.1 JACK6000.1 JACK6000.3 L6035.2
UNNAMED_16_BP02083B24B19H_I11_1: C7501.2(B) CN6050.4 D7505.2 R6053.2(B)
UNNAMED_16_BP02083B24B19H_I11_2: C7503.1(A) CN6050.6 D7506.2 R6057.2(B)
UNNAMED_16_BP02083B24B19H_I112_: C7500.2(B) CN6050.3 D7504.2 R6051.2(B)
UNNAMED_17_CSC0402_I437_A: C7001.1(A) R7000.1(A) R7017.2(B) U7000.2(IN-A)
UNNAMED_17_NMOS4D3S_I45_G: Q7350.3(D2) Q7351.4(G) Q7353.4(G) R7354.1(A)
UNNAMED_17_NMOS_I432_D: Q7355.3(D) R7355.1(A)
UNNAMED_17_NMOS_I432_G: Q7350.5(G2) Q7350.6(D1) Q7352.1(G) Q7355.1(G) R7350.2(B)
UNNAMED_17_NMOS_I433_D: Q7352.3(D) R7353.2(B)
UNNAMED_18_COMPARATOR2_I225_: R7407.1(A) R7409.2(B) U7400.5(+IN)
UNNAMED_18_COMPARATOR2_I225__1: C7402.2(B) R7410.2(B) R7412.2(B) U7400.2(-IN) U7400.6(-IN)
UNNAMED_18_COMPARATOR2_I226_: R7406.1(A) R7408.2(B) U7400.3(+IN)
UNNAMED_18_COMPARATOR_I211_1: R2953.1(A) R2955.2(B) U2950.1
UNNAMED_18_COMPARATOR_I211_3: C2950.1(A) R2950.2(B) R2951.2(B) U2950.3
UNNAMED_18_CSC0402_I9_A: C7401.1(A) R7401.1(A) R7408.1(A) R7425.2(B) R7426.2(B) R7428.2(B)
UNNAMED_18_CSC0402_I27_A: C7403.1(A) D7400.3 R7405.2(B) R7409.1(A) R7416.2(B) R7418.1(A)
UNNAMED_18_CSC0402_I96_A: C2951.1(A) D2951.2 R2956.1(A)
UNNAMED_18_CSC0402_I96_B: C2951.2(B) R2952.2(B) R2956.2(B)
UNNAMED_18_CSC0402_I112_A: C2952.1(A) D2951.3 R2955.1(A) R2958.2(B) R2959.2(B) R2960.2(B)
UNNAMED_18_DB3X313J0L_I216_1: D2951.1 R2957.2(B)
UNNAMED_18_DB3X313J0L_I217_1: D7400.1 R7414.2(B)
UNNAMED_18_DB3X313J0L_I217_2: D7400.2 R7415.2(B)
UNNAMED_19_502710040N001_I72_4: CN4300.4 R4302.2(B)
UNNAMED_19_CSC0402_I74_A: C4411.1(A) R4412.2(B) U4411.5(VCC)
UNNAMED_19_G708T1U_I75_SET: R4411.1(A) U4411.1(SET)
UNNAMED_19_G780P81U_I726_4: R5049.2(B) U5000.4
UNNAMED_19_NMOSDUALC_I66_D1: Q4300.6(D1) R4302.1(A) R4303.1(A)
UNNAMED_19_NMOSDUALC_I66_D2: Q4300.1(S1) Q4300.3(D2)
UNNAMED_20_NMOSDUALC_I83_D2: Q4926.2(G1) Q4926.3(D2) R4931.2(B)
UNNAMED_21_CL8064701477702SR1_1: R4541.2(B) U4555.AV60(SM_RCOMP1)
UNNAMED_21_CL8064701477702SR1_2: R4540.2(B) U4555.AU61(SM_RCOMP2)
UNNAMED_21_CL8064701477702SR170: R4518.2(B) U4555.AU60(SM_RCOMP0)
UNNAMED_22_CL8064701477702SR1_1: TP4503.1 U4555.Y4(SPI_CS1*)
UNNAMED_22_CL8064701477702SR1_2: TP4504.1 U4555.AC2(SPI_CS2*)
UNNAMED_22_CL8064701477702SR1_3: R4936.1(A) U4555.AV5(DPWROK)
UNNAMED_22_CL8064701477702SR1_4: R4742.2(B) U4555.AW7(DSWVRMEN)
UNNAMED_22_CL8064701477702SR1_5: R4815.2(B) U4555.AK2(SUSACK*)
UNNAMED_22_CL8064701477702SR1_6: R4802.2(B) U4555.AG2(SYS_PWROK)
UNNAMED_22_CL8064701477702SR170: R4840.1(A) U4555.AU4(SML1ALERT/PCHHOT/GPIO73*)
UNNAMED_23_CL8064701477702SR1_1: TP4531.1 U4555.D3(SDIO_D0/GPIO66)
UNNAMED_23_CL8064701477702SR170: R4748.1(A) U4555.AW15(PCH_OPI_RCOMP)
UNNAMED_24_CL8064701477702SR1_1: R4866.2(B) U4555.U7(GPIO55)
UNNAMED_24_CL8064701477702SR1_2: TP4509.1 U4555.AD4(PME*)
UNNAMED_24_CL8064701477702SR170: R4544.2(B) U4555.D20(EDP_RCOMP)
UNNAMED_25_CL8064701477702SR1_1: TP90664.1 U4555.AL32(SB_ODT0)
UNNAMED_25_CL8064701477702SR170: TP90665.1 U4555.AP32(SA_ODT0)
UNNAMED_25_CSC0402_I269_B: C4121.2(B) R4110.2(B)
UNNAMED_25_CSC0402_I270_B: C4122.2(B) R4111.2(B)
UNNAMED_25_CSC0402_I271_B: C4124.2(B) R4136.2(B)
UNNAMED_26_CL8064701477702SR1_1: R4811.2(B) U4555.B27(PCIE_IREF)
UNNAMED_26_CL8064701477702SR1_2: R4812.2(B) U4555.A27(PCIE_RCOMP)
UNNAMED_26_CL8064701477702SR1_3: R4756.1(A) U4555.AJ10(USBRBIAS*) U4555.AJ11(USBRBIAS)
UNNAMED_26_CL8064701477702SR170: R4700.2(B) U4555.AT1(OC1/GPIO41*)
UNNAMED_27_CL8064701477702SR1_1: R4901.2(B) U4555.AU8(HDA_RST/I2S_MCLK*)
UNNAMED_27_CL8064701477702SR1_2: R4903.2(B) U4555.AV11(HDA_SYNC/I2S0_SFRM)
UNNAMED_27_CL8064701477702SR1_3: R4852.1(A) U4555.C12(SATA_RCOMP)
UNNAMED_27_CL8064701477702SR170: R4910.2(B) U4555.AW8(HDA_BCLK/I2S0_SCLK)
UNNAMED_27_CSC0402_I6_A: C4764.1(A) R4834.2(B) U4555.AV6(SRTCRST*)
UNNAMED_27_LBSS84LT1G_I270_D: Q4754.2(S) Q4755.3(D)
UNNAMED_27_LBSS84LT1G_I270_G: Q4755.1(G) R4863.2(B)
UNNAMED_27_LBSS84LT1G_I270_S: Q4755.2(S) R4861.2(B)
UNNAMED_27_NMOS_I61_G: Q4756.1(G) R4899.1(A)
UNNAMED_27_NMOS_I61_S: Q4756.2(S) R4869.2(B) R4874.1(A)
UNNAMED_27_RSC0402_I4_A: D4750.1(A1) R4832.1(A)
UNNAMED_28_CL8064701477702SR1_1: R4520.1(A) U4555.AY15(PROC_OPI_RCOMP)
UNNAMED_28_CL8064701477702SR170: R4519.2(B) U4555.V63(CFG_RCOMP)
UNNAMED_29_CL8064701477702SR1_1: R4875.2(B) U4555.AH13(DCPSUS2)
UNNAMED_29_CL8064701477702SR1_2: R4850.2(B) U4555.J13(DCPSUS3)
UNNAMED_29_CL8064701477702SR1_3: R4855.1(A) U4555.AB8(DCPSUS4)
UNNAMED_29_CL8064701477702SR1_4: TP4703.1 U4555.AC20(RSVD_AC20)
UNNAMED_29_CL8064701477702SR170: R4877.1(A) U4555.AD8(DCPSUS1_AD8) U4555.AD10(DCPSUS1_AD10)
UNNAMED_29_CSC0402_I167_B: C4712.2(B) U4555.AE7(DCPRTC)
UNNAMED_29_CSC0402_I251_A: C4714.1(A) U4555.AG19(DCPSUSBYP_AG19) U4555.AG20(DCPSUSBYP_AG20)
UNNAMED_29_CSC0402_I265_A: C4762.1(A) R4701.1(A) U4555.T9(VCCSDIO_T9) U4555.U8(VCCSDIO_U8)
UNNAMED_29_CSC0402_I282_A: C4728.1(A) R4535.2(B) U4555.AH10(VCCDSW3_3)
UNNAMED_29_CSC0402_I453_A: C4943.1(A) Q4505.G Q4942.6(D1) R4904.2(B)
UNNAMED_29_NMOSDUALC_I435_D2: Q4942.2(G1) Q4942.3(D2) R4900.2(B)
UNNAMED_30_CL8064701477702SR1_1: TP4565.1 U4555.N61(RSVD_TP_N61)
UNNAMED_30_CL8064701477702SR1_2: TP4562.1 U4555.P60(RSVD_TP_P60)
UNNAMED_30_CL8064701477702SR1_3: TP4563.1 U4555.P61(RSVD_TP_P61)
UNNAMED_30_CL8064701477702SR1_4: R4525.1(A) U4555.L62(VIDALERT*)
UNNAMED_30_CL8064701477702SR170: TP4564.1 U4555.N59(RSVD_TP_N59)
UNNAMED_32_NMOS_I61_G: Q4101.1(G) Q4102.C R4116.2(B)
UNNAMED_32_NMOS_I514_S: Q4100.2(S) R4117.1(A) R4118.1(A) R4119.1(A) R4120.1(A)
UNNAMED_32_NPNB_I568_B: Q4102.B R4121.2(B) R4123.1(A)
UNNAMED_34_PS8338AQFN60GTR_I1_1: R5313.2(B) R5314.2(B) U5301.8(PEQ)
UNNAMED_34_PS8338AQFN60GTR_I1_2: R5309.2(B) U5301.60(PI0/SDA_CTL)
UNNAMED_34_PS8338AQFN60GTR_I1_3: R5311.2(B) R5312.2(B) U5301.1(PI1/SCL_CTL)
UNNAMED_34_PS8338AQFN60GTR_I1_4: R5315.1(A) U5301.20(REXT)
UNNAMED_34_PS8338AQFN60GTR_I190: R5310.2(B) U5301.59(CFG0)
UNNAMED_35_PS8338AQFN60GTR_I1_1: R5409.2(B) U5401.60(PI0/SDA_CTL)
UNNAMED_35_PS8338AQFN60GTR_I1_2: R5415.1(A) U5401.20(REXT)
UNNAMED_35_PS8338AQFN60GTR_I193: R5410.2(B) U5401.59(CFG0)
UNNAMED_36_BEADSINGLE_I625_INA: C3087.1(A) L3066.1(INA) U3065.27
UNNAMED_36_CSC0402_I588_A: C3094.1(A) R3067.1(A) TP3066.1 U3065.16
UNNAMED_36_CSC0402_I612_B: C3069.2(B) R3061.2(B) R3062.2(B) U3065.2
UNNAMED_36_CSC0402_I615_B: C3070.2(B) R3062.1(A) R3065.1
UNNAMED_36_CSC0402_I617_B: C3077.2(B) R3063.2(B) R3065.2 U3065.5
UNNAMED_36_CSC0402_I618_A: C3073.1(A) U3065.11
UNNAMED_36_CSC0402_I623_A: C3074.1(A) R3064.2(B) R3082.2(B) R3094.1(A) U3065.14
UNNAMED_36_CSC0402_I627_A: C3067.1(A) C3068.1(A) R3081.1(A) U3065.35
UNNAMED_36_CSC0402_I632_A: C3090.1(A) C3091.1(A) R3075.2(B) U3065.38
UNNAMED_36_IDUTSINGLE_I650_INA: L3068.1(INA) U3065.39
UNNAMED_36_PTN3355BS_I608_15: R3078.1(A) TP3065.1 U3065.15
UNNAMED_36_PTN3355BS_I608_17: R3083.2(B) R3093.1(A) R3095.1(A) U3065.17
UNNAMED_36_PTN3355BS_I608_18: TP3067.1 U3065.18
UNNAMED_36_PTN3355BS_I608_19: TP3068.1 U3065.19
UNNAMED_36_PTN3355BS_I608_30: R3068.2(B) U3065.30
UNNAMED_36_PTN3355BS_I608_37: R3074.2(B) R3076.2(B) U3065.37
UNNAMED_36_PTN3355BS_I608_40: R3092.2(B) U3065.40
UNNAMED_37_CN204G_I498_14: CN3300.14 R3302.1(A)
UNNAMED_37_NCT3521U_I501_4: R3305.2(B) U3300.4
UNNAMED_38_CN404G_I622_6: CN3000.6 R3013.2(B)
UNNAMED_38_CN404G_I622_12: CN3000.12 TP3000.1
UNNAMED_38_NCT3521U_I599_4: R3001.1(A) U3000.4
UNNAMED_40_APCI0020P001A01_I3_1: CN1951.75(GND14) R1952.1(A)
UNNAMED_40_APCI0020P001A01_I3_2: CN1951.69(PEDET) Q1950.1(G) R1953.2(B) R1955.2(B)
UNNAMED_40_APCI0020P001A01_I3_3: CN1951.68(SUSCLK) TP1951.1
UNNAMED_40_APCI0020P001A01_I375: CN1951.12(3.3VAUX3) R1956.1(A)
UNNAMED_41_CSC0402_I174_B: C2578.2(B) R2560.2(B) R2594.2(B) U2550.48(VBUS_DET/GPIO2)
UNNAMED_41_CSC0402_I305_A: C2583.1(A) R2564.2(B) U2550.43(TDO/UART_TX/GPIO7/OCS4)
UNNAMED_41_CSC0402_I692_A: C2575.1(A) R2571.2(B) R2592.2(B) U2550.50(RESET*)
UNNAMED_41_DB3X313J0L_I691_3: D2551.3 R2569.2(B) R2571.1(A)
UNNAMED_41_MX25L1606EM2I12G_I66: R2572.2(B) U2550.39(VSS_1) U2551.1(CS#)
UNNAMED_41_MX25L1606EM2I12G_I_1: R2580.2(B) U2551.7(HOLD#)
UNNAMED_41_MX25L1606EM2I12G_I_2: R2575.2(B) R2591.1(A) U2550.40(VDD33) U2551.6(SCLK)
UNNAMED_41_MX25L1606EM2I12G_I_3: R2570.2(B) R2573.2(B) U2550.41(VSS) U2551.5(SI_SIO0)
UNNAMED_41_MX25L1606EM2I12G_I_4: R2590.2(B) U2550.42(VDD33_5) U2551.2(SO_SIO1)
UNNAMED_41_MX25L1606EM2I12G_I_5: R2581.2(B) U2551.3(WP#_ACC)
UNNAMED_41_RSC0402_I42_B: R2553.2(B) U2550.64(RBIAS)
UNNAMED_41_RSC0402_I206_A: R2574.1(A) R2593.1(A) U2550.45(TRST/GPIO0/LED0)
UNNAMED_41_RSC0402_I244_A: R2554.1(A) U2550.49(TEST)
UNNAMED_41_RSC0402_I245_A: R2555.1(A) U2550.60(ATEST)
UNNAMED_41_RSC0402_I273_A: R2556.1(A) R2558.2(B) U2550.38(VDD33_6)
UNNAMED_41_RSC0402_I275_B: R2557.2(B) R2559.1(A) U2550.37(VSS_2)
UNNAMED_41_RSC0402_I666_A: R2567.1(A) U2550.32(PRT_CTL4/GPIO11)
UNNAMED_41_RSC0402_I674_A: R2561.2(B) R2585.1(A) U2550.46(TCK/GPIO1/OCS1/LED1)
UNNAMED_41_RSC0402_I681_A: R2576.1(A) U2550.36(PRT_CTL1/GPIO8)
UNNAMED_42_ANDGATE_I507_4: U2401.4 U2402.4
UNNAMED_42_BD82034FVJGE2_I495_4: U2400.4 U2403.4
UNNAMED_42_RSC0402_I117_B: R2512.2(B) U2511.16
UNNAMED_42_RSC0402_I343_A: R2511.1(A) U2511.15
UNNAMED_42_RSC0402_I344_B: R2514.2(B) R2515.1(A) U2511.4
UNNAMED_44_505050064N001_I156_1: C2200.1(A) C2201.1(A) CN2200.1 R2202.1(A) R2203.2(B)
UNNAMED_45_HP3DC2TR_I54_INT2: R1010.2(B) U1000.9(INT2)
UNNAMED_45_HP3DC2TR_I54_SDOSA0: R1000.1(A) R1001.2(B) U1000.7(SDO_SA0)
UNNAMED_45_NMOS_I80_D: Q1000.3(D) R1006.2(B)
UNNAMED_45_NMOS_I80_G: Q1000.1(G) R1010.1(A)
UNNAMED_45_NMOS_I80_S: Q1000.2(S) Q1001.3(D)
UNNAMED_45_NMOS_I81_G: Q1001.1(G) Q1002.3(D) R1007.2(B)
UNNAMED_45_NMOS_I82_G: Q1002.1(G) R1008.2(B)
UNNAMED_46_5023802471001_I103_1: CN375.22 R343.2(B)
UNNAMED_46_5023802471001_I103_2: CN375.3 CN375.23
UNNAMED_46_5023802471001_I1031_: CN375.12 R372.2(B)
UNNAMED_46_CSC0402_I309_A: C301.1(A) R300.2(B) U300.42(ADC2/GPIO060)
UNNAMED_46_CSC0402_I625_B: C304.2(B) R302.2(B) U300.39(ADC3/GPIO061)
UNNAMED_46_CSC0402_I856_A: C306.1(A) R316.2(B) U300.43(ADC1/GPIO057)
UNNAMED_46_CSC0402_I857_A: C307.1(A) R315.2(B) U300.44(ADC_TO_PWM_IN/ADC0/GPIO056)
UNNAMED_46_CSC0603_I1002_A: C302.1(A) U300.15(CAP)
UNNAMED_46_MECC1322NU_I1013_ADC: R301.1(A) U300.38(ADC4/GPIO062)
UNNAMED_46_MECC1322NU_I1013_G_1: R328.1(A) U300.80(GPIO132/PECI_DAT)
UNNAMED_46_MECC1322NU_I1013_G_2: R329.1(A) R330.1(A) U300.85(GPIO143/NRSMRST)
UNNAMED_46_MECC1322NU_I1013_G_3: R362.2(B) U300.2(GPIO153/PVT_SCLK)
UNNAMED_46_MECC1322NU_I1013_G_4: TP304.1 U300.86(GPIO162/RXD)
UNNAMED_46_MECC1322NU_I1013_G_5: TP303.1 U300.87(GPIO165/TXD/SHD_NCS1)
UNNAMED_46_MECC1322NU_I1013_G_6: R319.2(B) U300.41(GPIO206)
UNNAMED_46_MECC1322NU_I1013_GPI: R396.1(A) U300.127(GPIO054/PVT_MOSI)
UNNAMED_46_MECC1322NU_I1013_SER: R333.1(A) U300.57(SER_IRQ/GPIO115)
UNNAMED_46_MECC1322NU_I1013_XTA: R382.1(A) U300.69(XTAL2)
UNNAMED_46_RSC0402_I665_A: R344.1(A) R345.1(A) U366.3
UNNAMED_46_RSC0402_I670_A: R346.1(A) U366.7
UNNAMED_47_CN342G_I454_2: CN300.2 R392.2(B)
UNNAMED_47_CN342G_I454_3: CN300.3 R393.2(B)
UNNAMED_47_CN342G_I454_5: CN300.5 R394.2(B)
UNNAMED_47_NMOS_I61_D: Q300.1 Q301.3(D) R351.1(A)
UNNAMED_47_NMOSDUALC_I486_D2: Q320.1(S1) Q320.3(D2)
UNNAMED_47_NMOSDUALC_I486_G1: Q320.2(G1) R323.2(B) R334.2(B)
UNNAMED_48_RSC0402_I140_B: R3501.2(B) R3502.1(A) U3500.7
UNNAMED_48_RSC0402_I166_B: R3503.2(B) U3500.6
UNNAMED_48_RSC0402_I170_B: R3507.2(B) U3500.9
UNNAMED_49_CSC0402_I358_A: C475.1(A) C476.1(A) C477.1(A) C478.1(A) C479.1(A) U470.3(TDCT) U470.4 U470.9 U470.10
UNNAMED_49_CSC0603_I402_A: C472.1(A) U470.16
UNNAMED_49_CSC0603_I402_B: C472.2(B) R472.2(B)
UNNAMED_49_CSC0603_I403_A: C473.1(A) U470.15(TXTC)
UNNAMED_49_CSC0603_I403_B: C473.2(B) R473.2(B)
UNNAMED_49_CSC0603_I404_A: C471.1(A) U470.21
UNNAMED_49_CSC0603_I404_B: C471.2(B) R471.2(B)
UNNAMED_49_CSC0603_I405_A: C470.1(A) U470.22
UNNAMED_49_CSC0603_I405_B: C470.2(B) R470.2(B)
UNNAMED_49_CSCSPECIAL_I439_A: C474.1(A) R470.1(A) R471.1(A) R472.1(A) R473.1(A)
UNNAMED_49_I218LM_I128_6: R499.2(B) U400.6
UNNAMED_49_I218LM_I128_12: R401.1(A) U400.12
UNNAMED_49_I218LM_I128_27: R403.2(B) U400.27
UNNAMED_49_I218LM_I128_30: R404.1(A) U400.30
UNNAMED_49_I218LM_I128_32: TP7.1 U400.32
UNNAMED_49_I218LM_I128_33: TP8.1 U400.33
UNNAMED_49_I218LM_I128_34: TP10.1 U400.34
UNNAMED_49_I218LM_I128_35: TP2.1 U400.35
UNNAMED_49_JM3611SP51AB117H_I45: JACK485.A2 JACK485.B2 Q485.3(D)
UNNAMED_49_LBSS84LT1G_I406_G: Q485.1(G) Q486.3(C) R485.2(B)
UNNAMED_49_NPND_I463_B: Q487.1(B) R487.1(A) R488.2(B)
UNNAMED_50_AS0BC26S30BE7H_I49_1: CN1300.58 TP1301.1
UNNAMED_50_AS0BC26S30BE7H_I49_2: CN1300.60 TP1302.1
UNNAMED_50_AS0BC26S30BE7H_I49_3: CN1300.62 TP1303.1
UNNAMED_50_AS0BC26S30BE7H_I497_: CN1300.56 Q1304.3(D) R1300.2(B)
UNNAMED_50_CSC0402_I241_B: C1308.2(B) Q1300.3(G) R1301.2(B)
UNNAMED_50_NMOS_I493_G: Q1304.1(G) R1307.2(B)
UNNAMED_50_NMOS_I493_S: D1300.1(A2) Q1304.2(S)
UNNAMED_50_RSC0402_I190_B: R1301.1(A) R1302.2(B) R1311.2(B)
UNNAMED_51_APCI0018P005A_I342_1: CN1400.21(WWAN/SSD IND GND-WWAN/OC-SSD) R1409.2(B)
UNNAMED_51_APCI0018P005A_I342_F: CN1400.6(FULL_CARD_POWER_OFF#) Q1401.3(D) R1407.2(B) R1417.1(A)
UNNAMED_51_APCI0018P005A_I342_R: CN1400.67(RESET#) R1410.2(B)
UNNAMED_51_APCI0018P005A_I342_W: CN1400.8(W_DISABLE#) D1410.1(A2) Q1402.3(D)
UNNAMED_51_CSC0402_I358_B: C1402.2(B) Q1400.3(G) R1403.1(A)
UNNAMED_54_ALC3228CG_I513_CBN: C521.2(B) U501.35(CBN)
UNNAMED_54_ALC3228CG_I513_CBP: C521.1(A) U501.36(CBP)
UNNAMED_54_ALC3228CG_I513_CPVEE: C516.1(A) U501.34(CPVEE)
UNNAMED_54_ALC3228CG_I513_GPIO0: R516.1(A) U501.2(GPIO0/DMIC-CLK)
UNNAMED_54_ALC3228CG_I513_JDREF: R502.1(A) U501.22(JDREF)
UNNAMED_54_ALC3228CG_I513_LDO: C513.1(A) U501.21(LDO-CAP)
UNNAMED_54_ALC3228CG_I513_LINE1: R532.1(A) U501.28(LINE1-L)
UNNAMED_54_ALC3228CG_I513_SDATA: R514.1(A) U501.8(SDATA-IN)
UNNAMED_54_ALC3228CG_I513_SEN_1: R531.1(A) U501.14(SENSE B)
UNNAMED_54_ALC3228CG_I513_SENSE: R515.1(A) R528.1(A) U501.13(SENSE A)
UNNAMED_54_ALC3228CG_I513_VREF: C504.1(A) C517.1(A) U501.25(VREF)
UNNAMED_54_CSC0402_I606_B: C640.2(B) R534.1(A)
UNNAMED_54_CSC0402_I607_B: C641.2(B) R535.1(A)
UNNAMED_54_CSC0402_I608_B: C642.2(B) R536.1(A)
UNNAMED_54_CSC0402_I609_B: C643.2(B) R537.1(A)
UNNAMED_54_CSC0603_I578_B: C526.2(B) R504.1(A) R507.1(A)
UNNAMED_54_CSC0603_I579_B: C514.2(B) R505.1(A) R506.1(A)
UNNAMED_54_DB3X313J0L_I629_2: D500.2 R511.2(B) R533.2(B)
UNNAMED_54_DB3X313J0L_I631_2: D501.2 R501.1(A)
UNNAMED_54_NMOS_I641_D: Q501.3(D) R503.2(B)
UNNAMED_55_2SJ3005001211_I441_7: C603.1(A) JACK600.7 L602.1(INA)
UNNAMED_55_BEADSINGLE_I549_INA: L550.1(INA) R568.2(B)
UNNAMED_55_BEADSINGLE_I550_INA: L551.1(INA) R569.2(B)
UNNAMED_55_CSC0402_I466_A: C552.1(A) U550.17
UNNAMED_55_CSC0402_I466_B: C552.2(B) U550.18(CPP)
UNNAMED_55_CSC0402_I497_A: C569.1(A) U551.2(LEFTINP)
UNNAMED_55_CSC0402_I497_B: C569.2(B) R562.1(A)
UNNAMED_55_CSC0402_I505_A: C564.1(A) U551.17
UNNAMED_55_CSC0402_I505_B: C564.2(B) U551.18(CPP)
UNNAMED_55_CSC0402_I514_A: C572.1(A) R561.2(B)
UNNAMED_55_CSC0402_I516_A: C570.1(A) U551.4(RIGHTINP)
UNNAMED_55_CSC0402_I516_B: C570.2(B) R563.1(A)
UNNAMED_55_CSC0402_I529_A: C573.1(A) R564.2(B)
UNNAMED_55_CSC0402_I594_B: C612.2(B) C616.2(B) R612.2(B) R617.2(B) U610.2(1IN-)
UNNAMED_55_CSC0402_I595_A: C613.1(A) C614.1(A) R618.1(A) R619.1(A) U610.5(2IN+)
UNNAMED_55_CSC0402_I599_A: C617.1(A) C627.2(B) R617.1(A)
UNNAMED_55_CSC0603_I458_A: C553.1(A) U550.15 U550.16
UNNAMED_55_CSC0603_I504_A: C565.1(A) U551.15 U551.16
UNNAMED_55_CSC0603_I568_B: C560.2(B) R553.2(B)
UNNAMED_55_CSC0603_I569_B: C561.2(B) R556.2(B)
UNNAMED_55_CSC0603_I604_A: C627.1(A) R620.2(B)
UNNAMED_55_HPA022642RTJ_I457_7: R550.1(A) U550.7
UNNAMED_55_HPA022642RTJ_I457_8: R551.1(A) U550.8
UNNAMED_55_HPA022642RTJ_I457__1: R567.1(A) U550.11(HPRIGHT)
UNNAMED_55_HPA022642RTJ_I457__2: R571.2(B) U550.2(LEFTINP)
UNNAMED_55_HPA022642RTJ_I457__3: R572.2(B) U550.4(RIGHTINP)
UNNAMED_55_HPA022642RTJ_I457_HP: R566.1(A) U550.14(HPLEFT)
UNNAMED_55_HPA022642RTJ_I457_LE: R552.2(B) R553.1(A) U550.1(LEFTINM)
UNNAMED_55_HPA022642RTJ_I457_RI: R556.1(A) R557.2(B) U550.5(RIGHTINM)
UNNAMED_55_HPA022642RTJ_I496_7: R558.1(A) U551.7
UNNAMED_55_HPA022642RTJ_I496_8: R559.1(A) U551.8
UNNAMED_55_HPA022642RTJ_I496__1: R569.1(A) U551.11(HPRIGHT)
UNNAMED_55_HPA022642RTJ_I496_HP: R568.1(A) U551.14(HPLEFT)
UNNAMED_55_HPA022642RTJ_I496_LE: R560.1(A) R561.1(A) U551.1(LEFTINM)
UNNAMED_55_HPA022642RTJ_I496_RI: R564.1(A) R565.1(A) U551.5(RIGHTINM)
UNNAMED_56_DB3X313J0L_I357_3: D801.3 R808.2(B) U800.1(PERST#)
UNNAMED_56_NMOS_I358_D: Q800.3(D) Q801.1 R803.2(B)
UNNAMED_56_NMOS_I363_S: Q802.2(S) R809.2(B) U800.2(CLKREQ#)
UNNAMED_56_RSC0402_I275_B: R801.2(B) U800.9(RREF)
UNNAMED_57_2322BY2ST3DC302A_I15: D110.3 D110.4 R115.1(A)
UNNAMED_57_2322BY2ST3DC302A_I_1: D110.2(YELLOW) Q110.3(D)
UNNAMED_57_2322BY2ST3DC302A_I_2: D126.3 D126.4 R126.1(A)
UNNAMED_57_2322BY2ST3DC302A_I_3: D126.1(PUREWHITE) Q125.3(D2)
UNNAMED_57_2322BY2ST3DC302A_I_4: D126.2(YELLOW) Q125.5(G2) Q125.6(D1) R130.2(B)
UNNAMED_57_CSC0402_I213_A: C9114.1(A) Q114.1 R136.2(B)
UNNAMED_57_LEDSINGLE_I235_A2: D9100.2(A2) R9100.1(A)
UNNAMED_57_NMOS_I256_D: Q113.3(D) R135.2(B) R136.1(A)
UNNAMED_58_1222Y2ST3DC302C_I4_1: D9033.3(-) Q9031.3(D)
UNNAMED_58_1222Y2ST3DC302C_I4_2: D9030.2 Q9032.6(D1)
UNNAMED_58_1222Y2ST3DC302C_I436: D9032.1(+) R9032.1(A)
UNNAMED_58_1222Y2ST3DC302C_I437: D9033.1(+) R9033.1(A)
UNNAMED_58_1222Y2ST3DC302C_I438: D9030.1(+) R9034.1(A)
UNNAMED_58_6712KF08M02L_I525_8: C9021.1(A) CN9021.8 R9038.1(A) R9040.1(A)
UNNAMED_58_AU9542B55GBSGR_I52_1: C9011.1(A) R9002.2(B) U9000.23(RESET)
UNNAMED_58_AU9542B55GBSGR_I52_2: R9000.2(B) R9001.2(B) U9000.7(SCARD0DATA)
UNNAMED_58_AU9542B55GBSGR_I523_: R9011.1(A) R9012.1(A) U9000.26(PWRSV_SEL)
UNNAMED_58_CN152G_I567_4: CN9002.4 TP9002.1
UNNAMED_58_CN152G_I567_10: CN9002.10 R9044.1(A)
UNNAMED_58_CN152G_I567_12: C9035.1(A) CN9002.12 R9048.1(A) R9049.2(B)
UNNAMED_58_CN152G_I567_13: CN9002.13 TP9001.1
UNNAMED_58_CN152G_I567_15: C9036.1(A) CN9002.2 CN9002.3 CN9002.15 R9045.2(B) R9046.1(A) R9047.2(B)
UNNAMED_58_LEDSINGLE3PINB_I518_: D9031.2(IN) R9031.1(A)
UNNAMED_64_BEADSINGLE_I40_INA: CN600.4 L603.1(INA)
UNNAMED_64_RSC0402_I32_B: MIC600.2 R640.2(B)
UNNAMED_64_RSC0402_I34_A: MIC601.2 R641.1(A)
USB30_D_RX2_DN: CN2400.5 U2550.15(USB3DN_RXDM2)
USB30_D_RX2_DP: CN2400.6 U2550.14(USB3DN_RXDP2)
USB30_D_RX3_DN: CN2401.5 U2550.23(USB3DN_RXDM3)
USB30_D_RX3_DP: CN2401.6 U2550.22(USB3DN_RXDP3)
USB30_D_TX2_C_DN: C2404.2(B) CN2400.8
USB30_D_TX2_C_DP: C2405.2(B) CN2400.9
USB30_D_TX2_DN: C2404.1(A) U2550.12(USB3DN_TXDM2)
USB30_D_TX2_DP: C2405.1(A) U2550.11(USB3DN_TXDP2)
USB30_D_TX3_C_DN: C2406.2(B) CN2401.8
USB30_D_TX3_C_DP: C2407.2(B) CN2401.9
USB30_D_TX3_DN: C2406.1(A) U2550.20(USB3DN_TXDM3)
USB30_D_TX3_DP: C2407.1(A) U2550.19(USB3DN_TXDP3)
USB30_RX0_DN: CN3601.88 U4555.G20(USB3RN1)
USB30_RX0_DP: CN3601.87 U4555.H20(USB3RP1)
USB30_RX1_DN: CN2500.5 U4555.E18(USB3RN2)
USB30_RX1_DP: CN2500.6 U4555.F18(USB3RP2)
USB30_RX2_C_DN: C2567.2(B) U2550.56(USB3UP_TXDM)
USB30_RX2_C_DP: C2568.2(B) U2550.55(USB3UP_TXDP)
USB30_RX2_DN: C2567.1(A) U4555.G17(PERN1/USB3RN3)
USB30_RX2_DP: C2568.1(A) U4555.F17(PERP1/USB3RP3)
USB30_TX0_DN: CN3601.91 U4555.C33(USB3TN1)
USB30_TX0_DP: CN3601.90 U4555.B34(USB3TP1)
USB30_TX1_C_DN: C2500.2(B) CN2500.8
USB30_TX1_C_DP: C2501.2(B) CN2500.9
USB30_TX1_DN: C2500.1(A) U4555.B33(USB3TN2)
USB30_TX1_DP: C2501.1(A) U4555.A33(USB3TP2)
USB30_TX2_C_DN: C2569.2(B) U2550.59(USB3UP_RXDM)
USB30_TX2_C_DP: C2570.2(B) U2550.58(USB3UP_RXDP)
USB30_TX2_DN: C2569.1(A) U4555.C30(PETN1/USB3TN3)
USB30_TX2_DP: C2570.1(A) U4555.C31(PETP1/USB3TP3)
USB_D_P1_DN: L3001.1(INC) U2550.2(USB2DN_DM1)
USB_D_P1_DP: L3001.4(INA) U2550.1(USB2DN_DP1)
USB_D_P1_L_DN: CN3000.39 L3001.2(IND)
USB_D_P1_L_DP: CN3000.38 L3001.3(INB)
USB_D_P2_DN: L2400.4(INA) U2550.10(USB2DN_DM2)
USB_D_P2_DP: L2400.1(INC) U2550.9(USB2DN_DP2)
USB_D_P2_L_DN: CN2400.2 L2400.3(INB)
USB_D_P2_L_DP: CN2400.3 L2400.2(IND)
USB_D_P3_DN: L2404.4(INA) U2550.18(USB2DN_DM3)
USB_D_P3_DP: L2404.1(INC) U2550.17(USB2DN_DP3)
USB_D_P3_L_DN: CN2401.2 L2404.3(INB)
USB_D_P3_L_DP: CN2401.3 L2404.2(IND)
USB_HUB_RST#: D2551.2 R4839.1(A) U4555.AL2(SML0ALERT/GPIO60*)
USB_P0_DN: CN3601.45 U4555.AN8(USB2N0)
USB_P0_DP: CN3601.44 U4555.AM8(USB2P0)
USB_P1_CH_DN: L2500.2(IND) U2511.11
USB_P1_CH_DP: L2500.3(INB) U2511.10
USB_P1_CH_L_DN: CN2500.2 L2500.1(INC)
USB_P1_CH_L_DP: CN2500.3 L2500.4(INA)
USB_P1_DN: U2511.2 U4555.AR7(USB2N1)
USB_P1_DP: U2511.3 U4555.AT7(USB2P1)
USB_P2_DN: U2550.54(USB2UP_DM) U4555.AR8(USB2N2)
USB_P2_DP: U2550.53(USB2UP_DP) U4555.AP8(USB2P2)
USB_P3_DN: CN1300.5 U4555.AR10(USB2N3)
USB_P3_DP: CN1300.3 U4555.AT10(USB2P3)
USB_P4_DN: CN2200.2 D2201.1 U4555.AM15(USB2N4)
USB_P4_DP: CN2200.3 D2201.2 U4555.AL15(USB2P4)
USB_P5_DN: L1400.3(INB) U4555.AM13(USB2N5)
USB_P5_DP: L1400.2(IND) U4555.AN13(USB2P5)
USB_P5_L_DN: CN1400.9(USB_D-) L1400.4(INA)
USB_P5_L_DP: CN1400.7(USB_D+) L1400.1(INC)
USB_P6_DN: L3000.4(INA) U4555.AP11(USB2N6)
USB_P6_DP: L3000.1(INC) U4555.AN11(USB2P6)
USB_P6_L_DN: CN3000.7 L3000.3(INB)
USB_P6_L_DP: CN3000.8 L3000.2(IND)
USB_P7_DN: CN200.12 U4555.AR13(USB2N7)
USB_P7_DP: CN200.11 U4555.AP13(USB2P7)
USB_P7_SM_DN: CN9000.12 U9000.8(DM)
USB_P7_SM_DP: CN9000.11 U9000.9(DP)
USB_PORT_EN: R4917.2(B) U2402.1 U2403.1 U4555.AL4(GPIO58)
V_3.9K: C6902.1(A) Q6902.3(D) Q6903.2(E) R6049.1(A) R6915.1(A) R6916.1(A) R6917.1(A)
VADPBL: D6017.1(A1) D6017.2(A2) Q6010.5(DXXX) Q6010.6(DXX) Q6010.7(DX) Q6010.8(D) Q6011.1(S0) Q6011.2(S1) Q6011.3(S2) Q6012.4(G) R6028.1(A) R6931.1(A)
VBIAS: Q6902.1(G) R6902.2(B) R6903.1(A)
VGA_B_L2: C3056.1(A) CN3050.3 L3053.2(INB)
VGA_DEMUX_SW: Q5401.3(D) R5418.2(B) U5401.18(SW)
VGA_G_L2: C3055.1(A) CN3050.2 L3052.2(INB)
VGA_R_L2: C3054.1(A) CN3050.1 L3051.2(INB)
VGAPC11: R5403.1(A) U5401.55(PC11)
VGAPC21: R5407.1(A) U5401.53(PC21)
VOLTAGE_ADC: C6998.1(A) R302.1(A) R6994.1(A) R6995.2(B)
VR_SVID_ALERT#: R4524.2(B) R4525.2(B) U6600.32
VR_SVID_CLK: R6641.2(B) U4555.N63(VIDSCLK) U6600.31
VR_SVID_DATA: R4821.2(B) R6640.2(B) U4555.L63(VIDSOUT) U6600.1
VRA3V3A_LDO: C6121.1(A) D4750.2(A2) R2950.1(A) R6934.2(B) R7111.2(B) R7410.1(A) U6100.6 U7000.5(VCC)
VRA3V3A_SNB: C7610.1(A) R7610.2(B)
VRA3V3A_VCC: C6122.1(A) U6100.11
VRA3V3A_VCLK: U6100.5
VRA5V0A_LDO: C6120.1(A) U6150.6
VRA5V0A_SNB: C7615.1(A) R7615.2(B)
VRA5V0A_VCC: C6172.1(A) U6150.11
VRACPU_BST1: C6615.2(B) U6610.7
VRACPU_BST11: C6615.1(A) R6615.2(B)
VRACPU_BST12: R6615.1(A) U6610.6
VRACPU_COMP: C6640.2(B) R6633.2(B) R6651.1(A) R6656.2(B) U6600.26
VRACPU_COMP1: C6639.1(A) R6633.1(A)
VRACPU_CSN1: C6614.1(A) C6617.2(B) C6618.2(B) L6610.4 R6617.2(B) R6619.2(B) U6600.18
VRACPU_CSN2: U6600.19
VRACPU_CSN3: U6600.22
VRACPU_CSP1: C6613.1(A) C6617.1(A) C6618.1(A) R6616.2(B) R6618.1(A) R6619.1(A) U6600.17
VRACPU_CSP2: R6663.2(B) U6600.20
VRACPU_CSP3: R6666.2(B) U6600.21
VRACPU_DROOP: C6639.2(B) C6640.1(A) R6656.1(A) U6600.25
VRACPU_IMAX: R6649.2(B) R6650.1(A) U6600.10
VRACPU_IMON: C6645.1(A) R6655.1(A) U6600.13
VRACPU_OCP: R6654.1(A) R6655.2(B) U6600.12
VRACPU_PWM1: U6600.6 U6610.8
VRACPU_PWM2: U6600.5
VRACPU_PWM3: R6612.1(A) U6600.4
VRACPU_RAMP: R6652.2(B) R6653.1(A) U6600.11
VRACPU_SKIP#: U6600.7 U6610.1
VRACPU_SLEWA: R6659.2(B) R6660.2(B) U6600.15
VRACPU_SNB1: C7661.1(A) R7661.2(B)
VRACPU_THERM: C6646.2(B) R6658.2(B) R6661.2(B) U6600.14
VRACPU_USR: R6646.2(B) R6647.1(A) U6600.9
VRACPU_V5A: C6643.1(A) R6665.1(A) U6600.28
VRACPU_VBAT: R6657.2(B) U6600.16
VRACPU_VDD: C6642.1(A) R6645.1(A) U6600.2
VRACPU_VREF: C6644.1(A) R6646.1(A) R6649.1(A) R6651.2(B) R6652.1(A) R6659.1(A) R6661.1(A) U6600.27
VRANB669GQ_VCLK: C6156.1(A) C6157.1(A) U6150.5
VRANB669GQ_VCLK1: C6156.2(B) D6150.3(C)
VRANB669GQ_VCLK2: C6157.2(B) D6151.3(C)
VRANB669GQ_VCLK3: C6158.1(A) D6150.1(A1) D6151.2(A2)
VRAVR_ON: R6643.1(A) U6600.8
VRB3V3A_BST: R6115.1(A) U6100.10
VRB3V3A_BST1: C6115.1(A) R6115.2(B)
VRB5V0A_BST: R6165.1(A) U6150.10
VRB5V0A_BST1: C6165.1(A) R6165.2(B)
VRB_VDD5: D6150.2(A2) R6161.2(B) R6210.2(B) R6310.2(B)
VREF_EQ: C616.1(A) U610.3(1IN+) U610.6(2IN-) U610.7(2OUT)
VRP1V2A: C6450.1(A) C6452.1(A) L6450.2(INB) PAD6450.1 R6450.2(B)
VRP1V2A_PH: L6450.1(INA) U6450.1 U6450.2 U6450.3
VRP1V05A: C6300.1(A) C6301.1(A) C6302.1(A) C6303.1(A) C6304.1(A) C7471.2(B) C7474.2(B) L6300.2 L6300.4 PAD6300.1 R6300.1(A)
VRP1V05A_PH: C6315.2(B) L6300.1 L6300.3 R7630.1(A) U6300.10 U6300.11 U6300.16 U6300.17 U6300.18
VRP1V5S: C6350.1(A) C6352.1(A) L6350.2(INB) PAD6350.1 R6350.2(B)
VRP1V5S_PH: L6350.1(INA) U6350.1 U6350.2 U6350.3
VRP3V3A: C6100.1(A) C6101.1(A) C6109.1(A) D7620.2 L6100.2(INB) PAD6100.1 U6100.7
VRP3V3A_PH: C6115.2(B) L6100.1(INA) R7610.1(A) U6100.8 U6100.9 U6100.15 U6100.16
VRP5V0A: C6150.1(A) C6151.1(A) C6152.1(A) C6166.2(B) C6169.1(A) D7619.2 L6150.2(INB) PAD6150.1 R6150.2(B) R6161.1(A) U6150.7
VRP5V0A_PH: C6165.2(B) L6150.1(INA) R6166.1(A) R7615.1(A) U6150.8 U6150.9 U6150.15 U6150.16
VRPPM_SLP_S0_N: CN4941.15 R4799.1(A)
VRPPM_SLP_S0_N_R: R4799.2(B) U4555.AF3(SLP_S0*)
VRPVDDQ: C6200.1(A) C6201.1(A) C6202.1(A) C6203.1(A) C6204.1(A) C7469.2(B) C7470.2(B) L6200.2 L6200.4 PAD6200.1 R6200.1(A)
VRPVDDQ_PG: R7416.1(A) U6200.1(PGOOD)
VRPVDDQ_PH: C6215.2(B) L6200.1 L6200.3 R7620.1(A) U6200.10 U6200.11 U6200.16 U6200.17 U6200.18
VRPVPACK_HG: Q6000.4(G) U6000.18(HIDRV)
VRPVPACK_LG: Q6001.4(G) U6000.15(LODRV)
VRPVPACK_PH: C6015.2(B) L6000.1(INA) Q6000.1(S0) Q6000.2(S1) Q6000.3(S2) Q6001.5(D3) Q6001.6(D2) Q6001.7(D1) Q6001.8(D0) R7600.1(A) U6000.19(PHASE)
VRPVTT: C6240.1(A) PAD6240.1 U6240.3(VTT) U6240.5(VTTSNS)
VRPVTT_REF: C6243.1(A) PAD6242.1 U6240.6(VTTREF)
WL_LED_ALL#: CN200.16 CN1300.6 CN1300.16 D110.1(PUREWHITE) Q110.1(G) Q112.3(D) R118.1(A)
WL_LED_SM_ALL#: CN9000.16 D9033.2 Q9031.1(G)
WLAN_OFF: R1311.1(A) U300.30(GPIO031)
WLAN_TRANSMIT_OFF#: D1300.3(A1) R1315.1(A) U4555.AG6(GPIO56)
WLAN_WAKE#: CN1300.55 R363.2(B) U300.103(GPIO053/PS2_CLK3)
WWAN_CONFIG_1: CN1400.69(PEDET_OC-PCIE/GND-SATA) R4914.2(B) U4555.AG5(GPIO45)
WWAN_CONFIG_2: CN1400.75(USB3.0IND/GND-OTHER) R4915.2(B) U4555.AG3(GPIO46)
WWAN_DET#: CN1400.1(GND_PRESENCE_IND) Q4831.1(G) R1405.1(A) R4831.2(B)
WWAN_NGFF_DPR: CN1400.25(RESERVED_25) R1408.2(B)
WWAN_OFF#: Q1401.1(G) R1403.2(B) R1404.2(B) R1417.2(B) U300.33(GPIO147)
WWAN_TRANSMIT_OFF#: D1410.3(A1) Q112.1(G) R4714.2(B) U4555.AU2(GPIO8)
WWANSSD_M12DET: R1409.1(A) R4918.2(B) U4555.AT5(GPIO59)
XCLK_BIASREF: R4892.1(A) U4555.C26(DIFFCLK_BIASREF)
XDP_DBRESET#: CN4920.48(DBR#_HOOK7) CN4941.13 R4922.2(B) U4555.AC3(SYS_RESET*)
XDP_RST_R_N: CN4920.46(RESET#_HOOK6) R4921.1(A)
XDP_TRST#: CN4920.54(TRSTN) Q4920.3(D2)
XTAL24_IN: C4828.1(A) R4898.2(B) U4555.A25(XTAL24_IN) X4751.3
XTAL24_OUT: C4826.1(A) R4898.1(A) U4555.B25(XTAL24_OUT) X4751.1

Pads without a net: CN200 8; CN202 2 7; CN290 5; CN300 1 7; CN600 5 6 7 9 10; CN1300 8 9 10 11 12 13 14 15 17 19 20 21 22 23 32 34 36 44 46 48 50 59 61 64 65 66 67 68 70 71 73; CN1400 20 22 23 24 28 29 31 35 37 38 40 41 42 43 44 46 47 48 49 50 52 53 54 55 56 58 59 60 61 62 63 64 65 68; CN1451 P4 P8; CN1700 P1 P2 P11 P13 P14 P15; CN1951 5 6 7 8 10 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; CN3000 4 35 36; CN3050 4 11; CN3601 8 9 26 27 42 54 55 57 58 60 61 69 70 72 73; CN4100 77 122 125; CN4125 77 122 125; CN4941 16 17 18; CN6050 5; CN9000 8; CN9100 2; D100 2; D1300 2; D1410 2; D3000 2; D9031 NC; FIX1 1; FIX2 1; FIX3 1; FIX4 1; FIX5 1; FIX6 1; FIX7 1; FIX8 1; FIX600 1; FIX601 1; FIX602 1; FIX9000 1; FIX9001 1; FIX9002 1; FIX9003 1; FIX9004 1; FIX9005 1; FIX9006 1; FIX9007 1; FIX9100 1; FIX9101 1; FIX9102 1; JACK600 3; SW152 2 4; SW154 2 4; SW9100 2 4; U300 5 6 71 109; U400 25; U501 15 16 17 18 24 29 37; U800 13 22 23 24 25 26 31; U1000 2 3; U2511 9 13; U2550 3 4 6 7 24 25 26 27 29 30; U3051 5; U3065 12 23 29 32; U3500 1 2 3 8 12 13 14 15 28; U4555 A5 A15 A21 A23 A39 A49 A51 A53 AA23 AA59 AB21 AB23 AC4 AC58 AC59 AD23 AD59 AD60 AE59 AE60 AF20 AG58 AL1 AL11 AM10 AM11 AN10 AP7 AT2 AU10 AU12 AU15 AU44 AU63 AV2 AV10 AV44 AV50 AV62 AV63 AW10 AW14 AW49 AY8 AY14 AY42 AY43 B15 B21 B22 B23 B39 B43 B49 B50 B51 B53 C21 C22 C23 C42 C43 C46 C47 C49 C62 C63 D1 D15 D58 E1 E6 E8 E10 E13 E15 F6 F8 F10 F22 G10 H5 H10 H18 H22 J5 J20 J21 J58 K10 K18 K21 L11 L59 L60 M20 M21 N23 N58 N60 P20 R20 R23 T23 T59 U10 U59 V21 V59 W23 Y20 Y22; U4700 1; U5301 14 58; U5401 1 8 12 13 14 15 16 31 32 34 35 41 42 44 45 54 56 58; U6100 3; U6350 7; U6450 7; U7000 1; U9000 20 21 22 24 25 27 28; X400 2 4; X2500 2 4; X3065 2 4; X4750 2 3; X4751 2 4

## Via types
v1: diameter 0.61, hole 0.305, TOP to BOTTOM, 663 vias
v2: diameter 0.457, hole 0.254, TOP to BOTTOM, 3272 vias
v3: diameter 0.61, hole 0.254, TOP to BOTTOM, 539 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 451 vias
v5: diameter 0.762, hole 0.406, TOP to BOTTOM, 328 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V2A_PG: length 65.8
  TOP w0.102: R2568.2 260.15,62.49 260.15,59.28 D2551.1 259.16,58.85 258.6,58.3 258.6,52.94 257.59,51.93 250.22,51.93 249.21,52.94 249.21,55.79 251.67,58.25 251.67,70.2 249.21,72.66 249.21,73.03 245.41,76.82 244.92,76.82 244.76,76.98 244.76,79.11 246.03,80.38 v1(246.03,80.86) 246.03,84.19 246.29,84.44 246.29,88.89 246.67,89.27 246.97,89.27 247.3,88.94 U6450.4
1V5S_PG: length 242.6
  TOP w0.102: v2(248.83,104.13) 248.83,103.21 247.07,101.46 246.67,101.46 246.08,100.87 R7428.1
  TOP w0.254: v3(102.78,141.46) 101.63,142.61 96.68,142.61 96.17,143.11 96.17,144 96.93,144.77 97.82,144.77 97.95,144.89 U6350.4
  L3 w0.102: v2(248.83,104.13) 248.83,111.21 250.88,113.27 250.88,114.64 247.94,117.59 247.94,123.55 257.41,133.03 257.41,141.65 255.69,143.37 247.81,143.37 247.2,143.98 247.2,144.99 v2(246.03,146.16)
  L5 w0.102: v3(102.78,141.46) 102.88,141.56 102.88,144.55 109.44,151.12 v2(111.41,151.12)
  L6 w0.102: v2(111.41,151.12) 112.72,152.42 137.62,152.42 139.57,150.48 184.99,150.48 185.81,149.67 213.09,149.67 214.15,150.73 214.15,153.91 214.92,154.67 218.36,154.67 222.32,158.63 232.18,158.63 233.98,160.44 242.52,160.44 244.43,158.52 244.43,147.76 v2(246.03,146.16)
3V3DS_PG: length 8
  BOTTOM w0.254: R7000.2 210.94,152.47 v1(210.09,151.62) 209.84,151.37 205.39,151.37 204.48,152.28 U6100.4
5V_PG: length 30.5
  TOP w0.254: R7010.1 211.61,153.7 211.61,153.17 v1(211.44,152.99) 219.51,152.99 221.88,150.63 230.64,150.63 234.63,146.64 v2(235.82,146.64)
  BOTTOM w0.254: U6150.4 235.84,148.42 235.62,148.19 235.62,146.85 v2(235.82,146.64)
AGND_AUDIO: length 158.4
  TOP w0.254: v2(305.47,61.2) 305.54,61.2 306.19,60.56 R563.2 ; v2(305.47,61.2) 305.32,61.06 U501.33 ; v2(305.47,61.2) 305.72,61.45 R562.2 ; Q528.1 297.35,55.63 296.05,54.33 Q528.4 ; v2(304.65,57.34) 304.76,57.34 304.98,57.57 304.98,58.13 304.85,58.26 U501.26
  TOP w0.356: 308.13,74.25 308.15,74.27 U550.9 ; 308.13,74.25 U550.21 v2(308.13,72.76) U550.3 ; 308.13,74.25 308.13,74.77 ; 312.19,60.32 U551.21 ; 312.19,60.32 U551.9 ; 312.19,60.32 312.69,59.82 U551.10 ; U551.21 U551.13 ; U551.21 311.19,61.32 U551.19 ; 308.13,74.77 U550.13 308.13,77.22 308.54,77.63 C555.2 C554.2 ; 308.13,74.77 U550.10 ; U551.3 v2(308.9,60.82) ; v2(307.12,72.76) 307.12,73.01 306.86,73.27 U550.19
  TOP w0.381: Q528.4 296.05,53.56 295.69,53.2 v2(295.69,52.96) ; R530.2 296.52,52.96 v2(295.69,52.96) ; C550.2 303.97,71.87 303.44,72.4 v2(303.44,72.5) ; v2(310.93,55.61) 310.93,55.78 C567.2 311.65,56.65 C566.2 ; C574.2 309.32,52.77 v2(309.66,52.44) 310.12,52.9 C575.2 ; v2(307.34,56.37) 307.34,56.76 306.78,57.32 C511.2 ; C501.2 303.44,71.49 v2(302.93,71.99) 302.42,71.49 C529.2 ; C553.2 303.42,74.61 303.42,72.52 v2(303.44,72.5) ; v2(307.12,68.31) 307.12,68.77 R571.1 ; C7578.1 315.96,15.94 v2(316.39,15.51) ; R572.1 307.88,68.9 v2(307.88,68.31) ; C517.2 307.03,54.52 v2(307.21,54.34) 307.25,54.31 R605.2 ; C516.2 308.86,63.45 v2(308.77,63.36) 308.69,63.27 R560.2 ; v2(306.23,68.31) R552.1 ; C7520.1 v2(314.23,83.55) ; v2(295.69,52.96) 295.05,53.59 R529.1 ; v2(303.44,72.5) 303.69,72.76 C551.2 ; v2(309.27,58.84) 308.83,58.41 R565.2 ; C507.2 305.64,66.2 306.28,66.84 v2(306.36,66.84) ; C513.2 303.98,53.58 v2(304.71,53.58) R502.2 ; R557.1 309.56,67.53 v2(309.56,66.56) 309.66,66.66 310.41,66.66 R520.2 310.89,66.1 309.96,66.1 v2(309.91,66.05) 309.89,66.05 309.91,66.03 C562.2 C563.2 ; Q600.2 294.04,54.04 294.04,53.33 v2(294.42,52.94) ; v2(302.17,52.77) R507.2 R506.2 ; C7521.1 321.01,117
  TOP w0.635: R520.2 312.55,66.14 C565.2
  L3 w0.635: CN3601.19 324.42,115.68 325.15,115.68
  L3 w1.016: v5(319.95,105.34) 319.34,104.73 319.34,103.54 320.28,102.6 321.72,102.6 321.83,102.68 322,102.79 322.37,102.94 322.76,103.02 322.96,103.02 324.43,103.02 325.51,104.1 325.51,115.33 325.15,115.68
  L5 w0.381: v2(310.62,61.91) 310.67,61.96 311.44,61.96 ; CN3601.16 322.27,114.2 321.72,113.65
  L5 w1.524: 321.72,113.65 321.72,107.12 v5(319.95,105.34) 318.28,105.34 314.43,101.49 314.43,83.75 v2(314.23,83.55) 312.43,81.75 312.43,77.23 314.51,75.14 314.51,65.03 311.44,61.96
  BOTTOM w0.381: C601.2 v2(318.93,5.32) ; C7579.1 294.67,55.48 v2(294.42,55.23) ; U610.4 288.18,54.94 v2(288.47,54.65) ; v2(289.29,57.01) 289.26,57.03 289.26,57.25 C617.2 ; R619.2 C613.2 293.6,56.19 v2(294.04,55.74) 293.8,55.5 C614.2 ; C615.2 294.22,53.14 v2(294.42,52.94) ; C603.2 v2(324.39,10.78) ; C602.2 v2(318.93,10.4)
  vias: v2(291.12,57.38) v2(302.96,52.69) v2(309.15,72.76) v2(310.62,60.82) v2(310.62,59.78)
AGND_KBC: length 10.9
  TOP w0.254: U300.45 278.8,101.33
  TOP w0.381: v1(283.12,101.08) 282.99,100.95 C313.1 282.14,101.29 281.72,101.71 280.19,101.71 279.81,101.33 278.8,101.33 ; C304.1 285.06,96.38 C301.2 C306.2 C307.2 285.06,99.37 284.33,100.1 PAD310.2
DGND: length 1817.1
  TOP w0.254: U300.82 269.28,109.4 v2(269.35,109.33) ; v2(185.9,89.72) 186.05,89.56 C4701.2 ; U300.56 276.69,105.73 276.51,105.9 v2(276.51,106.28) ; R4748.2 186.77,94.44 v2(187.48,93.73) ; R4519.1 211.06,83.04 v2(211.16,82.94) ; C7488.1 173.05,84.78 172.81,85.02 v4(172.81,85.6) ; v2(185.25,95.4) 185.42,95.24 186.34,95.24 186.77,95.66 R4520.2 ; v2(179.47,78.78) 179.31,78.62 C4760.2 ; CN4920.8 232.9,77.52 233.08,77.7 234.21,77.7 234.63,77.28 v2(234.63,77.22) ; C6032.2 285.23,132.11 285.8,131.53 v2(285.8,131.18) ; 260.99,52.97 266.04,52.97 C2566.1 ; U300.11 267.68,96.06 v2(267.88,96.25) ; R4534.2 211.32,85.81 v2(211.18,85.95) ; U300.104 260.63,106.13 v2(260.59,106.08) ; v4(212.81,75.28) 212.5,74.98 R4522.2 ; v2(263.43,100.7) 263.2,100.93 U300.117 ; U300.36 276.81,97.73 v2(276.38,98.16) ; 261.04,56.88 265.69,56.88 v2(266.17,56.4) ; R4523.2 209.54,86.2 209.82,85.92 209.82,85.93 209.83,85.94 209.84,85.94 v2(209.84,85.94) ; v2(274.81,112.35) 274.81,112.08 274.09,111.36 274.1,111.35 274.11,111.35 274.08,111.32 U300.70 ; C4535.2 v5(201.2,78.98) ; C4531.2 v5(196.37,78.98) ; U300.47 v2(278.86,102.13)
  TOP w0.305: CN4920.7 238.67,77.52 238.86,77.33 239.28,77.33 v2(239.41,77.46) ; 230.06,81.3 v2(230.03,81.27) ; CN200.15 106.55,91.08 v2(106.48,91.15) ; CN300.6 268.15,85.58 269.38,86.82 v2(269.65,86.82) ; PAD310.1 284.77,101.26 285.6,102.09 v2(285.66,102.09) ; CN200.14 106.05,90.82 v2(105.82,91.04) ; v2(233.2,83.77) 232.96,83.53 CN4920.32 ; CN200.6 v2(102.05,91.76) ; 230.05,80.52 230.03,80.5 ; CN200.3 v2(100.55,88.91)
  TOP w0.33: U1000.12 241.71,96.39 v2(241.33,96.76) ; v5(285.02,126.35) 285.54,126.87 U6000.14 ; v2(241.59,97.78) 241.59,97.65 241.85,97.39 U1000.10 ; U1000.15 243.49,95.24 v2(243.75,94.98) 243.99,95.23 U1000.16
  TOP w0.356: CN4920.25 238.94,82.02 v2(238.94,82.03) ; CN4941.14 129.68,80.58 v5(129.41,80.32) 129.38,80.34 129.37,80.34 129.38,80.34 129.38,79.58 ; CN4920.2 234.02,76.02 234.63,76.64 v2(234.63,77.22) ; v2(233.2,85.16) 233.07,85.02 CN4920.38 ; CN202.3 191.8,58.65 191.8,57.77 ; v2(300.26,83.3) 300.39,83.3 301.1,84.01 CN301.3 ; 129.38,79.58 CN4941.12 ; 129.38,79.58 129.38,78.79 129.59,78.58 CN4941.10 ; CN4920.49 238.69,88.02 239.02,88.35 v2(239.02,88.48) ; CN4920.1 237.68,76.02 237.78,75.93 v2(237.78,75.35) ; 230.06,81.3 230.06,81.82 230.26,82.02 CN4920.26 ; v2(300.26,83.93) 300.6,84.27 CN301.4 ; CN4920.31 238.9,83.53 v2(238.95,83.58) ; CN4920.20 230.05,80.52 ; CN200.37 117.55,89.17 v2(117.61,89.11) 117.71,89.11 118.05,89.45 CN200.38 ; U1000.5 244.94,98.11 ; v2(235.85,79.08) 235.87,79.1 235.87,79.06 235.9,79.02 CN4920.13 ; CN4941.8 130.71,77.58 131.61,77.58 131.64,77.55 132.02,77.55 132.23,77.33 v2(132.49,77.33) ; CN4920.19 239.5,80.52 v2(239.58,80.6) ; v2(235.21,90.43) 235.31,90.53 CN4920.59 ; v2(118.27,88.91) 118.55,89.19 CN200.39 ; CN200.40 119.05,88.9 117.74,87.59 v2(117.74,87.34) ; CN301.5 300.1,84.66 v2(300.01,84.57) ; v2(233.76,79.16) 233.63,79.02 CN4920.14 ; CN4920.50 230.2,88.02 v2(230.08,88.15) ; U1000.13 U1000.12 ; v2(238.92,85.02) CN4920.37
  TOP w0.381: C4787.2 v4(191.42,83.45) ; v5(252.51,84.95) 253.4,84.06 C6450.2 ; C7623.2 v2(100.11,104.13) ; v2(123.48,132.7) 123.48,132.4 C4129.2 ; C7457.1 275.24,118.48 ; Q110.2 v2(309.28,150.62) ; C7578.2 316.3,16.79 v2(316.38,16.88) ; C4730.1 174.34,87.28 v2(174.54,87.48) ; v2(316.62,20.36) 316.59,20.36 C7592.2 ; v2(320.21,127.75) 320.28,127.68 C3602.2 ; CN4941.G1 133.51,71.11 v2(133.51,71.11) ; C7581.2 115.86,123.99 v2(114.03,123.99) 113.81,123.99 112.3,122.48 C2256.2 ; v2(158.82,139.93) 158.36,139.93 158.15,140.15 158.15,141.75 C4141.2 ; 272.57,115.03 272.57,114.59 C100.2 ; 272.57,115.03 v2(272.57,115.05) ; 272.57,115.03 271.97,115.62 271.5,115.62 271.05,115.17 R342.2 ; v2(183.73,132.56) 185.45,134.28 C4144.2 ; v2(130.59,113.4) 130.38,113.19 C7611.2 ; 239.66,143.22 C4116.2 ; R3068.1 88.12,82.96 v2(87.76,83.32) ; v2(257.84,144.26) 257.84,144.51 257.46,144.89 C7467.1 ; C6029.1 291.67,128.04 v2(291.67,128.76) ; C4729.2 171.87,108.32 171.19,107.65 v2(170.56,107.65) ; U4411.2 v2(46.77,89.53) ; v2(304.32,144.26) 304.32,144.05 C6018.2 ; C4128.2 v2(120.17,140.07) ; v2(259.37,82.41) 259.44,82.33 D1451.2 ; v2(309.18,112.8) 308.21,112.8 C1303.2 307.83,112.42 C1304.2 ; v2(179.43,87.41) 179.34,87.32 C4728.2 ; v2(319.46,117.74) 319.49,117.71 C7521.2 ; D4202.2 v2(209.96,145.91) ; v5(304.21,132.7) 304.28,132.77 C1305.2 ; C4115.2 228.38,143.78 v2(228.38,144.38) ; v2(289.34,67.68) 289.88,67.68 C802.2 ; C502.2 295.93,62.39 296.36,61.96 C505.2 ; v2(201.4,126.5) 201.38,126.5 201.23,126.35 C7604.2 ; v4(107.47,117.46) 107.39,117.38 R3008.2 ; v2(268.89,115.05) 269.27,115.43 C7601.2 ; C2566.1 266.35,53.28 266.74,53.28 v2(267.16,53.71) ; C3601.2 318.93,127.11 v2(318.37,126.55) ; v2(182.28,82.79) 181.77,82.28 C4717.2 ; C4146.2 229.65,129.53 ; v2(249.74,111.34) 249.97,111.11 U2950.2 ; R5314.1 277.7,72.29 279.12,73.72 v2(279.55,73.72) ; v2(179.99,87.62) 179.82,87.79 C4716.2 ; C510.2 303.48,67.47 303.1,67.47 v2(303.08,67.45) 302.93,67.3 C509.2 ; C532.2 299.5,74.18 v2(299.68,74.36) ; D4204.2 199.96,131.56 v2(199.3,132.22) ; D4205.2 169.91,147.77 v2(170.09,147.94) ; v2(291.5,119.75) 291.12,119.37 288.07,119.37 287.43,118.73 C9114.2 ; v2(152.81,80.58) 152.81,80.63 153.21,81.03 C4762.2 ; v2(58.58,80) 58.62,80.04 C7617.2 ; C404.1 v2(294.37,103.83) ; v2(303.05,68.03) 302.73,68.35 R537.2 R536.2 ; C4109.2 233.21,136.7 v2(232.9,136.7) ; v2(64.93,90.66) R6916.2 ; 145.22,143.62 143.92,143.62 v5(143.16,144.38) ; v2(175.73,56.21) 175.63,56.12 C7494.1 ; R305.2 R391.2 253.99,104.46 v2(254.54,105.01) ; C7603.2 v2(126.52,113.78) ; v2(122.08,149.59) 122.08,149.21 121.83,148.96 C3506.2 ; v2(292.13,124.57) 291.96,124.75 C6030.2 ; v2(294.04,127.55) 294.04,128.08 R6994.2 ; C7402.1 241.33,99.94 v2(241.33,99.43) ; v2(281.92,103.93) 281.83,104.01 C131.2 ; C7464.1 222.92,69.2 223.43,69.71 225.21,69.71 v2(225.46,69.46) 224.98,68.99 C7463.1 ; R371.2 283.41,103.53 v2(282.99,103.11) ; C7598.2 241.38,141.17 v2(241.08,141.46) ; C2564.2 265.05,59.55 v2(264.83,59.77) ; C2550.1 266.35,56.22 v2(266.17,56.4) ; CN301.G2 297.42,82.28 297.85,82.28 v2(298.23,81.9) ; Q6998.2 286.78,100.85 R6999.2 287.01,101.64 v2(286.75,101.89) ; v2(225.58,94.73) 225.5,94.64 R4526.2 ; C4119.2 262.75,136.22 262.29,135.76 v2(262.31,135.76) ; D7613.1 201.2,127.49 v2(201.45,127.24) ; R4804.2 R4803.2 R4805.2 159.08,71.53 156.8,69.25 v2(156.8,67.93) ; D6015.3 314.04,140.57 v2(314.48,140.57) ; v2(36.99,66.28) C3055.2 36.23,66.87 35.93,67.17 33.85,67.17 CN3050.7 ; v2(298.1,117.54) 298.81,118.25 Q7056.4 ; R7412.1 241.46,110.84 v2(241.28,111.02) ; C7609.2 135.72,68.44 ; C4111.2 220.7,143.64 v2(220.7,144.32) ; 109.63,135.75 109.89,135.75 110.01,135.62 v2(110.52,135.62) ; R3502.2 v2(126.65,149.59) ; v4(114.1,121.19) 113.46,120.55 C2255.2 ; C2554.2 268.81,52.39 R2553.1 269.2,52.39 v2(269.48,52.67) ; v2(183.8,144.33) 183.63,144.5 C7636.2 ; C6999.2 294.03,133.64 294.62,133.64 v2(294.8,133.46) ; v2(203.9,144.26) 203.91,144.27 C7635.2 ; R6930.2 v2(294.67,136.51) C6906.2 ; v2(127.54,149.59) C3503.2 ; C475.2 C476.2 298.18,99.84 298.86,99.16 v2(299.27,99.16) ; C403.2 297.97,112.38 v2(298.1,112.51) ; Q1002.2 233.22,106.1 233.22,105.01 ; v2(257.46,100.74) 257.67,100.74 258.01,100.4 R304.2 ; C7612.2 188.2,74.96 v4(187.77,75.39) ; C3074.2 78.2,89.63 78.2,90.22 v2(78.16,90.26) ; C3060.2 82.84,80.89 v2(82.49,80.55) ; v2(117.51,97.65) 117.13,97.27 C7037.2 ; Q125.4 v2(313.85,149.19) ; Q7002.2 310.2,120.52 309.63,121.09 v2(309.63,121.19) ; R7627.2 318.17,60.18 317.41,60.95 v2(317.28,60.95) ; R2585.2 C2584.2 267.72,67.11 v2(267.72,67.83) ; v2(241.05,64.81) 241.05,64.42 240.07,63.44 C7585.2 ; R6023.2 288.49,133.76 288.07,133.34 288.07,132.6 288.14,132.53 v2(288.14,132.52) 287.72,132.11 C6022.2 C6049.2 ; D4201.2 185.05,143.99 v2(185.05,144.36) ; C4120.2 262.57,137.09 v2(261.95,137.09) ; C7036.2 210.47,147.86 v2(210.47,148.19) ; v2(252.64,145.65) 253.31,145.65 D7607.1 ; C2250.2 111.41,122.79 v2(111.28,122.92) ; CN2200.4 283.23,57.5 v2(283.37,57.64) ; Q1401.2 259.95,71.46 258.05,71.46 257.54,71.97 257.54,72.63 v2(257.62,72.71) ; R4574.1 157.7,77.9 v4(157.31,77.51) 157.07,77.75 C7584.2 ; 233.22,105.01 235.38,105.01 235.63,105.27 Q1001.2 ; 233.22,105.01 230.91,102.7 230.91,98.42 v2(231.17,98.16) ; D6901.2 55.02,82.66 v2(56.17,81.52) ; v2(169.53,144.43) 169.53,145.07 169.91,145.46 C4214.2 ; C4754.2 187.19,75.15 v4(187.15,75.19) ; v2(279.56,91.95) 279.32,91.95 278.69,91.31 Q320.4 ; v2(83.86,80.38) 83.85,80.38 83.91,80.38 84.51,80.98 C3059.2 ; v2(187.23,83.35) 187.28,83.3 C4935.2 ; v2(314.76,105.85) 314.44,106.17 C486.2 ; C4920.2 241.31,84.5 Q4926.4 240.97,83.68 241.04,83.6 v2(241.08,83.6) ; R7401.2 244.13,101.3 v2(244.3,101.48) 243.77,101.48 243.24,100.95 C7401.2 ; C7614.2 307.83,117.12 C7355.2 305.77,118.01 304.37,118.01 v5(304.2,117.84) 304.2,117.93 305.03,118.76 Q7355.2 ; C2556.2 265.31,62.22 264.84,62.69 v2(264.84,62.84) 264.84,62.91 265.03,63.1 C2563.2 ; C1451.2 255.18,80.88 ; Q7350.1 207.39,148.21 v2(207.68,148.21) ; C3311.2 317.13,37.45 ; C7400.2 239.94,111.69 v2(240.01,111.76) ; v2(257.49,99.99) 257.96,99.51 C315.2 ; C7520.2 v2(314.95,81.73) ; v2(245.27,98.28) 245.11,98.28 244.94,98.11 ; v2(162.52,104.69) 162.47,104.69 C7478.1 ; v2(283.62,109.46) 284.05,109.88 R321.2 ; v2(184.22,80.41) 184.69,80.88 C4721.2 ; C7632.2 225.65,130.24 ; v2(308.22,151.37) 308.1,151.5 SW152.G1 ; R4115.2 178.21,144.66 178.15,144.6 v2(178.15,144.39) 177.09,145.46 Q4101.2 ; C806.2 286.75,71.18 286.67,71.1 v2(286.67,70.72) 287.09,70.72 C805.2 ; C7587.2 281.21,124.36 v2(281.34,124.49) ; Q7101.2 304.57,108.14 304.57,108.82 304.58,108.82 ; C7035.2 v2(97.02,143.87) ; v2(180.34,76.18) 180.25,76.08 R4841.1 ; R329.2 266.48,114.78 v2(266.66,114.97) 266.97,114.97 267.37,114.56 C308.2 ; C7629.2 v2(316.35,76.86) ; v2(181.22,86.73) 181.01,86.51 C4746.1 181.04,86.05 C4758.1 ; v2(182.66,132.51) 182.66,132.78 C4145.2 ; C7654.2 296.37,66.24 C508.2 ; v2(174.66,144.38) 174.66,143.83 C7637.2 ; R510.2 C519.2 295.16,59.03 v2(295.23,58.96) ; C3085.2 91.47,87.11 91.69,87.32 93.16,87.32 93.67,86.81 C3067.2 94.13,86.14 v2(94.3,86.14) ; v4(190.97,84.46) 190.96,84.45 C4789.2 ; C7633.2 232.57,129.65 ; v2(284.51,114.54) 284.51,114.29 285.04,113.76 Q113.2 ; C401.2 288.92,107.67 v2(289.17,107.42) ; v2(257.33,104.82) 257.85,104.82 R356.2 C310.2 ; C7456.1 116.24,125.46 115.73,125.97 v2(115.73,126.28) 115.92,126.48 C7455.1 ; C474.2 310.42,83.68 v2(309.15,84.95) ; C3051.2 v2(39.53,63.87) ; R124.2 312.49,150.9 Q125.1 313.5,150.5 v2(313.52,150.48) ; v2(201.45,137.91) C4103.2 ; R7115.2 208.9,156.62 v2(208.82,156.7) ; v2(191.8,54.57) 191.8,57.77 ; v2(226.47,144.38) 226.25,144.17 C4118.2 ; R4509.1 v2(224.52,72.74) ; v2(224.96,53.46) 225.46,53.96 C7462.1 ; R3095.2 75.6,89.62 v2(74.89,90.33) ; C7485.2 128.15,130.8 v4(129.36,132.01) ; v2(240.74,89.35) R4808.2 C4937.2 ; v2(316.52,65.14) 316.35,65.31 C2402.2 ; 260.99,52.97 260.35,53.61 CN1451.G1 260.35,56.19 261.04,56.88 ; R6936.1 57.06,82.59 v2(57.06,81.52) ; R3052.2 v2(40.42,66.15) ; v4(104.05,112.25) 104.05,111.41 104.43,111.03 U3000.2 ; R1000.2 248.32,98.45 v2(248.32,98.41) ; C1001.2 243.03,92.86 C1000.2 244.39,92.86 245.24,93.71 v2(245.24,93.96) ; Q4501.2 222.93,84.24 R4516.2 223.41,84.72 223.41,85.75 v2(223.14,86.02) ; v2(287.94,102.65) 288.42,102.65 R405.2 288.86,102.78 289.43,102.78 R499.1 ; 254.79,81.27 254.4,80.87 CN1451.P5 ; C7634.2 214.08,143.78 D7616.1 ; C4133.2 161.2,141.84 161.7,141.34 v2(161.7,141.08) 162.21,141.59 C4142.2 ; D486.2 311.82,103.6 311.13,102.92 v2(311.08,102.92) ; v2(122.97,131.96) 122.97,131.68 123.86,130.8 C4130.2 ; v2(36.99,63.23) C3054.2 34.37,64.58 33.83,65.12 CN3050.6 ; v2(235.47,137.01) 235.1,137.01 234.73,136.64 C4112.2 ; v2(80.95,83.83) 80.51,83.39 C3093.2 ; D485.2 312.46,84.95 310.17,84.95 309.4,85.71 v2(309.15,85.71) ; C3072.2 93.99,82.38 94.65,83.04 v2(94.65,83.17) ; C314.2 v2(268.26,90.79) ; C803.2 297.99,73.16 v2(298.5,73.16) 298.5,74.36 C807.2 ; C7613.2 316.33,72.71 316.39,72.77 v2(316.39,72.76) ; v2(98.58,88.38) 98.58,87.58 CN200.G1 ; C4104.2 v2(199.3,134.22) ; v4(172.63,62.6) 172.67,62.55 R4771.1 ; C3053.2 39.53,68.95 39.91,68.57 v2(40.16,68.57) 40.42,68.82 R3053.2 ; v2(278.9,64.12) 279.3,63.72 R2567.2 ; v2(268.26,87.11) 267.2,88.17 C335.2 ; C7621.2 277.48,146.29 277.27,146.49 v2(277.27,146.54) ; v2(165.06,78.58) 165.18,78.46 R4572.1 ; C4765.1 180.8,81.03 v2(180.42,80.65) 180.27,80.65 179.78,80.17 C4761.2 ; v2(284.36,65.57) 284.36,66 285.56,67.2 C801.2 285.56,67.97 286.16,68.57 C800.2 ; R6990.1 282.23,133.34 v2(282.73,133.84) 283.12,133.46 C6900.2 ; Q1402.2 241.61,90.35 v2(241.61,89.3) ; v2(158.93,137.66) 158.15,136.88 C4143.2 ; v4(110.71,123.32) 110.4,123.01 C2251.2 ; v2(42.07,83.42) 42.15,83.51 R2511.2 ; C7586.2 v2(226.98,96) ; v2(262.54,85.71) 262.41,85.84 U302.2 ; C4205.2 184.94,142.73 184.44,143.24 v2(184.44,144.33) ; v2(276.38,115.17) 276.26,115.05 C312.2 C311.2 v2(277.15,115.17) ; v5(230.92,66.28) 231.09,66.11 C7661.2 ; C3052.2 v2(39.53,66.15) ; C1307.2 305.12,131.99 C1301.2 ; Q301.2 289.58,96.01 v2(290.48,95.11) ; C7639.2 162.47,135.88 161.88,136.46 v2(161.55,136.46) 161.55,135.69 C4135.2 ; v2(258.99,76.54) 260.15,76.54 Q5401.2 ; C7625.2 187.53,161.4 v5(187.15,161.02) ; v2(252.25,108.19) 251.96,107.89 C2950.2 251.62,107.89 R2951.1 ; v2(157.39,80.18) 157.78,80.57 C4753.2 ; v2(309.28,139.94) 309.83,139.94 C6020.2 ; v2(192.26,62.87) 192.26,62.78 193.2,61.83 193.83,61.83 194.8,60.86 C7459.1 194.8,60.56 C7460.1 ; C2578.1 265.42,65.67 v2(265.42,65.67) R2554.2 C2575.2 ; C4555.2 v2(225.93,74.28) ; R383.1 269.91,87.07 v2(269.65,86.82) ; R801.1 283.37,72.76 ; v4(106.76,117.46) 106.71,117.46 106.49,117.23 R3021.2 ; C6017.2 307.73,140.07 ; C7458.1 275.24,117.59 ; v2(201.45,137.15) 201.12,137.15 C4100.2 ; v2(299.7,121.3) 300.11,120.89 Q7056.1 ; C7582.2 v2(141.56,152.56) ; Q1950.2 295.1,97.01 v2(294.29,97.01) 294.29,97.5 293.76,98.03 292.7,98.03 Q6900.3 ; Q1302.1 314.79,110.33 315.12,110.66 v2(316.59,110.66) 315.6,109.67 Q486.2 ; C4147.2 148.11,136.76 ; v2(168.87,144.43) 168.83,144.47 Q7155.2 ; C303.2 282.35,94.22 282.87,93.71 v2(282.87,93.3) ; v2(125.43,132.57) 125.88,133.02 R4125.2 ; v2(256.07,139.66) 256.42,139.66 257.08,140.32 D4200.2 ; v2(230.1,83.65) 229.49,83.04 C6644.2 ; C7607.2 v2(170.44,52.31) ; v2(296.58,103.62) 296.88,103.92 C400.1 ; v2(316.64,60.82) 316.64,60.69 317.23,60.1 C7627.2 ; R7418.2 242.35,113.52 242.98,114.15 v2(243.21,114.15) 243.24,114.12 C7403.2 ; v2(274.15,52.69) 274.23,52.77 C2559.2 276.09,52.77 276.64,53.33 D2201.3 ; C4723.2 185.34,76.48 v2(185.26,76.56) ; v2(301.91,126.73) 301.91,126.74 301.71,126.94 C7001.2 ; v2(272.93,52.68) 272.21,52.68 C2560.2 C2561.2 ; v5(118.65,97.78) 119.58,97.78 R6309.1 ; R6030.2 291.54,129.53 290.99,129.53 v2(290.99,129.52) ; R2512.1 v2(45.5,84.19) ; R2557.1 277.34,68.86 v2(277.63,69.15) 278.04,68.74 C2552.2 277.7,67.51 277.4,67.21 C2555.2 ; v2(270.14,90.66) 269.49,90.66 C302.2 ; v2(321.09,153.02) 321.09,152.71 SW154.G1 ; v2(285.68,104.89) 285.98,105.18 C402.2 ; v2(47.78,84.69) 48.5,85.41 C4411.2 ; v2(152.57,136.26) 153.03,136.26 C4132.2 ; R7631.2 315.71,43.67 C7631.2 315.71,42.45 315.86,42.3 317.71,42.3 v2(317.81,42.41) ; C7593.2 288.72,92.17 v2(288.6,92.17) ; v2(188.61,88.35) 188.59,88.37 188.64,88.37 188.85,88.57 C4751.2 ; v4(187.12,86.7) 186.45,86.7 C4714.2 ; R404.2 292.77,117 v2(292.77,117.46) ; R401.2 297.26,106.81 296.98,106.54 v2(296.98,106.01) 297.7,106.01 C409.2 ; U4411.4 46.28,86.07 v2(46.55,86.34) ; 155.06,96.24 155.03,96.22 R4801.2 ; 155.06,96.24 154.71,96.24 154.25,95.79 R4800.2 ; 155.06,96.24 v2(155.06,96.24) ; v2(49.69,88) 49.48,88.21 R4411.2 ; R2960.1 247.81,108.65 C2952.2 247.95,108.51 v2(247.95,107.94) ; C7638.2 146.59,146.29 ; v2(250.45,106.87) 249.97,106.39 C7641.2 ; C3006.2 103.07,108.49 v4(102.66,108.08) ; v2(309.28,132.95) 309.28,132.74 309.74,132.28 C7616.2 ; v2(286.8,121.78) 286.16,122.41 C6025.2 ; v2(92.6,91.85) 92.42,91.67 R3092.1 ; v2(187.23,82.53) 187.69,82.07 C4719.2 ; R3003.2 104.55,113.14 104.05,113.64 v2(104.05,113.65) ; v2(121.53,87.45) 121.52,87.46 121.24,87.46 120.75,86.97 CN200.G2 ; C7605.2 143.01,133.46 v2(142.2,132.65) ; R4101.2 204.16,132.96 v2(204.44,132.68) ; R4122.1 v2(210.85,145.91) ; v2(183.53,80.54) 183.53,80.06 C4763.2 ; v2(92.57,92.92) 92.24,92.59 C3089.2 ; v2(301.91,128.38) 301.16,129.13 U7000.3 ; R6904.2 v2(290.61,99.81) ; C527.2 289.21,61.86 v2(288.98,61.63) ; U7400.4 242.49,102.59 v2(243.25,102.59) ; v2(242.48,148.7) 242.48,148.15 R6199.1 ; C7628.2 316.97,38.47 ; v2(303.69,144.26) 303.69,144.43 303.39,144.73 R6005.2 ; v4(157.31,94.14) 157.31,94.31 R4756.2 ; v2(305.34,86.73) 305.04,86.73 C479.2 C478.2 C477.2 ; v2(279.43,69.8) 279.68,70.05 C5309.2 ; C4108.2 231.68,129.65 ; C4102.2 v2(201.45,139.18) ; U6903.2 v2(296.83,136.76) ; C4101.2 v2(201.45,140.19) ; R4131.1 188.67,147.86 v2(188.88,148.07) 189.47,147.48 R4111.1 ; R4136.1 226.94,100.5 v2(227.71,99.73) ; 303.72,110.17 C7589.2 ; C6031.2 282.99,128.81 C6021.2 281.63,128.81 281.46,128.64 281.46,128.6 v2(281.43,128.6) ; v2(224.2,53.46) 224.2,53.67 C7461.1 ; v2(249.5,140.65) 249.59,140.74 R4110.1 ; TP294.1 101.85,129.69 CN290.6 101.85,131.93 101.85,132.79 v2(102.39,133.34) ; R2558.1 272.04,72.58 v2(271.87,72.58) 271.87,72.3 271.43,71.87 C2583.2 ; R6903.2 v2(299.12,135.54) ; R535.2 R534.2 299.16,68.35 298.61,67.8 v2(298.61,67.47) 298.61,66.32 C515.2 ; C3600.2 318.04,127.37 317.48,126.81 v2(317.31,126.81) ; R4123.2 129.13,145.32 v2(128.68,144.87) ; C2412.2 v5(308.26,88.25) ; Q4926.1 239.09,82.02 238.95,82.02 v2(238.94,82.03) ; C7583.2 v2(131.22,113.4) ; C4139.2 152.94,135.62 ; v2(250.22,81.65) 250.6,81.27 C1453.2 ; v2(60.93,90.79) Q6901.2 ; 253.78,83.17 253.78,81.69 C1405.2 ; C4110.2 221.48,141.93 v2(220.76,141.21) ; v2(204.63,144.26) 204.63,144.85 Q7350.4 ; C3308.2 316.09,23.93 ; R487.2 v2(294.72,117.5) ; v2(224.06,80.57) 224.06,80.55 224.11,80.5 C4514.2 ; v2(65.82,90.66) C6902.2 ; R3094.2 v2(77.38,90.28) ; C4202.2 257.72,141.55 257.72,140.83 258.18,140.36 v2(258.52,140.36) 258.9,140.36 259.12,140.58 259.12,141.79 R4109.1 ; C6998.2 293.15,128.08 v2(293.15,127.55) ; D7600.1 283.8,133.97 v2(283.5,133.97) ; Q6903.3 v2(58.45,81.65) ; C4127.2 v2(120.77,141.76) ; v2(185.75,79.68) 185.68,79.61 C4718.2 ; C4211.2 199.63,132.83 v2(199.3,132.83) ; R6351.2 v2(104.55,144.38) ; C6016.2 308.7,140.53 v2(308.55,140.68) ; v2(307.88,82.79) 308.09,83 U2400.1 ; C4114.2 231.85,144.34 v2(231.81,144.38) ; v2(288.61,121.78) 288.73,121.91 289.73,121.91 C6027.2 ; R3071.1 79.36,89.5 v2(78.79,90.07) 78.79,90.22 C3073.2 ; v2(316.52,79.36) 316.35,79.19 R7629.2 ; C4720.2 185.95,82.07 v2(185.6,81.72) ; C4207.2 v2(209.07,145.91) ; v2(264.57,88.17) 264.57,88.14 264.6,88.17 C305.2 ; v2(131.86,144.26) 132.18,144.26 132.56,143.88 Q4102.E ; v2(270.11,69.63) 269.74,70.01 R2574.2 269.4,70.22 269.02,70.6 C2582.2 ; C7594.2 v2(245.52,82.03) ; C7476.1 v2(163.35,104.63) ; v2(181.52,82.92) 180.92,82.92 C7591.2 ; R3051.2 v2(40.42,63.87) ; C7640.2 148.88,136.3 148.88,136.51 ; v2(320.45,41.01) 320.15,40.7 U3300.2 ; v2(286.16,65.14) 286.16,63.49 285.77,63.09 285.77,62.27 285.6,62.1 ; C6460.2 249.04,81.9 v5(248.32,81.9) R6451.2 ; v2(311.56,112.51) 311.56,112.34 311.64,112.27 311.63,112.27 Q1302.4 ; v2(36.86,68.69) 36.99,68.82 C3056.2 35.85,69.28 35.43,69.7 CN3050.8 ; v2(126.02,149.59) 126.02,147.31 125.72,147.01 C3504.2 ; R4100.2 v2(199.3,135.11) ; C4136.2 152.31,141.34 v2(152.56,141.08) 153.03,141.08 C4134.2 ; v2(120.81,137.15) C4125.2 ; C7468.1 v2(141.51,160.64) ; v2(199.3,133.59) 199.76,133.59 C4105.2 ; C6360.2 v5(99.74,147.69) ; v2(281.48,126.37) 281.46,126.35 281.51,126.31 C6024.2 ; C3015.2 v2(117.38,120.25) ; R2555.2 261.02,57.64 ; C7502.2 135.74,65.14 ; D7605.1 v2(303.18,125.46) ; v2(93.25,85.46) 93.25,85.35 C3071.2 ; v2(120.81,136.26) C4126.2
  TOP w0.508: v2(215.3,144.38) 215.3,144.26 214.82,143.78 D7616.1 ; C3003.2 104.08,108.03 105.06,107.05 v4(105.44,107.05) ; R520.1 310.93,68.06 v2(311.59,68.72) ; C4525.2 v4(193.33,85.84) ; C4526.2 v4(195.87,85.84) ; v5(307.75,140.07) 307.73,140.07 L6035.4 L6035.3 ; D7615.1 v4(194.6,85.84) ; C4117.2 v2(224.53,144.29)
  TOP w0.635: v4(191.29,86.87) 190.8,87.36 C4700.2 ; v4(191.29,85.71) C4590.2
  TOP w0.762: CN1451.G2 239.57,54.6 233.71,54.6 231.85,52.73 S38.1 ; v4(274.23,147.43) 273.16,148.5 CN4750.G2 CN4750.G1
  BOTTOM w0.127: v2(192.16,97.8) 192.11,97.8 191.64,97.33 U4555.AY30 ; v2(189.29,97.62) 189.21,97.54 189.21,96.19 U4555.AY26 ; v2(187.24,99.4) 187.05,99.21 187.05,98.79 186.5,98.24 U4555.AY22 ; v2(184.06,97.27) 184.07,97.26 U4555.AY18
  BOTTOM w0.152: 187.85,96.19 U4555.AY24 187.85,96.22 187.84,96.23 187.84,97.33 v2(187.85,97.34) ; v2(210.05,93.43) 209.86,93.24 209.86,92.3 209.89,92.27 U4555.AN60 ; U4555.AN63 211.84,92.27 213.01,92.27 213.14,92.4 v2(213.15,92.4)
  BOTTOM w0.178: v2(213.18,89.99) 213.17,89.99 213.02,89.84 211.84,89.84 U4555.AJ63 ; v2(204.25,97.28) 204.41,97.12 204.41,96.31 204.52,96.2 U4555.AY51 204.52,96.19 ; U4555.AY57 208.3,97.09 208.52,97.31 v2(208.52,97.45) ; U4555.AG61 210.54,88.49 ; v2(205.71,97.47) 205.87,97.31 U4555.AY53 ; U4555.A32 192.68,74.32 192.68,74.75 U4555.B32 192.57,75.01 192.28,75.31 v2(192.28,75.53) ; 211.19,88.49 U4555.AG62 ; U4555.AD63 212.18,87.05
  BOTTOM w0.203: U4555.AU1 172.93,94.54 v4(172.71,94.76) ; v2(178.78,95.52) 178.49,95.22 178.37,95.22 U4555.AV8 ; 209.89,92.27 209.84,92.23 209.84,91.51 ; U4555.AT40 197.22,94.2 198.6,94.2 U4555.AT42 198.7,94.11 ; v2(179.58,97.29) 179.58,97.25 179.58,97.25 179.58,97.22 179.91,96.9 179.91,96.52 U4555.AY11 ; U4555.M22 186.95,80.91 187.1,81.06 v2(187.12,81.06) ; U4555.R22 186.14,82.53 v2(187.23,82.53) ; v2(175.26,75.54) 174.72,75.54 174.3,75.96 174.19,75.96 U4555.D2 ; U4555.AJ60 209.86,89.87 209.86,90.64 ; U4555.AY6 176.91,96.52 176.91,97.16 v2(176.82,97.25)
  BOTTOM w0.254: R5319.2 286.54,78.55 286.54,79.11 286.12,79.53 C5312.2 ; U5301.19 279.81,76.92 279.53,77.2 279.53,77.48 v2(279.55,77.5) ; U4555.AM31 U4555.AL31 191.8,90.1 191.52,89.83 191.52,89.34 U4555.AH30 ; U4555.AM31 U4555.AN31 ; U4555.AM31 191.29,91.13 v2(191.29,91.13) 191.22,91.13 190.9,90.8 U4555.AL29 ; U4555.C11 179.89,75.29 U4555.D12 ; U6600.29 230.61,83.14 v2(230.1,83.65) ; U4555.AN52 205.52,91.7 v2(205.68,91.7) 205.64,91.66 v2(205.64,91.13) ; U4555.AN52 204.94,92.28 204.48,92.28 204.3,92.1 ; U4555.AN52 205.48,92.46 205.68,92.46 v2(205.69,92.47) ; U4555.AN52 U4555.AP52 205.19,92.82 205.19,93.3 205.12,93.37 U4555.AR52 205.3,93.4 205.87,93.97 U4555.AU53 ; U4555.L7 177.47,80.22 v2(177.47,79.57) ; U4555.AF11 179.59,88.17 179.5,88.07 179.5,87.48 v2(179.43,87.41) ; v2(181.78,95.54) 181.7,95.54 181.37,95.22 U4555.AV14 ; U4555.AP22 186.57,93.08 v2(186.63,93.08) ; U4555.AN39 U4555.AP39 ; U4555.AN39 U4555.AL39 ; U4555.AN39 197.34,91.78 U4555.AN40 ; U4555.AP39 197.34,92.43 U4555.AN40 ; U4555.AP39 U4555.AR39 ; v4(172.81,85.6) 173.54,85.6 U4555.AA1 ; v2(203.74,93.64) 203.92,93.64 204.26,93.98 U4555.AU51 ; v2(203.74,93.64) 203.53,93.64 U4555.AR49 ; v2(203.74,93.64) 203.74,93.79 203.45,94.08 203.45,94.13 ; U4555.AN35 194.26,92.1 194.59,92.43 v2(194.66,92.43) ; v2(193.7,91.07) 193.52,91.07 193.26,90.8 U4555.AL33 ; v2(180.31,90.52) 180.97,90.52 181.11,90.66 181.11,90.66 ; v2(180.31,90.52) 179.34,90.52 179.19,90.66 U4555.AL10 ; v2(180.31,90.52) 180.81,90.01 U4555.AJ13 ; v2(233.2,83.77) 233.49,84.06 234.5,84.06 235.12,83.44 235.12,83.26 235.49,82.89 ; 201.34,92.1 201.23,92.21 200.52,92.21 U4555.AN45 U4555.AN43 199.38,92.1 v2(199.05,92.43) 198.81,92.43 U4555.AN42 198.15,92.43 v2(198.06,92.43) 197.99,92.43 U4555.AN40 ; 201.34,92.1 201.78,91.67 v2(201.85,91.67) 201.95,91.67 U4555.AN48 ; 201.34,92.1 U4555.AN46 ; U4555.AL52 205.31,90.8 v2(205.64,91.13) ; U4555.AU20 185.63,94.24 185.68,94.18 186.11,94.18 186.16,94.24 U4555.AU22 186.5,94.24 186.95,94.24 186.97,94.22 187.24,93.96 v2(187.48,93.73) ; U4555.AU20 U4555.AV20 185.29,95.36 v2(185.25,95.4) ; U4555.AU20 184.85,94.24 184.8,94.19 184.48,94.19 184.43,94.24 U4555.AU18 184.07,94.24 183.64,94.24 183.51,94.11 183.3,94.11 183.17,94.24 U4555.AU16 ; v2(187.48,91.13) 187.15,90.8 U4555.AL23 ; v2(187.48,91.13) 187.48,90.5 v2(187.52,90.45) 187.23,90.15 U4555.AK23 187.06,89.57 ; v2(187.48,91.13) 187.15,91.45 187.15,91.45 U4555.AM23 ; v2(187.48,91.13) v2(187.48,92.43) ; U4555.AU16 182.76,93.79 v2(182.56,93.58) 182.76,93.38 U4555.AR17 U4555.AP17 U4555.AN17 U4555.AM17 182.75,91.12 182.36,90.73 v2(182.23,90.73) ; U4555.AU16 U4555.AV16 182.76,95.54 ; U4555.A36 195.1,74.23 195.1,74.84 U4555.B36 195.08,75.3 v2(195.02,75.36) 194.87,75.36 U4555.D35 194.15,75.84 U4555.D34 193.83,76.14 193.52,75.84 U4555.D33 192.88,75.45 v2(192.84,75.45) 192.36,75.45 v2(192.28,75.53) 191.98,75.84 U4555.D31 191.65,75.84 U4555.D30 191,75.84 U4555.D29 190.72,75.84 v2(190.36,75.48) ; R4876.1 172.58,101.97 172.17,101.56 v2(172.17,101.41) ; v2(217.94,72.45) 217.74,72.25 R4527.1 ; v2(204.69,91.13) 204.62,91.13 204.3,90.8 U4555.AL51 ; U4555.AY33 U4555.AW33 ; U4555.AW33 193.23,95.54 U4555.AV34 ; U4555.AW33 192.99,94.94 U4555.AV33 ; v2(190.39,95.4) 190.42,95.36 U4555.AV28 U4555.AU28 ; U4555.AT43 200.33,94.16 ; 200.33,94.16 201.79,94.16 U4555.AT46 201.85,94.11 201.91,94.17 202.59,94.17 202.59,94.18 202.98,94.18 202.98,94.17 203.41,94.17 203.45,94.13 ; 200.33,94.16 199.93,93.76 v2(199.93,93.73) ; 182.76,95.54 182.72,95.58 182.72,96.19 U4555.AY16 182.61,96.3 182.61,96.86 182.18,97.29 v2(182.02,97.29) ; 182.76,95.54 U4555.AW16 ; v2(174.54,81.48) 174.54,81.37 174.84,81.07 U4555.N3 ; v2(193.7,93.67) 193.52,93.67 U4555.AR33 ; v2(193.7,93.67) 193.97,93.94 U4555.AT35 194.03,94.16 194.46,94.16 194.47,94.17 194.86,94.17 194.87,94.16 195.49,94.16 U4555.AT37 195.66,93.99 v2(196.08,93.99) 196.27,94.17 197.05,94.17 U4555.AT40 197.12,93.12 U4555.AR39 ; v2(193.7,93.67) 193.15,94.22 U4555.AU33 ; v2(197.9,75.5) 197.36,75.5 v2(197.32,75.46) ; v2(197.9,75.5) 197.9,75.17 U4555.B40 U4555.A40 ; v2(197.9,75.5) 198.24,75.84 U4555.D41 198.6,76.16 U4555.D42 199.08,76.16 U4555.D43 199.46,75.84 v2(199.83,75.47) ; U4555.D57 208.26,75.84 v2(207.86,75.44) ; U4555.C20 185.05,74.92 184.9,74.77 v2(184.9,74.39) 185.25,74.39 U4555.B20 ; v2(209.13,85.94) 209.13,85.43 U4555.AA58 209.2,85.22 209.56,84.85 U4555.Y59 208.91,84.2 U4555.V58 209.1,83.73 209.1,82.8 U4555.T58 209.56,81.96 U4555.P59 ; 186.91,75.67 186.91,75.43 v4(187.15,75.19) 187.48,74.86 U4555.B24 ; 186.91,75.67 U4555.D23 ; 186.91,75.67 186.27,76.31 185.77,76.31 ; U4555.G8 177.89,77.65 177.25,77.65 U4555.G6 176.79,77.5 v2(176.58,77.5) ; v2(182.23,90.73) 182.23,90.61 181.63,90.01 ; v2(182.23,90.73) 182.49,90.47 U4555.AL17 182.85,90.38 v2(182.85,89.7) ; 210.54,93.52 210.59,93.58 211.35,93.58 ; 210.54,93.52 U4555.AT61 ; 210.54,93.52 210.14,93.52 v2(210.05,93.43) 209.78,93.69 209.78,93.94 209.76,93.96 209.76,94.02 209.54,94.24 U4555.AU59 ; v2(165.64,103.49) 166.66,103.49 169.78,100.37 169.78,100.14 171.02,98.89 v2(171.58,98.89) ; C4788.1 164.92,100.29 164.56,99.93 163.63,99.93 163.13,100.44 157.89,100.44 156.75,101.59 156.75,103.24 157.59,104.07 164.55,104.07 164.92,103.7 C4767.1 ; v2(211.16,82.94) 211.16,83.05 U4555.U61 ; U4555.AU59 209.19,94.24 209.13,94.18 208.82,94.18 208.76,94.24 208.3,94.24 ; U4555.AU59 U4555.AV59 U4555.AW59 209.86,95.86 U4555.AW60 ; U4555.AU51 204.89,94.24 204.94,94.18 205.81,94.18 U4555.AU53 ; U4555.AU51 U4555.AV51 U4555.AW51 204.52,96.19 ; U4555.D55 207.51,76.42 v2(207.54,76.42) ; U4555.D55 206.69,75.84 U4555.D54 206.04,75.84 U4555.D53 205.4,75.43 ; U4555.D55 207.12,75.84 207.51,75.44 v2(207.86,75.44) ; U4555.AU53 205.92,94.18 206.59,94.18 206.65,94.24 207.08,94.24 ; v2(279.43,69.8) 279.75,70.12 U5301.2 ; v2(319.46,117.74) 320,117.2 CN3601.68 ; U4555.H57 208.59,77.68 208.7,77.58 208.7,77.53 208.91,77.32 U4555.F58 ; U4555.AD3 174.54,87.36 v2(174.54,87.48) ; U4555.AM52 205.44,91.13 v2(205.64,91.13) ; v2(184.78,91.21) 184.74,91.21 184.34,90.8 U4555.AL20 ; v2(267.72,67.83) 267.72,68.08 268.01,68.36 U5401.52 ; U4555.AL39 197.08,89.63 197.21,89.5 ; U4555.AL39 197.34,90.48 U4555.AL40 198,91.14 v2(198.06,91.14) ; 183.63,75.67 U4555.D18 ; 183.63,75.67 184.04,75.26 U4555.C18 ; 183.63,75.67 183.2,76.1 v2(183.2,76.18) 183.13,76.18 182.8,76.5 ; U4555.AN48 202.49,92.2 203.2,92.2 203.29,92.1 ; U4555.AN48 U4555.AP48 202.72,93.08 v2(202.78,93.08) ; U4555.AH30 191.03,89.5 U4555.AJ29 190.71,88.96 v4(190.85,88.81) ; U4555.AH30 191.51,89.02 191.51,88.63 v2(191.59,88.55) ; v2(212.92,87.07) 212.91,87.07 212.89,87.05 212.18,87.05 ; U4555.AN31 U4555.AP31 U4555.AR31 ; U4555.AN31 192.03,91.78 U4555.AN32 192.36,92.1 192.68,92.43 v2(192.75,92.43) ; 181.11,90.66 181.11,90.53 181.63,90.01 ; 181.11,90.66 U4555.AL13 ; v2(205.64,91.13) 205.64,91.13 v2(205.64,90.34) ; v2(199.83,75.47) 199.86,75.5 v2(200.4,75.5) 200.74,75.84 U4555.D45 201.11,76.16 U4555.D46 201.59,76.16 U4555.D47 202.25,75.5 v2(202.3,75.5) ; v2(199.83,75.47) 199.83,75.13 U4555.B44 U4555.A44 ; U4555.D12 180.34,75.75 v2(180.34,76.18) 180.27,76.18 179.95,76.51 ; U4555.D12 U4555.D14 ; 203.45,94.13 U4555.AT49 ; 210.54,88.49 211.84,88.49 U4555.AG63 ; U4555.AR31 191.8,93.76 ; U4555.AR31 191.29,93.08 v2(191.29,93.08) 191.22,93.08 U4555.AP29 ; 191.8,93.76 192.13,93.76 192.58,94.22 U4555.AU33 ; 191.8,93.76 191.8,94.08 U4555.AU30 191.63,94.24 191.28,94.24 191.21,94.17 190.49,94.17 U4555.AU28 ; U4555.AP20 184.37,92.75 184.53,92.91 184.54,92.91 184.7,93.08 v2(184.73,93.08) ; 181.63,90.01 U4555.AJ14 ; 179.95,76.51 179.95,76.5 179.44,77.01 v2(179.44,77.44) 179.47,77.47 v2(179.47,78.78) 179.32,78.78 179,79.1 U4555.J10 ; 179.95,76.51 U4555.E11 ; 203.71,88.86 v4(203.71,88.86) ; U4555.AH28 189.73,89.5 U4555.AJ27 189.26,89.5 189.06,89.7 188.3,89.7 U4555.AJ25 187.78,89.5 U4555.AH24 187.06,89.57 ; U4555.D14 181.06,75.88 v2(181.29,76.11) v2(182.24,76.11) 182.41,76.11 182.8,76.5 ; U4555.D14 181.46,75.27 U4555.C14 181.46,75.08 181.45,75.07 181.45,74 U4555.A14 ; U4555.AV49 203.01,95.22 203.01,95.3 203.29,95.58 v2(203.43,95.58) 203.7,95.86 U4555.AW50 ; v2(211.18,85.95) 211.18,86.03 U4555.AC61 ; U4555.T1 172.75,82.61 v4(172.73,82.58) ; v2(179.54,72.49) 179.9,72.85 U4555.A11 ; U6610.3 235.11,66.6 234.64,66.12 234.64,65.82 234.58,65.77 ; 183.76,77.8 184.41,77.16 U4555.F20 184.71,77.11 v2(185.26,76.56) 185.26,76.56 185.52,76.56 185.77,76.31 ; 183.76,77.8 U4555.G18 ; 183.76,77.8 183.4,78.16 v2(183.24,78.16) 183.09,78.16 182.8,78.45 U4555.H17 ; U4555.AN36 195.52,92.1 v2(195.64,91.99) ; 205.11,74.86 205.21,74.76 205.21,74.31 205.11,74.21 U4555.A52 ; 205.11,74.86 U4555.B52 ; 205.11,74.86 205.4,75.15 205.4,75.43 ; v2(187.48,93.73) v2(187.48,92.43) ; v2(187.48,93.73) 187.85,94.11 U4555.AU24 ; v2(187.48,93.73) 187.39,93.73 U4555.AR23 ; v2(187.48,92.43) 187.39,92.43 ; U4555.AN51 204.3,92.1 ; 204.3,92.1 204.19,92.21 203.4,92.21 203.29,92.1 ; v2(205.64,90.34) 205.31,90.34 U4555.AK52 ; v2(205.64,90.34) 205.64,89.2 ; 189.2,94.24 189.56,94.24 189.62,94.18 189.93,94.18 189.99,94.24 189.99,94.24 U4555.AU28 ; 189.2,94.24 U4555.AU26 ; 189.2,94.24 188.74,94.24 188.67,94.17 187.92,94.17 U4555.AU24 ; v2(182.85,89.7) 182.91,89.7 U4555.AH17 U4555.AH19 184.07,89.38 184.27,89.58 184.65,89.58 U4555.AH20 184.88,89.36 184.88,89.38 185.15,89.65 v2(185.3,89.65) 185.3,89.2 U4555.AG21 186.12,89.01 U4555.AH22 ; v2(182.85,89.7) 182.78,89.7 182.44,89.36 U4555.AH16 ; 187.39,92.43 U4555.AP23 ; 187.39,92.43 187.06,92.1 U4555.AN23 ; U4555.C27 189.47,75.19 v2(189.77,75.49) ; U4555.G3 174.54,78.37 v2(174.54,78.47) ; U4555.AV33 193.23,94.89 U4555.AV34 ; U4555.AV33 192.94,94.24 U4555.AU33 ; U4555.B24 187.77,75.07 v4(187.77,75.39) ; U4555.B24 U4555.A24 187.29,73.95 187.29,73.49 v2(187.05,73.25) ; v2(177.3,83.54) 177.3,83.86 U4555.V7 ; U4555.AL57 208.04,90.8 208.26,91.02 v2(208.49,91.02) ; U4555.AP54 206.46,93.06 v2(206.62,93.06) ; U4555.AL60 U4555.AL61 210.99,91.06 v2(211.05,91.11) ; U4555.AL60 209.89,91.47 209.84,91.51 ; U4555.AL60 209.89,90.67 209.86,90.64 ; v2(199.93,93.73) 199.76,93.73 199.43,93.4 U4555.AR43 ; v2(199.93,93.73) 199.49,94.16 199.22,94.16 199.22,94.16 198.83,94.16 198.83,94.16 198.75,94.16 198.7,94.11 ; U5401.2 263.59,70.12 263.5,70.04 v2(263.3,69.84) ; v2(207.05,95.4) 207.08,95.36 U4555.AV55 207.08,94.24 ; U4555.AG1 173.54,88.6 v4(172.81,88.6) ; v2(189.46,90.97) 189.16,90.97 188.99,90.8 U4555.AL26 ; v2(207.55,88.95) 207.61,89.01 U4555.AJ56 ; U4555.V3 174.84,84.06 174.55,84.35 v2(174.55,84.47) ; v2(177.82,81.58) 177.82,81.82 178.12,82.13 U4555.R8 ; U4555.K12 v2(180.42,80.65) ; U4555.L15 U4555.L17 ; U4555.L20 184.79,80.02 185.4,80.02 v2(185.75,79.68) ; v2(179.44,84.57) 179.44,84.56 179.01,84.98 U4555.Y10 U4555.AB10 ; U4555.AL46 201.07,91.07 v2(200.88,91.07) 200.68,91.07 U4555.AL45 ; U4555.AK3 174.54,90.35 v2(174.54,90.46) ; U4555.AP29 U4555.AP29 ; 185.77,76.31 U4555.D21 ; 203.29,92.1 U4555.AN49 ; v2(202.3,75.5) 202.3,75.17 U4555.B48 U4555.A48 ; v2(202.3,75.5) 202.83,75.5 v2(202.88,75.45) 202.91,75.45 U4555.D49 203.62,76.16 U4555.D50 204.1,76.16 U4555.D51 204.79,75.47 v2(204.83,75.47) 205.36,75.47 205.4,75.43 ; U4555.AP26 189,92.75 189.33,93.08 v2(189.38,93.08) ; v2(185.6,83.37) 185.64,83.41 185.64,83.65 U4555.W22 ; U4555.P62 211.51,81.81 212.16,81.81 ; v2(211.16,76.93) 211.15,76.94 211.15,77.06 210.86,77.35 U4555.F61 ; U4555.AL36 195.63,90.8 v2(195.65,90.82) ; v4(212.81,75.28) 212.8,75.28 212.21,75.86 212.16,75.86 ; v2(235.85,79.08) 235.9,79.08 236.03,78.95 236.03,78.95 236.55,78.43 R6612.2 ; R4540.1 217.36,92.72 216.87,92.24 v2(216.87,92.13) ; v2(177.32,85.46) 177.32,85.79 U4555.AB7 ; U4555.D59 209.94,75.33 v2(209.94,75.25) 209.94,75.16 210.2,74.91 U4555.B60 ; 211.35,93.58 211.54,93.58 211.7,93.73 U4555.AT63 ; 211.35,93.58 U4555.AT62 ; U5401.11 v2(263.3,73.72) ; U4555.AE5 175.98,87.65 v2(175.98,87.35) ; U4555.AV36 195.13,95.22 195.43,95.52 v2(195.53,95.52) 195.88,95.86 U4555.AW37 ; v2(212.9,81.67) 212.75,81.81 212.16,81.81 ; 187.06,89.57 186.94,89.44 U4555.AJ23 186.37,89.72 v2(185.9,89.72) ; U4555.AU24 U4555.AV24 U4555.AW24 187.85,96.19 ; U4555.D5 176.03,75.54 v2(175.26,75.54) ; U4555.H13 181.06,78.46 v2(181.34,78.18) ; v2(186.63,91.13) 186.57,91.13 186.24,90.8 186.24,90.8 U4555.AL22 ; U4555.Y63 212.16,84.81 212.96,84.81 213.04,84.89 213.04,84.89 v2(213.04,84.89) ; 212.16,81.81 U4555.P63 ; U4555.AW35 194.38,95.87 194.09,95.57 v2(193.98,95.57) 193.92,95.57 U4555.AV34 ; 212.16,75.86 211.57,75.86 U4555.D62 ; 212.16,75.86 U4555.D63 ; U5401.19 263.2,76.92 v2(263.1,77.02) ; U4555.AV39 197.01,95.52 v2(197.11,95.52) 197.19,95.52 U4555.AW40 ; U4555.B26 188.49,75.19 U4555.C25 187.97,75.19 v4(187.77,75.39) ; v2(320.07,115.43) 320.34,115.7 CN3601.65 ; U4555.C57 208.12,75.19 v2(207.86,75.44) ; 207.08,94.24 207.52,94.24 207.57,94.18 207.89,94.18 207.94,94.24 208.3,94.24 ; 207.08,94.24 U4555.AU55 ; v2(207.86,75.44) 207.62,75.2 U4555.B56 207.77,74.72 207.77,74.36 U4555.A56 ; v2(209.86,78.45) 209.86,78.56 U4555.J59 ; U4555.V10 179.12,84.03 179.37,83.79 v2(179.37,83.48) 179.29,83.56 178.57,83.56 U4555.U9 ; U4555.D37 196.1,76.16 U4555.D38 196.57,76.16 U4555.D39 196.94,75.84 v2(197.32,75.46) ; v2(212.88,78.82) 212.78,78.82 212.78,78.82 212.16,78.82 U4555.J63 ; U4555.AR39 196.63,93.08 v2(196.59,93.03) 196.45,93.03 U4555.AP38 ; v2(211.15,79.93) 211.15,80.07 210.86,80.35 U4555.L61 ; U5301.11 v2(279.55,73.72) ; U4555.AM1 173.54,91.6 v4(172.81,91.6) ; U4555.N10 179.3,81.47 v2(179.3,81.65) 179.3,81.83 179.01,82.13 U4555.R10 ; U4555.A18 184.14,73.88 184.14,73.27 184.23,73.18 v2(184.23,73.16) ; U4555.AP10 179.19,92.61 179.03,92.61 178.76,92.89 v2(178.76,92.9) ; v2(189.77,75.49) 189.77,75.49 189.42,75.84 U4555.D27 189.14,75.84 U4555.D26 188.49,75.84 U4555.D25 188.15,75.84 187.77,75.46 v4(187.77,75.39) ; v2(189.77,75.49) 190.34,75.49 v2(190.36,75.48) ; v2(193.4,71.66) 193.28,71.54 R4791.2 R4775.2 ; v2(190.36,75.48) 190.36,75.15 U4555.B28 U4555.A28 ; U4555.C38 196.34,75.51 196.66,75.19 U4555.C39 197.05,75.19 v2(197.32,75.46) ; U4555.AV43 199.86,95.22 200.16,95.52 v2(200.26,95.52) 200.34,95.52 U4555.AW44 ; U5301.52 v2(284.26,68.21) ; v2(176.85,92.24) 177,92.24 U4555.AN7 ; U4555.AP3 174.54,93.36 v2(174.54,93.47) ; U4555.AB22 185.68,86.24 185.68,86.53 v2(185.61,86.61) ; U4555.AR5 175.97,93.74 v2(175.97,93.76) ; v2(165.64,100.7) 167.67,100.7 170.82,97.55 174.63,97.55 175.15,97.03 v2(175.32,97.03) 175.46,96.88 U4555.AY4 175.46,96.23 175.51,96.18 U4555.AW4 ; U4555.AW42 199.04,95.86 v2(198.71,95.53) 198.6,95.53 U4555.AV41 ; 208.3,94.24 U4555.AU57 ; 182.8,76.5 U4555.E17 ; v2(171.1,101.46) 170.68,101.88 C523.2 ; v2(206.54,91.13) 206.47,91.13 206.15,90.8 U4555.AL54 ; U4555.K1 172.74,79.61 v4(172.74,79.61) ; U4555.AY59 209.62,96.52 210.61,97.5 210.61,98.36 v2(210.64,98.39) ; U4555.AT13 181.35,93.91 181.67,93.59 U4555.AR15 ; U4555.AV46 201.43,95.22 201.73,95.52 v2(201.83,95.52) 202.18,95.86 U4555.AW47 ; U4555.AP57 208.05,92.75 208.37,93.08 v2(208.44,93.08)
  BOTTOM w0.305: v2(111.37,119.09) 111.53,119.25 CN3000.14 ; CN3601.53 320.46,109.7 319.95,110.22 v2(319.95,110.35) ; v2(42.07,83.42) 42.23,83.26 U2511.14 ; CN3601.59 320.39,112.7 319.95,112.26 v2(319.95,112.25) 319.95,111.69 320.43,111.2 CN3601.56 ; v2(111.03,108.23) 111.2,108.23 112.22,109.25 CN3000.34 ; v2(111.16,107.43) 111.92,107.43 112.24,107.75 CN3000.37 ; v2(319.95,113.78) 320.37,114.2 CN3601.62 ; CN3000.31 113.7,110.75 113.91,110.75 v2(113.96,110.75) ; v2(319.06,108.95) 319.56,108.44 319.96,108.44 320.2,108.2 CN3601.50 ; CN3601.77 v2(320.11,121.7) ; v2(322.49,118.74) 322.45,118.7 CN3601.71 ; v2(111.03,113.95) 111.23,113.95 111.44,113.75 CN3000.25 ; CN3601.86 v2(320.11,126.2) ; v2(111.36,115.83) 111.44,115.75 CN3000.21 ; v2(322.49,119.76) 322.49,119.97 322.43,120.04 322.27,120.2 CN3601.74 ; R6301.2 120.52,97.35 121.06,97.89 121.06,98.23 v5(121.24,98.41) ; v2(113.96,112.07) 113.78,112.25 112.97,112.25 CN3000.28 ; v2(320.21,127.75) 320.26,127.7 CN3601.89 ; v2(320.17,124.53) 320.35,124.7 CN3601.83 ; CN3000.17 111.57,117.75 v2(111.41,117.59) ; v2(320.12,123.02) 320.12,123.1 320.23,123.2 CN3601.80 ; CN3000.40 111.52,106.25 v2(111.22,106.56) ; CN3000.5 112.11,123.75 111.62,124.23 v2(111.27,124.23) ; v4(177.96,152.92) U6240.8
  BOTTOM w0.356: CN1300.63 316.46,126.15 316.64,125.97 316.64,125.97 v2(316.63,125.97) 316.64,125.95 316.64,124.95 316.34,124.65 CN1300.57 ; v2(125.51,95.36) 125.32,95.36 124.99,95.69 U6300.19 ; CN1951.71 305.57,101.55 v2(305.73,101.71) 305.68,101.71 305.34,102.05 CN1951.73 ; CN1300.39 313.31,120.15 313.01,120.46 v2(312.35,120.46) ; v5(152.69,160.11) 152.74,160.16 U6200.4 ; v2(305.34,95.02) 305.31,95.05 CN1951.45 ; v2(246.21,57.52) 246.44,57.75 CN1400.71 ; v2(157.21,157.19) 157.16,157.24 156.79,157.24 156.59,157.44 U6200.19 ; CN1300.51 316.75,123.15 316.88,123.29 v2(316.88,123.29) 316.77,123.18 316.77,121.91 316.52,121.65 CN1300.45 ; CN1400.57 248.57,61.25 249.94,62.62 v2(249.94,64.27) ; CN1300.7 316.64,112.15 v2(317.02,112.53) ; CN1400.33 v2(248.75,67.25) ; CN1400.45 v2(248.72,64.25) ; CN1400.39 248.39,65.75 248.62,65.98 v2(248.62,66.15) ; CN1400.11 246.22,72.75 v2(246.14,72.84) ; U6240.4 v4(172.62,153.42) ; 111.69,121.75 CN3000.9 ; v2(305.34,90.55) CN1951.27 ; CN1300.69 314.2,127.65 313.93,127.92 313.93,128.84 314.24,129.15 CN1300.75 316.26,129.15 v2(316.64,128.76) ; CN1951.51 v2(305.34,96.55) ; v2(305.69,93.3) 305.45,93.55 CN1951.39 ; v2(309.02,115.81) 309.02,115.05 308.88,114.9 CN1300.18 ; v2(305.36,87.44) 305.26,87.55 CN1951.15 ; CN1400.27 v2(248.75,68.75) ; v2(248.57,57.51) 248.57,57.45 248.37,57.25 CN1400.73 ; CN1400.5 246.42,74.25 v2(246,74.67) 245.99,74.67 245.99,74.62 246.12,74.75 CN1400.3 ; CN1951.33 305.7,92.05 v2(305.7,92.04) ; 305.57,84.05 CN1951.1 ; CN1951.21 v2(305.3,89.05) ; U6300.4 v5(121.24,98.41) ; CN1951.3 305.2,84.55 v2(305.34,84.69) ; CN1400.51 248.39,62.75 249.33,63.69 v2(249.33,64.25) ; v2(316.52,130.03) 316.3,130.25 CN1300.G2 ; CN1300.1 316.58,110.65 ; v2(312.33,118.45) 312.68,118.45 312.88,118.65 CN1300.33 ; v2(305.34,86.05) CN1951.9 ; v2(305.34,98.05) CN1951.57
  BOTTOM w0.381: v2(108.49,89.14) 108.74,88.89 C7608.2 ; C3501.2 124.24,155.1 v2(124.37,154.97) ; v2(286.16,65.14) 286.16,65.39 285.91,65.64 C5311.2 ; 305.57,84.05 308.25,84.05 v2(309.15,84.95) ; R4731.2 157.97,77.56 157.36,77.56 ; CN375.1 141.26,77.41 v2(141.26,77.96) ; R521.1 290.91,59.18 290.48,59.61 v2(290.48,60.31) ; v2(276.59,80.35) 276.41,80.35 275.99,80.77 Q5301.2 274.53,80.77 C5450.2 ; CN4100.66 243.5,141.07 v2(244.07,140.5) ; U4555.AJ54 206.64,89.5 U4555.AH55 ; U4555.AJ54 206.31,88.93 v4(206.27,88.89) ; U4555.AJ54 205.99,89.5 U4555.AH53 ; C7596.2 143.16,64.09 v2(143.25,63.99) ; v2(147.1,81.77) 147.35,81.77 147.86,81.27 R370.2 ; v2(247.51,140.11) 247.42,140.11 246.94,140.59 246.94,141.16 247.1,141.32 CN4100.54 ; CN4125.8 183.9,143.9 183.8,144 v2(183.8,144.33) ; v2(263.58,140.07) 263.58,140.68 262.7,141.56 CN4100.2 ; R3061.1 89.17,90.96 89.55,91.34 89.55,91.65 v2(89.58,91.67) 89.37,91.87 C3069.1 ; C6211.2 151.42,159.67 v5(151.37,159.62) ; v2(169.89,132.66) 169.8,132.74 CN4125.55 ; C6311.2 127.54,102.98 ; C1700.2 v2(98.58,88.38) ; U3500.25 125.75,149.86 v2(126.02,149.59) ; v2(161.27,70.33) 161.27,70.59 162.91,72.22 ; CN4125.44 173.1,141.06 v2(172.68,140.64) 172.5,140.82 CN4125.46 ; R811.2 285.16,61.73 Q800.2 v2(285.16,60.31) ; C7110.2 211.11,151.02 v4(211.2,151.12) ; CN4125.63 167.4,132.59 167.42,132.57 ; C6169.2 234.16,148.5 v4(233.51,148.5) ; v2(39.4,76.44) 38.98,76.86 C3058.2 ; U4555.AG23 187.13,88.14 v2(187.17,88.14) 187.46,88.43 U4555.AH24 ; v2(220.39,132.6) 220.72,132.6 221,132.87 CN4100.133 ; CN820.6 297.94,59.07 297.24,59.78 296.4,59.78 296.04,60.13 v2(296.04,60.61) ; C3088.2 91.17,92.92 v2(92.57,92.92) 91.52,93.97 C3070.1 ; CN4100.144 v2(217.7,140.82) ; v2(148.14,101.46) 147.86,101.46 146.99,100.58 Q4831.2 ; C2562.2 274.94,57.94 v2(274.61,58.28) ; U4555.AJ50 203.71,88.86 ; U4555.AJ50 203.39,89.5 U4555.AH49 203.06,89.18 202.65,88.77 v4(202.61,88.77) 202.41,88.96 202.41,89.5 ; U4555.AJ50 204.04,89.5 U4555.AH51 204.82,88.72 ; v2(185.9,89.72) 185.9,89.48 186.14,89.24 U4555.AH22 ; v2(110.55,94.5) 110.55,95.13 111.06,95.65 C5009.2 ; U4555.U22 186.55,83.75 U4555.V23 186.83,83.75 v2(187.23,83.35) ; C7473.1 119.37,99 118.99,98.62 C7472.1 118.06,98.62 v2(118.02,98.66) ; v5(148.88,156.83) 149.77,157.72 R6201.2 ; v2(233.39,74.66) 232.82,75.23 R6650.2 R6653.2 ; R810.2 291.68,76.65 292.89,77.86 v2(292.89,79.56) ; v2(138.63,136.64) 138.46,136.64 138,136.18 CN4125.153 ; v4(110.18,106.4) 110,106.23 110,104.12 110.37,103.75 110.37,103.75 CN3000.G2 ; 316.58,110.65 316.59,110.66 ; 316.59,110.66 v2(316.59,110.66) ; 316.59,110.66 316.59,110.42 315.42,109.25 314.35,109.25 ; CN4100.184 205.7,144 205.41,144.28 v2(205.26,144.28) ; C7615.2 237.9,159.07 v5(237.9,158.23) ; C2514.2 41.48,77.84 v2(41.18,77.53) ; U4555.AE10 179.01,87.65 179.25,87.41 v2(179.43,87.41) ; v2(185.07,69.05) 185.07,69.38 185.61,69.92 C4724.2 ; R5417.2 268.34,81.9 v2(268.38,81.9) ; U4555.AR11 179.76,93.59 179.8,93.59 v2(180.21,93.18) 180.94,93.91 U4555.AT13 ; 235.49,82.89 235.49,82.28 234.73,81.52 C6642.2 ; v2(184.32,85.38) 184.37,85.38 184.72,85.72 184.72,85.78 184.71,85.78 U4555.AB20 ; v2(126.02,144.38) 126.02,144.51 125.83,144.69 125.83,144.7 125.75,144.78 U3500.4 ; 204.82,88.72 v4(204.82,88.66) ; 204.82,88.72 204.82,88.82 205.01,89.01 205.01,89.5 U4555.AJ52 205.01,90.05 U4555.AK52 ; v2(180.42,80.65) 180.9,80.18 U4555.L13 ; v2(249.59,145.53) 249.25,145.86 C7599.2 ; R5308.2 284.89,65.85 284.61,65.57 v2(284.36,65.57) 284,65.92 R5306.2 ; CN4100.150 215.9,140.71 216.26,140.35 216.27,140.35 v2(216.44,140.18) ; U4555.D54 U4555.F54 206.37,77.59 v2(206.37,77.6) ; v2(220.1,141.08) CN4100.136 ; U2551.4 262.03,62.77 v2(261.93,62.67) ; 183.76,80.03 183.84,80.03 v2(184.22,80.41) 184.4,80.41 184.71,80.09 U4555.L20 ; 183.76,80.03 183.76,80.03 183.53,80.26 v2(183.53,80.54) 182.83,80.54 v2(182.8,80.56) 182.8,80.03 U4555.L17 ; 183.76,80.03 U4555.L18 ; C7500.1 155.8,63.42 v2(156.62,62.6) 156.62,64.49 D7504.1 ; 275.72,63.28 276.02,63.58 U2403.3 ; R5425.1 270.67,81.01 v2(269.78,81.9) ; v2(180.49,132.71) 180.6,132.83 CN4125.19 ; U4555.D50 U4555.F50 203.86,77.59 v2(203.86,77.6) ; R6149.1 207.42,157.89 v4(207.42,156.7) ; C3066.2 92.3,92.15 v2(92.6,91.85) ; CN4100.167 210.8,132.89 210.51,132.6 v2(210.33,132.6) ; CN1400.G1 248.83,76.35 249.12,76.06 249.12,74.52 v2(248.98,74.37) ; U3051.1 39.57,68.57 v2(40.16,68.57) ; v2(257.08,144.26) 257.3,144.04 CN4100.20 ; CN4125.G1 190.09,126.5 v2(190.49,126.9) ; CN4125.66 166.5,143.95 v2(166.22,144.23) ; v2(203.15,136.89) 203.06,136.89 202.4,136.24 CN4100.195 ; CN4100.178 v2(207.5,141.21) ; CN4100.65 243.8,132.46 v2(243.79,132.45) ; CN4125.136 143.1,141.52 142.82,141.24 v2(142.82,141.2) 142.82,141.2 142.5,141.52 CN4125.138 ; v2(249.55,136.62) 249.54,136.62 249.48,136.56 248.6,135.68 CN4100.49 ; v2(137.32,101.76) C7471.1 ; Q7152.2 121.33,93.54 v2(121.52,93.36) ; v4(232.89,146.67) 233.24,146.32 C6120.2 ; U4555.D30 U4555.F30 191.33,77.02 v2(191.33,77.6) ; U3500.18 121.2,151.62 121.2,149.83 v2(121.44,149.59) ; C4767.1 v2(165.64,103.49) ; U4555.D42 U4555.F42 198.84,77.01 v2(198.84,77.71) ; CN4125.11 183,132.79 182.94,132.79 v2(182.66,132.51) 182.4,132.77 CN4125.13 ; R5426.1 271.56,78.43 v2(271.86,78.73) 271.88,78.71 C5412.2 R5422.2 ; v2(132.77,132.64) 133.4,132.64 133.8,133.04 CN4125.167 ; R5320.2 288.03,81.18 287.52,81.68 v2(287.43,81.68) ; v4(108.49,129.14) 108.74,128.89 110.21,128.89 CN3000.G1 ; U4555.G5 176.14,77.8 176.44,77.5 v2(176.58,77.5) ; v2(146.08,92.31) 145.19,92.31 143.98,93.52 U4700.3 ; v2(146.47,97.9) C4768.2 ; 222.8,132.57 CN4100.127 222.8,136.91 222.42,137.29 v2(222.11,137.29) ; CN375.24 135.18,66.3 134.91,66.03 134.91,65.4 v2(134.4,64.89) ; CN640.G2 v2(247,159.93) ; CN4125.162 v2(135.3,141.2) ; CN4100.38 v2(251.9,144.26) ; C6216.1 v2(154.08,155.31) ; v2(107.47,159.88) 107.52,159.93 CN4300.G1 ; v2(278.9,64.12) 278.87,64.09 278.39,64.09 U2402.3 ; C2553.2 274.12,53.58 v2(273.82,53.88) ; v4(129.36,132.67) 129.36,132.68 128.56,132.68 128.4,132.84 CN4125.185 ; v2(212.27,132.65) 212.6,132.98 CN4100.161 ; C7619.2 v2(214.41,155.81) ; v2(137.11,141.12) 137.1,141.12 CN4125.156 ; U4555.AH55 207.29,89.5 U4555.AJ56 207.94,89.5 U4555.AH57 208.26,89.18 208.27,89.18 208.59,89.5 U4555.AJ58 209.48,89.5 v2(209.64,89.33) 209.73,89.24 209.73,88.64 U4555.AG60 U4555.AG61 ; U4555.AH55 206.96,88.53 v4(206.96,88.53) ; v4(208.06,156.7) 208.06,157.25 C7602.2 ; C7595.2 v2(144.01,160.56) ; v2(254.85,136.69) 254.83,136.69 254,135.87 CN4100.31 ; C5413.2 264.7,81.43 v2(264.99,81.71) 264.26,81.71 263.81,81.27 R5415.2 ; R4541.1 219.34,91.92 v2(217.96,90.54) ; CN3000.G4 108.8,110.3 108.8,108.39 v2(110.09,107.1) ; R345.2 C316.2 C320.2 227.57,57.09 224.2,53.72 v2(224.2,53.46) 223.32,52.58 U366.4 ; v2(189.42,69.04) 189.49,69.04 190.03,68.49 C4828.2 ; 166.8,132.46 CN4125.65 166.8,136.75 167.31,137.27 v2(167.93,137.27) ; 246.54,55.87 246.46,55.95 C7588.2 ; v2(149.01,72.73) 148.8,72.95 148.8,76.44 CN365.4 ; C3087.2 87.66,83.42 v2(87.76,83.32) ; v2(245.01,141.14) 245.3,141.43 CN4100.60 ; C366.2 v2(144.18,63.99) ; v2(148.23,103.81) 148.16,103.87 C4710.2 ; 157.36,77.56 157.36,77.96 157.97,78.58 R4578.1 ; 157.36,77.56 v4(157.31,77.51) ; v2(270.72,68.18) 270.72,68.68 C5411.2 ; 180.41,88.17 U4555.AF12 ; 180.41,88.17 180.41,88.27 180,88.68 U4555.AG11 ; 180.41,88.17 180.41,88.03 v2(179.99,87.62) ; CN4125.127 145.8,132.98 145.37,132.56 v2(144.5,132.56) 144.4,132.56 144,132.95 CN4125.133 ; v2(250.8,140.08) 250.68,140.08 250.1,140.66 CN4100.44 ; v2(265.42,65.67) 265.42,65.69 265.44,65.66 265.89,66.11 C5410.2 ; v4(201.58,151.15) 202.05,151.61 C6109.2 ; v2(220.7,144.32) CN4100.134 ; CN4100.162 212.3,141.26 v2(212.12,141.08) ; D7603.1 250.05,145.95 250.48,145.53 v2(250.6,145.53) ; CN4125.151 138.6,132.92 v2(138.27,132.59) 137.69,132.59 137.4,132.88 CN4125.155 ; v2(127.41,92.49) 127.17,92.25 Q7154.2 ; v2(273.59,60.69) 272.57,61.71 R2573.1 ; CN4100.G2 201.4,126.5 v2(201.4,126.5) 201.4,127.19 v2(201.45,127.24) 201.45,128 v2(201.48,128.02) ; v2(143.69,141.24) 143.7,141.25 CN4125.134 ; v2(258.59,137.01) 258.56,137.01 257.6,136.06 CN4100.19 ; CN4125.195 125.4,132.6 v2(125.43,132.57) ; v5(139.73,82.41) 139.22,81.9 C2990.2 ; v2(270.16,132.74) C7600.2 ; v2(208.37,85.22) 208.37,85.22 U4555.AA58 ; v2(259.8,69.3) 260.08,69.58 C5409.2 ; v2(178.15,144.39) 178.15,144.29 178.5,143.94 CN4125.26 ; U3500.11 121.2,146.42 120.82,146.8 v2(120.3,146.8) ; CN4125.32 176.7,143.94 176.23,144.41 v2(176.05,144.41) ; C6646.1 R6658.1 228.08,75.12 v2(227.24,74.28) 227.24,74.95 R6660.1 ; 202.41,89.5 202.09,89.5 201.76,89.18 ; 202.41,89.5 U4555.AJ47 ; Q7150.1 122.83,90.04 124.13,88.74 Q7150.4 124.13,87.55 v2(124.11,87.56) ; U4555.AH42 199.49,89.5 U4555.AJ43 199.81,89.02 v2(199.98,88.86) 200.14,88.86 200.46,89.17 ; U4555.AH42 198.84,89.5 U4555.AJ41 198.51,88.87 v2(198.43,88.79) 198.25,88.79 U4555.AH40 197.57,88.88 v2(197.21,88.88) 197.21,89.5 U4555.AJ39 ; U4555.AH42 199.16,88.63 v2(199.16,88.63) ; v5(169.2,151.88) 169.11,151.8 C7470.1 ; v2(139.22,102.98) 139.31,103.07 C7152.2 ; CN4125.170 132.9,141.33 133.09,141.14 v2(133.17,141.14) 133.31,141.14 133.5,141.33 CN4125.168 ; Q7352.2 103.9,87.07 v2(103.54,86.7) ; v2(165.64,87.87) 165.64,88.05 165.18,88.51 R4824.2 ; U4555.AF14 v2(181.22,86.73) ; 257.76,75.87 C1414.2 C1413.2 ; C2558.2 274.86,58.79 ; v2(177.53,76.16) 177.69,75.99 U4555.D8 ; CN4125.150 138.9,141.27 v2(138.84,141.21) ; R5304.2 282.86,65.72 282.67,65.53 v2(282.44,65.53) 282.44,65.58 281.97,66.05 R5302.2 ; CN375.G1 137.95,78.57 137.95,73.39 v2(137.98,73.39) ; C7495.1 239.55,77.6 v2(239.41,77.46) 239.28,77.33 238.67,77.33 238.28,77.71 C7642.2 ; v2(194.05,88.61) 193.96,88.7 U4555.AH34 ; C3090.2 91.99,89.51 v2(92.32,89.18) 92.32,88.98 91.94,88.6 C3091.2 ; C6217.1 v2(153.19,155.31) ; C5313.2 280.25,80.93 279.81,80.49 v2(279.81,80.38) 279.39,80.8 R5315.2 ; v2(175.84,132.78) 175.34,132.78 175.2,132.92 CN4125.37 ; C2200.2 282.94,54.04 C2201.2 283.02,53.82 283.67,53.17 284.16,53.17 v2(284.51,52.82) ; v2(282.05,51.93) 282.05,52.66 Q501.2 ; CN4125.38 174.9,144.14 v2(174.66,144.38) ; CN3000.G3 107.38,121.7 107.38,121.7 v2(106.7,122.38) ; CN4300.2 v2(111.03,154.87) ; v2(208.04,80.02) 208.04,80.01 U4555.L58 ; R6654.2 230.66,73.24 v4(230.54,73.12) 230.3,73.12 229.78,73.65 C6645.2 ; U4555.V58 v2(208.37,83.92) ; v2(260.36,136.71) 260.28,136.71 259.4,135.83 CN4100.13 ; CN4100.168 v2(210.5,141.21) ; Q7051.4 119.55,88.23 118.88,88.91 v2(118.27,88.91) 118.25,88.93 Q7051.1 ; 305.47,103.24 v2(305.72,103.24) 307.04,103.24 307.42,102.86 R1952.2 ; D7602.1 187.15,161.02 v5(187.15,161.02) ; Q4700.2 165.26,67 v2(165.26,66.03) 164.41,66.87 C4943.2 ; v2(95.41,88) 95.39,88.01 C3092.2 ; D4203.2 v2(143.03,147.58) ; C7622.2 v2(211.28,64.29) ; C3068.2 v2(94.99,86.87) ; C6121.2 203.87,149.9 v4(203.87,148.32) ; U4555.AF18 183.66,88.17 184.01,87.81 v4(184.01,87.56) ; v2(188.02,68.91) 187.58,68.47 C4826.2 ; v5(171.1,157.46) C6240.2 ; U4555.D46 U4555.F46 201.35,77.59 v2(201.36,77.6) ; v2(321.32,41.64) 321.48,41.47 U2401.1 ; U4555.F20 184.93,77.38 v2(185.6,77.38) 185.87,77.38 U4555.G22 ; v2(164.84,132.71) 165,132.87 CN4125.71 ; C2413.2 324.23,37.53 C2414.2 ; v2(285.36,80.04) 285.86,79.53 C5312.2 ; v2(204.47,132.04) 205.04,132.04 205.4,132.4 CN4100.185 ; CN4100.187 204.8,133.03 v2(204.44,132.68) 204.2,132.92 CN4100.189 ; 200.46,89.17 200.79,89.5 U4555.AJ45 201.11,89.5 201.11,88.91 v2(201.32,88.69) 201.32,88.74 201.76,89.18 ; 200.46,89.17 U4555.AH44 ; U4555.AJ25 188.11,88.86 v2(188.61,88.35) ; v2(168.03,141.07) 168.3,141.34 CN4125.60 ; U4555.W20 184.71,84.16 184.71,84.14 v2(184.32,83.75) 184.32,83.74 184.71,83.34 U4555.U20 ; v2(93.96,92.42) 93.69,92.15 C3065.2 ; CN4100.14 v2(259.1,144.27) ; C6243.2 175.02,154.82 v4(174.02,154.82) ; 242,132.48 CN4100.71 242,136.25 242.55,136.8 242.71,136.8 v2(242.71,136.8) ; 205.64,89.2 U4555.AH53 ; U4555.AH53 205.66,88.76 v4(205.52,88.62) ; C4209.2 v2(143.92,147.58) ; CN4100.145 217.4,132.85 217.14,132.6 v2(216.71,132.6) ; CN4125.72 164.7,142.73 v2(164.12,142.73) ; v2(249.92,57.52) 249.92,56.56 249,55.65 CN1400.G2 ; v2(249.52,139.8) 249.47,139.8 248.9,140.37 CN4100.48 ; C2503.2 40.46,53.11 v2(40.37,53.02) ; CN4100.46 v2(249.5,140.65) ; v5(161.07,149.59) 161.49,150.02 162.21,150.02 ; v2(128.43,144.26) 128.7,143.99 CN4125.184 ; 195.95,67.36 C7465.1 ; v2(218.58,136.77) 218.62,136.77 219.17,136.22 219.17,136.18 219.2,136.15 CN4100.139 ; v2(224.06,80.57) 223.88,80.39 C6614.2 ; C2557.2 v2(274.73,59.68) ; CN4125.49 171.6,135.86 172.57,136.84 v2(172.62,136.84) ; v2(165.64,100.7) 165.1,100.7 C4788.1 ; CN4125.14 v2(182.1,141.16) ; R2576.2 v2(273.59,61.83) ; v2(296.09,62.8) 296.09,62.78 C810.2 ; R3303.2 316.9,27.67 v2(316.77,27.8) 316.77,28.18 317.15,28.56 R3304.2 ; U4555.H57 208.4,78.18 v2(208.01,78.18) ; v5(148.88,159.5) 150.03,159.5 C6210.2 ; U4555.AF17 182.85,87.63 v2(182.8,87.59) 182.62,87.59 182.03,88.17 U4555.AF15 ; v2(183.73,132.56) 183.6,132.69 CN4125.9 ; 83.02,88.84 C3061.2 ; v2(257.33,62.52) 256.83,62.01 C2590.2 ; v2(208.33,82.73) 208.45,82.61 U4555.T58 ; U4555.AH32 192.66,88.74 v2(192.57,88.65) ; R2200.2 282.82,57.09 v2(283.37,57.64) ; v2(111.28,122.92) 111.28,122.16 111.69,121.75 ; D7505.1 156.35,67.93 v2(156.8,67.93) 156.8,66.89 156.32,66.41 C7501.1 ; C7579.2 294.32,57.41 v2(294.32,57.6) ; C321.2 v2(145.07,63.99) ; 162.91,72.22 Q4942.4 ; 162.91,72.22 163.76,72.22 164.21,71.78 Q4942.1 ; C5310.2 280.85,65.52 280.88,65.49 v2(280.91,65.49) ; C6159.2 v4(219.34,149.01) ; v5(173.06,149.59) 173.01,149.59 172.93,149.51 C6241.2 ; C7597.2 219.62,144.64 v2(219.87,144.38) 219.5,144.01 CN4100.138 ; CN4125.31 177,135.89 177.6,136.49 177.65,136.49 v2(177.69,136.53) ; C3062.2 84.81,88.84 ; v2(124.39,94.19) 124.11,94.19 124,94.3 C6316.1 C6317.1 ; CN4125.144 v2(140.7,144.49) ; CN4100.25 255.8,133.01 v2(256.24,132.56) ; U5000.5 116.27,93.65 116.37,93.75 v2(116.37,94.44) ; v2(146.08,104) 145.87,103.79 C4764.2 ; CN4125.187 127.8,135.89 v2(127.64,136.05) 127.4,136.05 127.2,135.85 CN4125.189 ; v2(136,132.56) 135.6,132.96 CN4125.161 ; C6158.2 222.41,152.28 v4(222.17,152.51) ; CN4100.155 214.4,132.86 v2(214.66,132.6) 215,132.94 CN4100.153 ; C7487.1 168.18,149.72 v5(168.05,149.59) ; CN4100.8 260.9,143.99 260.64,144.26 v2(259.87,144.26) ; v2(142.86,151.62) D7604.1 ; C7475.1 156.62,85.5 v4(157.26,84.87) ; v2(185.61,86.61) 185.22,86.99 185.22,87 U4555.AD21 ; CN4125.28 177.9,140.65 178.28,140.28 v2(178.5,140.28) ; R2591.2 259.29,53.06 259.29,54.75 v2(259.82,55.28) ; C4138.2 v2(145.7,147.56) ; U4555.AH38 v2(196.56,88.64) ; v2(217.27,90.86) 218.43,92.02 R4518.1 ; C6152.2 228.03,150.52 D7619.1 ; U4555.AH36 195.26,89.05 v2(194.8,88.59) 194.61,88.78 U4555.AJ35 ; C5314.2 276.94,77.46 v2(276.33,76.85) ; v2(161.2,86.35) 161.2,86.55 161.54,86.89 162.43,86.89 R4919.2 ; C7620.2 v2(154.8,149.72) ; v5(158.4,67.9) 158.4,68.06 157.13,69.33 D7506.1 ; v2(295.23,58.96) 295.82,58.96 C503.2 ; U4555.J22 186.14,79.28 v2(185.75,79.68) ; CN4125.173 132,135.98 132.55,136.53 133,136.53 v2(133,136.53) ; v2(195.02,75.36) 195.3,75.36 195.77,75.83 U4555.D37 ; v2(161.87,94.45) 162.03,94.29 R4724.1 ; v2(208.37,87.82) 208.37,87.82 U4555.AE58 ; CN4100.9 260.6,135.73 v2(260.36,135.96) 260,135.6 CN4100.11 ; R3302.2 317.16,25 v5(316.52,25.65) ; v2(262.54,132.57) 262.4,132.71 CN4100.3 ; CN4100.128 222.5,140.86 v2(221.99,140.36) ; R5312.1 277.27,68.79 v2(277.63,69.15) ; v2(204.45,140.52) 203.9,141.07 CN4100.190 ; C7490.1 v2(213.52,155.81) ; C5414.2 262.24,74.48 263,73.72 v2(263.3,73.72) ; 201.76,89.18 U4555.AH46 ; U4555.P22 185.6,81.72 v2(185.6,81.72) 185.6,81.69 185.22,81.31 U4555.N21 ; CN4125.128 145.5,141.06 v2(145.74,140.82) ; v2(209.3,141.21) CN4100.172 ; U4555.B4 175.94,74.54 v2(175.98,74.5) ; CN4125.43 173.4,132.99 173.67,132.71 v2(174.1,132.71) ; C7618.2 v2(130.21,154.42) ; CN4100.G1 263.9,129.23 v2(264.07,129.4) ; 237.86,70.02 C7643.2 ; v2(188.82,77.6) 188.81,77.59 U4555.F26 U4555.D26 ; C7469.1 v2(161.32,158.86) ; v2(214.03,141.21) 214.1,141.28 CN4100.156 ; R4576.1 161.83,78.34 161.32,78.85 v2(161.32,79.11) ; R2572.1 257.08,67.14 256.7,66.76 256.7,63.99 v2(257.66,63.03) ; U4555.AH28 190.42,88.81 v4(190.85,88.81) ; v2(140.46,132.7) 140.4,132.76 CN4125.145 ; v2(245.66,137.72) 245.25,137.72 244.4,136.87 CN4100.63 244.4,132.6 ; C7650.2 275.79,115.77 ; 205.68,92.46 v2(205.68,91.7) ; v2(125.38,144.33) 125.38,144.32 125.19,144.13 125.19,144.11 125.1,144.01 CN4125.196 ; C7630.2 v5(133.68,102.73) ; v2(255.68,144.26) 255.5,144.07 CN4100.26 ; CN4125.48 171.9,144.09 171.61,144.38 v2(171.61,144.46) ; C3094.2 80.04,84.74 v2(80.95,83.83) ; v2(178.66,132.67) 178.8,132.81 CN4125.25 ; R4713.2 142.57,87.91 v2(142.4,87.74) ; C7610.2 v4(196.84,160.77) ; v2(134.91,101.76) C7474.1 ; v2(251.49,149.85) 250.73,149.08 C7491.1 ; C3077.1 83.13,91.87 82.84,91.58 v2(82.07,91.58) ; 176.01,151.07 C6242.2 v4(176.01,149.59) ; CN4125.61 168,132.88 168.21,132.67 v2(168.6,132.67) ; C3357.2 v2(38.64,64.63) ; 234.58,65.77 234.22,65.41 v5(234.15,65.41) 234.15,64.27 C6616.2 ; CN4100.170 v2(209.9,141.21) ; U4555.C38 U4555.D38 U4555.F38 196.33,77.01 v2(196.33,77.68) ; R6209.1 149.64,156.62 v2(149.64,155.56) ; v2(202.85,144.26) 202.34,144.26 202.1,144.01 CN4100.196 ; C2513.2 47.53,81.52 v2(47.91,81.14) 47.91,80.76 47.66,80.5 R2514.1 ; CN4100.151 215.6,136.32 215.23,136.68 v2(214.79,136.68) ; C2408.2 317.19,37.42 C2411.2 ; v2(241.08,141.46) 241.28,141.46 241.7,141.89 CN4100.72 ; CN4100.61 245,132.74 ; CN4100.55 246.8,136.7 v2(247.49,137.39) ; C7503.2 147.23,66.03 v2(146.21,67.04) ; CN4100.43 250.4,132.86 250.69,132.57 v2(251.91,132.57) 252.2,132.86 CN4100.37 ; 195.55,68.69 C7466.1 ; R5420.2 v2(271.87,72.58) ; v2(193.83,77.6) 193.83,77.59 U4555.F34 U4555.D34 ; CN4100.173 209,132.69 v2(208.91,132.6) 207.46,132.6 207.2,132.86 CN4100.179 ; v2(170.1,144.28) CN4125.54 ; C6641.2 230.28,87.95 v2(230.08,88.15) 229.82,87.88 228.77,87.88 228.38,87.49 C6643.2 ; v2(185.71,144.38) 185.7,144.38 CN4125.2 ; C3502.2 v2(125.64,155.81) ; v4(157.27,90.26) 157.26,90.26 157.64,90.64 C4712.1 ; CN4100.28 v2(254.9,144.26) ; CN4125.172 v2(132.3,141.2) ; CN4125.3 185.4,132.65 ; CN4125.178 v2(130.5,144.8) ; R4758.2 166.83,69.17 166.83,68.41 v2(166.78,68.36) 166.99,68.36 167.55,67.8 167.55,67.17 167.93,66.79 R4759.2 ; C4766.2 v2(148.14,102.09) ; C6613.2 v2(223.3,77.2) ; CN820.12 297.48,51.81 297.47,51.81 297.09,51.42 287.94,51.42 287.94,51.44 v4(287.93,51.44) ; C4709.2 148.09,102.98 v2(148.17,102.89) ; CN4125.179 130.2,132.57 ; CN4125.139 v2(142.2,132.65) ; R6647.2 235.49,75.22 234.93,74.66 v2(234.75,74.66) ; CN4125.20 v2(180.3,141.02) ; Q4300.4 v2(117.38,155.04) ; C4137.2 v2(144.81,147.58) ; R3076.1 89.44,86.17 v2(89.44,85.84) ; CN4100.32 253.7,144.08 v2(253.52,144.26) ; D7601.1 v2(110.9,162.04) ; C7606.2 163.23,150.48 ; CN4125.190 v2(126.9,144.33)
  BOTTOM w0.457: v2(192.16,104.08) 192.99,104.08 193.93,103.14 C4516.2 ; v2(195.52,100.84) 195.52,102.98 C4515.2
  BOTTOM w0.508: C4990.2 200.18,104.92 v2(200.51,105.24) ; C4790.2 170.6,62.71 170.97,62.34 172.37,62.34 v4(172.63,62.6) 172.58,62.6 C4792.2 ; C4785.2 164.13,63.37 163.3,62.54 v2(163.12,62.54) ; C4528.2 201.33,104.87 v2(201.7,105.24) 202.24,105.24 202.85,104.63 C4527.2 ; 119.38,126.5 CN4125.G2 ; CN4125.G2 121.8,124.03 ; CN4125.G2 124.22,126.5 ; CN4125.G2 121.8,128.97 ; C4786.2 165.25,63.11 165.77,62.6 v2(166.28,62.6)
  BOTTOM w0.635: v2(216.69,155.98) D7610.1 ; D7608.1 v2(213.39,158.86) ; v2(121.7,153.91) 122.24,154.45 D7609.1 ; C4755.2 v5(158.4,67.9) ; D7606.1 v2(143.42,157.08)
  vias: v1(41.31,82.03) v1(202.72,80.38) v1(229.9,63.23) v2(41.31,54.72) v2(41.89,81.48) v2(41.92,80.67) v2(42.5,81.06) v2(42.58,55.92) v2(43.06,81.46) v2(43.07,80.67) v2(43.85,75.8) v2(43.85,73.01) v2(43.85,68.95) v2(43.85,65.14) v2(44.86,77.71) v2(45.63,81.9) v2(49.66,80.73) v2(50.91,81.57) v2(66.88,88.73) v2(69.42,88.73) v2(71.9,88.81) v2(83.34,88.25) v2(83.34,86.73) v2(83.34,85.2) v2(84.87,88.25) v2(84.88,86.66) v2(84.87,85.2) v2(85.58,80.97) v2(86.39,88.25) v2(86.39,86.6) v2(86.39,85.2) v2(93,97.27) v2(96.43,88.66) v2(97.19,92.09) v2(99.56,95.1) v2(99.55,93.2) v2(99.85,146.29) v2(99.85,144.51) v2(100.49,133.84) v2(100.87,146.29) v2(100.87,144.51) v2(100.92,91.98) v2(101.38,158.99) v2(102.14,162.42) v2(102.19,93.25) v2(107.83,92.36) v2(110.14,149.21) v2(110.17,98.97) v2(110.17,96.84) v2(110.52,112) v2(110.52,110.22) v2(114.59,83.55) v2(117.89,121.18) v2(118.17,123.78) v2(121.75,123.84) v2(121.77,82.54) v2(121.83,123.05) v2(122.05,104.99) v2(124.11,104.89) v2(125.7,140.37) v2(125.68,138.15) v2(125.66,136.71) v2(126.52,101.71) v2(126.52,101.08) v2(127.64,136.81) v2(127.82,137.96) v2(127.93,140.24) v2(128.04,78.05) v2(129.14,76.24) v2(129.29,138.59) v2(129.27,136.98) v2(129.31,140.12) v2(130.95,138.79) v2(130.97,137.12) v2(131.09,140.49) v2(132.97,138.61) v2(134,138.31) v2(134.18,140.28) v2(134.3,136.89) v2(136.15,137.98) v2(136.15,136.56) v2(136.23,139.45) v2(136.56,63.49) v2(137.93,90.92) v2(138.42,138.58) v2(139.19,90.92) v2(139.57,139.95) v2(139.85,90.92) v2(140.9,140.37) v2(140.85,138.24) v2(140.87,136.75) v2(142.91,139) v2(142.94,136.67) v2(144.26,140.03) v2(144.3,138.54) v2(144.34,136.79) v2(145.5,82.91) v2(145.98,137.23) v2(147.21,140.33) v2(147.22,137.42) v2(149.53,140.13) v2(149.72,138.59) v2(149.71,137.75) v2(152.08,140.4) v2(153.18,139.07) v2(153.18,138.25) v2(154.21,137.57) v2(155.25,140.24) v2(155.32,138.82) v2(156.74,138.32) v2(156.93,140.29) v2(160.35,138.7) v2(160.32,137.23) v2(160.43,140.3) v2(161.1,140.47) v2(161.56,138.3) v2(162.08,108.57) v2(163.43,110.53) v2(165.75,137.31) v2(165.9,140.5) v2(167.83,75.26) v2(167.92,138.66) v2(169.24,140.15) v2(170.21,75.3) v2(171.08,140.43) v2(171.15,139.01) v2(171.17,137.59) v2(172.67,139.12) v2(172.88,65.11) v2(173.79,71.61) v2(174.47,138.84) v2(174.55,137.24) v2(176.31,140.19) v2(176.31,137.27) v2(177.75,138.89) v2(179.74,69.78) v2(180.18,137.31) v2(180.21,138.82) v2(181.13,59.93) v2(182.06,139.06) v2(182.24,137.63) v2(182.28,56.37) v2(182.76,72.4) v2(183.17,103.57) v2(183.86,101.25) v2(183.8,99.45) v2(184.36,59.62) v2(184.44,56.37) v2(184.74,140.35) v2(184.75,138.88) v2(184.8,137.48) v2(185.19,101.15) v2(185.19,100.57) v2(185.5,102.96) v2(185.76,101.74) v2(185.76,99.98) v2(185.96,56.37) v2(187.2,101.33) v2(188.14,61.48) v2(189.07,103.11) v2(189.22,101.29) v2(189.22,99.39) v2(189.36,71.54) v2(190.38,71.5) v2(190.66,104.07) v2(190.66,102.7) v2(190.66,100.74) v2(190.66,98.99) v2(191.32,71.54) v2(192.16,102.92) v2(192.16,101.01) v2(192.16,99.69) v2(193.33,136.26) v2(193.33,54.6) v2(193.95,99.7) v2(193.93,98.4) v2(195.38,98.94) v2(195.4,97.8) v2(196.45,70.93) v2(197.15,99.04) v2(198.65,97.85) v2(198.7,99.14) v2(199.9,98.55) v2(200.44,69.56) v2(201.09,99.2) v2(201.11,98.03) v2(202.47,69.56) v2(202.82,98.52) v2(203.16,140.27) v2(204.44,138.39) v2(205.14,71.82) v2(205.58,98.7) v2(205.74,100.81) v2(206.36,140.18) v2(206.44,138.51) v2(206.46,136.99) v2(206.69,69.43) v2(206.91,102.3) v2(207.04,98.96) v2(207.47,100.7) v2(207.77,103.15) v2(208.26,140.15) v2(208.26,138.29) v2(208.21,136.86) v2(208.57,100.17) v2(209.25,69.73) v2(210.03,139.28) v2(210.09,136.86) v2(211.36,69.1) v2(211.9,138.04) v2(212.02,136.64) v2(212.81,140.44) v2(213.35,94.93) v2(214.03,61.5) v2(214.39,92.17) v2(214.85,140.25) v2(214.82,138.17) v2(215.63,90.08) v2(215.91,92.66) v2(216.19,61.48) v2(216.47,137.13) v2(216.52,138.62) v2(218.37,61.5) v2(218.62,138.24) v2(218.76,140.31) v2(220.41,139) v2(220.41,136.7) v2(222.07,138.84) v2(223.62,138.41) v2(224.9,140.41) v2(225.23,137.93) v2(225.28,136.53) v2(225.47,129.54) v2(225.54,83.09) v2(225.84,130.05) v2(226.29,140.43) v2(226.85,65.14) v2(228.03,139.96) v2(228.19,138.52) v2(228.16,136.98) v2(229.39,81.27) v2(229.39,79.23) v2(229.52,80.25) v2(229.66,140.91) v2(229.66,138.86) v2(230.03,79.11) v2(231,138.29) v2(230.97,136.05) v2(232.48,139.92) v2(232.57,99.93) v2(232.98,138.59) v2(234.05,140.31) v2(234.3,128.93) v2(234.7,129.38) v2(235.36,97.01) v2(235.54,140.67) v2(236.44,141.2) v2(236.48,69.17) v2(236.48,68.49) v2(236.48,67.85) v2(236.48,67.19) v2(236.46,66.51) v2(236.66,138.68) v2(237.14,70.47) v2(237.27,71.36) v2(237.24,69.17) v2(237.24,66.51) v2(237.52,72.12) v2(237.65,140.51) v2(237.62,139.12) v2(237.98,66.51) v2(238.03,69.78) v2(238,69.17) v2(238,68.49) v2(238,67.85) v2(238,67.19) v2(239.15,141.21) v2(239.33,138.8) v2(239.32,137.48) v2(242.65,138.13) v2(242.75,139.49) v2(243.79,131.79) v2(244.15,138.32) v2(244.23,68.97) v2(245.72,140.36) v2(245.7,139.04) v2(246.92,86.98) v2(246.92,85.96) v2(247.43,152) v2(247.58,138.72) v2(248.7,86.98) v2(248.7,85.96) v2(249.52,138.97) v2(250.83,138.71) v2(250.88,137.34) v2(252.39,140.06) v2(252.34,138.73) v2(252.35,137.38) v2(254.89,138.91) v2(255.3,81.65) v2(256.09,138.24) v2(256.09,136.84) v2(257.59,158.35) v2(258.45,138.71) v2(258.4,76.54) v2(260.13,80.38) v2(260.4,140.68) v2(260.45,138.36) v2(261.96,139.94) v2(261.98,138.58) v2(262.03,132.07) v2(262.16,160.77) v2(262.67,118.35) v2(263.05,129.4) v2(263.53,60.82) v2(264.07,123.81) v2(265.67,79.41) v2(265.97,83.17) v2(269.56,53.76) v2(270.54,74.79) v2(273.59,59.68) v2(273.59,58.28) v2(273.97,76.9) v2(274,74.13) v2(274.73,60.69) v2(275.62,74.48) v2(275.85,71.41) v2(276.13,104) v2(277.73,54.95) v2(278.29,56.86) v2(279.18,52.89) v2(282.4,82.56) v2(283.34,82.08) v2(284.18,82.84) v2(284.94,51.72) v2(286.21,81.8) v2(287.05,128.13) v2(287.05,127.37) v2(287.05,126.6) v2(287.26,72.88) v2(287.33,107.6) v2(287.81,128.13) v2(287.81,127.37) v2(287.81,126.6) v2(288.58,128.13) v2(288.58,127.37) v2(288.58,126.6) v2(288.64,74.05) v2(289.85,90.66) v2(289.85,89.77) v2(290.07,92.77) v2(291.14,117.87) v2(291.62,111.49) v2(291.62,110.35) v2(291.62,109.21) v2(292.64,70.85) v2(292.64,70.27) v2(292.77,111.49) v2(292.77,110.35) v2(292.77,109.21) v2(293.81,70.85) v2(293.81,70.27) v2(293.91,111.49) v2(293.91,110.35) v2(293.91,109.21) v2(297.06,66.1) v2(297.77,76.69) v2(297.77,67.47) v2(297.9,97.78) v2(297.87,95.79) v2(298.13,93.48) v2(298.3,110.02) v2(298.69,95.34) v2(298.81,97.45) v2(298.99,77.79) v2(299.27,90.82) v2(299.24,88.89) v2(300.18,82.49) v2(300.74,78.01) v2(305.39,122.5) v2(305.47,82.92) v2(305.47,82.15) v2(306.74,88.38) v2(307.37,88.38) v2(309.22,123.05) v2(310.95,94.27) v2(310.98,91.6) v2(311.01,89.37) v2(311.03,69.1) v2(311.68,125.72) v2(315.32,58.07) v2(315.42,140.07) v2(316.39,28.61) v2(316.54,36.69) v2(316.95,116.52) v2(316.91,30.56) v2(317.05,27.04) v2(317.53,118.4) v2(319.03,107.05) v2(324.9,154.67) v2(324.9,153.27) v2(325.91,156.2) v4(30.64,58.53) v4(30.64,55.32) v4(30.64,54.05) v4(30.64,52.78) v4(30.61,51.37) v4(33.53,64.07) v4(34.04,62.88) v4(36.36,51.38) v4(42.96,64.25) v4(42.96,61.89) v4(118.55,82.54) v4(130.46,64.37) v4(132.87,67.04) v4(174.67,153.92) v4(174.7,151.91) v4(175.69,153.89) v4(175.72,151.9) v4(237.52,53.58) v4(238.03,52.06) v4(266.1,72.2) v4(266.1,76.02) v4(266.1,75.02) v4(266.1,74.02) v4(266.1,73.02) v4(266.99,72.25) v4(267.1,76.02) v4(267.1,75.02) v4(267.1,74.02) v4(267.1,73.02) v4(269.75,152.89) v4(282.36,76.02) v4(282.36,75.02) v4(282.36,74.02) v4(282.36,73.02) v4(282.36,72.02) v4(283.36,76.02) v4(283.36,75.02) v4(283.36,74.02) v4(283.36,73.02) v4(283.36,72.02) v4(300.13,61.33) v4(300.13,60.06) v4(300.13,58.79) v4(301.4,61.33) v4(301.4,60.06) v4(301.4,58.79) v4(302.67,61.33) v4(302.67,60.06) v4(302.67,58.79) v4(316.42,140.49) v4(321.72,98.54) v4(322.41,135.95) v4(324.64,136.26) v4(325.99,135.16) v4(326.68,101.97) v4(326.68,100.06) v4(328.34,25.05) v4(328.58,19.29) v4(328.53,16.14) v4(329.09,131.43) v4(329.09,130.16) v4(329.09,128.89) v4(329.09,127.62) v4(329.09,126.48) v4(329.09,125.21) v4(329.09,123.94) v4(329.09,122.67) v4(329.09,120.64) v4(329.09,119.37) v4(329.09,118.1) v4(329.09,116.83) v4(329.09,115.3) v4(329.09,114.03) v4(329.09,112.76) v4(329.09,111.49) v4(329.09,109.21) v4(329.09,107.94) v4(329.09,106.67) v4(329.11,98.38) v5(36.74,82.28) v5(36.74,81.14) v5(36.74,80) v5(97.7,88.63) v5(103.41,133.84) v5(107.73,83.3) v5(126.91,100.44) v5(127.16,99.43) v5(127.16,98.41) v5(128.3,103.24) v5(128.33,102.22) v5(128.33,101.2) v5(129.19,102.73) v5(129.19,101.71) v5(135.54,64.43) v5(139.22,99.17) v5(139.22,97.14) v5(139.22,95.11) v5(139.86,98.16) v5(139.86,96.12) v5(158.78,161.02) v5(159.29,160.01) v5(160.05,161.02) v5(160.56,160.01) v5(161.2,161.02) v5(161.7,160.01) v5(162.34,161.02) v5(162.85,160.01) v5(163.61,161.02) v5(164.12,160.01) v5(164.75,161.02) v5(165.26,160.01) v5(169.2,156.07) v5(185.2,152.39) v5(186.47,152.39) v5(193.58,84.44) v5(193.58,81.9) v5(195.87,66.53) v5(195.87,65.39) v5(195.87,64.25) v5(195.87,63.1) v5(196.25,81.27) v5(197.39,84.44) v5(198.66,86.73) v5(198.66,81.27) v5(199.93,84.44) v5(200.69,66.53) v5(200.69,65.39) v5(200.69,64.25) v5(200.69,63.1) v5(201.2,81.27) v5(202.47,84.44) v5(203.74,86.73) v5(203.74,81.9) v5(205.01,84.44) v5(205.52,66.15) v5(205.52,65.14) v5(205.52,64.12) v5(205.52,63.1) v5(205.7,153.43) v5(205.73,152.42) v5(207.3,152.26) v5(208.69,152.26) v5(210.36,65.96) v5(210.32,64.94) v5(210.38,63.88) v5(211.23,65.24) v5(223.75,153.5) v5(224.53,156.49) v5(224.6,154.43) v5(224.62,155.49) v5(226.18,70.08) v5(227.87,65.26) v5(228.89,66.28) v5(228.89,65.26) v5(229.9,66.28) v5(229.9,65.26) v5(230.92,65.26) v5(235.36,72.12) v5(235.36,71.11) v5(235.36,70.09) v5(236.38,72.12) v5(236.38,71.11) v5(236.38,70.09) v5(236.89,147.18) v5(237.52,146.42) v5(241.33,145.2) v5(242.48,145.2) v5(243.62,145.2) v5(246.41,79.87) v5(270.29,140.57) v5(270.29,139.3) v5(270.29,138.03) v5(270.29,136.76) v5(276.38,118.22) v5(276.38,116.95) v5(278.04,122.29) v5(278.04,121.02) v5(293.91,123.46) v5(304.84,110.03) v5(316.39,75.68) v5(316.39,74.66) v5(318.68,37.96) v5(318.68,36.94) v5(324.9,36.56) v5(325.79,36.56)
