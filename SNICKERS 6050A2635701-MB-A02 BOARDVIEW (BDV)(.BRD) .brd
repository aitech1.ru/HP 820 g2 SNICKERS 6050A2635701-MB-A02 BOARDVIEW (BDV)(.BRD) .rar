# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LPC_RESET#: length 13.4
  TOP w0.102: U300.53 278.92,104.53 v2(278.93,104.53) ; R4868.1 277.27,94.09 278.16,94.98 v3(278.67,94.98)
  L3 w0.102: v3(278.67,94.98) 278.16,95.49 278.16,104 278.69,104.53 v2(278.93,104.53)
LVDS_VDD_EN: length 115.7
  TOP w0.102: U3000.3 105.37,111.98 105.49,112.11 R3003.1 v1(106.46,113.14) 108.26,114.95 113.72,114.95 v2(114.08,115.3) 114.57,115.8 114.57,116.3 114.23,116.65 113.39,116.65 111.99,118.04 111.21,118.04 109.63,119.62 109.63,121.22 R3013.1
  L5 w0.102: v2(173.32,71.27) 172.93,71.66 153.63,71.66 153.22,72.07 151.39,72.07 150.18,73.29 147.73,73.29 144.48,76.54 143.44,76.54 134.5,85.48 134.5,88.08 132.47,90.1 126.19,90.1 124.49,91.81 120.96,91.81 116.24,96.53 116.24,113.14 v2(114.08,115.3)
  BOTTOM w0.076: v2(173.32,71.27) 173.34,71.26 173.34,71.94 174.09,72.69 175.66,72.69 176.1,73.13 176.37,73.13 176.75,73.51 176.75,74.08 177.31,74.64 U4555.C6
M_A_A<0>: length 71.7
  L6 w0.076: 198.55,103.24 198.55,103.06 195.94,100.45 195.94,95.27 v2(195.53,94.86)
  L6 w0.165: v3(232.48,139.17) 232.48,136.91 232.27,136.7 232.27,134.74 231.48,133.94 231.48,131.31 226.79,126.63 215.27,126.63 210.83,122.18 209.42,122.18 198.55,111.31 198.55,103.24
  BOTTOM w0.076: U4555.AU36 195.09,94.57 195.38,94.86 v2(195.53,94.86)
  BOTTOM w0.178: v3(232.48,139.17) 231.5,140.15 CN4100.98
M_A_A<1>: length 72.3
  L6 w0.076: 198.02,102.98 198.02,102.8 195.77,100.55 195.77,98.74 v2(195.4,98.37)
  L6 w0.165: v3(231.73,136.19) 231.73,134.96 230.94,134.16 230.94,131.53 226.57,127.16 213.64,127.16 213.5,127.02 213.5,126.79 213.95,126.34 213.95,126.11 213.79,125.94 213.56,125.94 213.11,126.39 212.88,126.39 212.71,126.23 212.71,126 213.16,125.55 213.16,125.32 213,125.15 212.77,125.15 212.32,125.6 212.09,125.6 211.92,125.44 211.92,125.21 212.37,124.76 212.37,124.53 212.21,124.36 211.98,124.36 211.53,124.81 211.3,124.81 211.13,124.65 211.13,124.42 211.58,123.97 211.58,123.74 211.42,123.57 211.19,123.57 210.74,124.02 210.51,124.02 210.34,123.86 210.34,123.63 210.79,123.18 210.79,122.95 210.63,122.78 210.4,122.78 209.95,123.23 209.72,123.23 198.02,111.53 198.02,110.55 198.02,110.55 198.02,102.98
  BOTTOM w0.076: U4555.AY37 195.96,96.52 195.96,97.9 195.5,98.37 v2(195.4,98.37)
  BOTTOM w0.178: CN4100.97 231.8,136.13 v3(231.73,136.19)
M_A_A<2>: length 73.6
  L6 w0.076: 199.83,103.87 199.83,103.64 196.44,100.25 196.44,94.17 196.64,93.97 v2(196.64,93.6)
  L6 w0.165: v3(232.51,140.6) 233.13,139.98 233.13,139.35 233.91,138.57 233.91,132.42 233.5,132 233.5,131.07 227.46,125.03 216.98,125.03 212.54,120.58 210.08,120.58 200.3,110.8 200.3,106.44 199.83,105.98 199.83,103.87
  BOTTOM w0.076: v2(196.64,93.6) 196.37,93.6 U4555.AR38
  BOTTOM w0.178: CN4100.96 232.1,141.01 v3(232.51,140.6)
M_A_A<3>: length 73.4
  L6 w0.076: v3(195.64,92.68) 195.23,93.09 195.23,94 196.11,94.89 196.11,100.38 199.17,103.44 199.17,103.72
  L6 w0.165: 199.17,103.72 199.17,103.72 199.17,111.18 209.64,121.65 211.05,121.65 212.32,122.92 212.56,122.92 212.83,122.65 213.06,122.65 213.22,122.82 213.22,123.05 212.95,123.32 212.95,123.55 213.12,123.72 213.35,123.72 213.62,123.44 213.85,123.44 214.02,123.61 214.02,123.84 213.74,124.11 213.74,124.34 213.91,124.51 214.14,124.51 214.41,124.23 214.64,124.23 214.81,124.4 214.81,124.63 214.53,124.9 214.53,125.13 214.7,125.3 214.93,125.3 215.2,125.02 215.43,125.02 215.6,125.19 215.6,125.42 215.32,125.69 215.32,125.92 215.49,126.09 227.01,126.09 232.01,131.09 232.01,133.72 232.8,134.51 v2(232.8,136.09)
  BOTTOM w0.076: v3(195.64,92.68) 195.57,92.75 U4555.AP36
  BOTTOM w0.178: v2(232.8,136.09) 232.4,135.69 CN4100.95
M_A_A<4>: length 73.6
  L6 w0.076: 200.32,105.89 200.12,105.69 200.12,103.69 196.61,100.18 196.61,95.45 v2(197.13,94.93)
  L6 w0.165: v3(234.09,139.53) 234.44,139.18 234.44,132.2 234.03,131.78 234.03,130.85 227.68,124.49 217.2,124.49 212.76,120.05 210.3,120.05 200.83,110.58 200.83,108.64 200.83,106.41 200.32,105.89
  BOTTOM w0.076: U4555.AU39 196.66,94.57 196.77,94.57 v2(197.13,94.93)
  BOTTOM w0.178: CN4100.92 233.3,139.22 233.45,139.07 233.94,139.07 234.09,139.22 v3(234.09,139.53)
M_A_A<5>: length 73.8
  L6 w0.076: v2(195.62,93.34) 195.62,94.16 196.28,94.82 196.28,100.32 199.51,103.55 199.51,103.78
  L6 w0.165: v3(233.11,137.92) 233.38,137.65 233.38,133.85 233.21,133.68 232.72,133.68 232.56,133.52 232.56,133.29 232.72,133.12 233.21,133.12 233.36,132.97 233.36,132.64 233.21,132.49 232.8,132.49 232.54,132.23 232.54,130.87 227.23,125.56 216.76,125.56 212.32,121.11 209.86,121.11 199.77,111.02 199.77,106.37 199.51,106.11 199.51,103.78
  BOTTOM w0.076: U4555.AR36 195.56,93.4 v2(195.62,93.34)
  BOTTOM w0.178: CN4100.91 233.6,137.42 v3(233.11,137.92)
M_A_A<6>: length 73.8
  L6 w0.076: 200.57,104.12 200.34,103.9 200.34,103.62 196.77,100.05 196.77,98.71 v2(197.1,98.38)
  L6 w0.165: 200.57,104.12 200.96,104.51 200.96,106 201.36,106.41 201.36,106.45 201.37,106.45 201.37,110.36 210.52,119.51 212.98,119.51 217.42,123.96 227.9,123.96 234.98,131.04 234.98,141.64 234.78,141.84 234.32,141.84 234.12,141.64 v3(234.12,141.06)
  BOTTOM w0.076: U4555.AV40 197.54,95.22 197.83,95.51 197.83,97.66 197.11,98.38 v2(197.1,98.38)
  BOTTOM w0.178: v3(234.12,141.06) 233.9,141.28 CN4100.90
M_A_A<7>: length 73.5
  L6 w0.076: 202.97,106.54 202.97,106.39 202.6,106.02 202.6,105.17 197.74,100.31 197.74,96.8 v2(197.11,96.17)
  L6 w0.165: v3(235.56,140.01) 236.1,139.47 236.1,139.25 235.94,139.09 235.69,139.09 235.53,138.93 235.53,138.69 235.69,138.53 235.94,138.53 236.1,138.37 236.1,137.77 236.58,137.29 236.58,134.94 237.42,134.1 237.42,130.57 229.21,122.36 218.09,122.36 213.64,117.91 211.18,117.91 202.97,109.7 202.97,106.54
  BOTTOM w0.076: U4555.AW39 196.71,95.87 196.81,95.87 v2(197.11,96.17)
  BOTTOM w0.178: CN4100.86 235.1,140.48 v3(235.56,140.01)
M_A_A<8>: length 72.6
  L6 w0.076: v2(197.05,97.11) 197.5,97.56 197.57,97.63 197.57,100.38 202.13,104.94 202.13,106.07 202.43,106.37 202.43,106.54
  L6 w0.165: 202.43,106.54 202.43,109.92 210.96,118.45 213.42,118.45 217.87,122.89 228.99,122.89 236.05,129.95 236.05,130.62 236.15,130.73 236.77,130.73 236.89,130.85 236.89,131.16 236.77,131.28 236.5,131.28 236.3,131.49 236.3,131.99 236.5,132.19 236.77,132.19 236.87,132.29 236.87,133.9 236.05,134.72 236.05,134.76 236.05,134.76 236.05,137.07 235.51,137.6 v3(235.51,137.97)
  BOTTOM w0.076: U4555.AY39 197.05,96.86 v2(197.05,97.11)
  BOTTOM w0.178: v3(235.51,137.97) 234.55,137.97 234.2,137.62 CN4100.89
M_A_A<9>: length 73.6
  L6 w0.076: 200.71,103.85 200.51,103.65 200.51,103.55 197.15,100.19 v2(197.15,99.7)
  L6 w0.165: 200.71,103.85 201.25,104.39 201.25,105.85 201.9,106.49 201.9,110.14 210.74,118.98 213.2,118.98 217.65,123.43 228.76,123.43 228.96,123.63 228.96,123.86 228.87,123.95 228.87,124.18 229.04,124.35 229.27,124.35 229.36,124.26 229.59,124.26 229.75,124.42 229.75,124.65 229.67,124.74 229.67,124.97 229.83,125.14 230.06,125.14 230.15,125.05 230.38,125.05 230.54,125.21 230.54,125.45 230.46,125.53 230.46,125.76 230.62,125.93 230.85,125.93 230.94,125.84 231.17,125.84 231.33,126 231.33,126.24 231.25,126.32 231.25,126.55 231.41,126.72 231.64,126.72 231.73,126.63 231.96,126.63 232.12,126.8 232.12,127.03 232.04,127.11 232.04,127.34 232.2,127.51 232.43,127.51 232.52,127.42 232.75,127.42 232.91,127.59 232.91,127.82 232.83,127.9 232.83,128.14 232.99,128.3 233.22,128.3 233.31,128.21 233.54,128.21 233.71,128.38 233.71,128.61 233.62,128.69 233.62,128.93 234.6,129.91 234.83,129.91 234.91,129.83 235.14,129.83 235.31,129.99 235.31,130.22 235.23,130.3 235.23,130.53 235.51,130.82 235.51,131.3 235.76,131.55 235.76,132.07 235.51,132.32 235.51,133.01 235.61,133.12 236.18,133.12 236.34,133.27 236.34,133.59 236.18,133.74 235.61,133.74 235.51,133.84 235.51,136.35 v3(235.51,136.35)
  BOTTOM w0.076: v2(197.15,99.7) 198.15,98.71 198.15,97.25 197.99,97.1 197.99,94.97 197.58,94.57 U4555.AU40
  BOTTOM w0.178: CN4100.85 235.4,136.24 v3(235.51,136.35)
M_A_A<10>: length 75.3
  L6 w0.076: 194.35,101.57 194.35,96.67 195.04,95.98 195.04,93.47 v2(194.66,93.08)
  L6 w0.165: 194.35,101.57 194.35,101.9 195.69,103.24 195.69,112.5 210.05,126.85 210.05,127.08 209.72,127.41 209.72,127.64 209.88,127.8 210.11,127.8 210.44,127.48 210.67,127.48 210.84,127.64 210.84,127.87 210.51,128.2 210.51,128.43 210.67,128.59 210.9,128.59 211.23,128.27 211.46,128.27 211.63,128.43 211.63,128.66 211.3,128.99 211.3,129.22 211.46,129.38 211.69,129.38 212.02,129.06 212.25,129.06 212.68,129.48 224.58,129.48 226.68,131.58 226.68,131.58 226.68,132.12 226.84,132.29 227.07,132.29 227.22,132.44 227.22,132.69 227.07,132.84 226.84,132.84 226.68,133.01 226.68,133.19 228.77,135.28 228.77,137.24 v3(228.21,137.81)
  BOTTOM w0.076: U4555.AP35 194.26,92.75 194.59,93.08 v2(194.66,93.08)
  BOTTOM w0.178: v3(228.21,137.81) 228.8,137.21 CN4100.107
M_A_A<11>: length 73.1
  L6 w0.076: v2(198.68,96.18) 198.68,96.17 198.13,96.72 198.13,100.13 203.57,105.57
  L6 w0.165: 203.57,105.57 204.11,106.11 204.11,108.96 204.11,109.2 211.76,116.85 214.08,116.85 218.53,121.29 229.66,121.29 238.49,130.13 238.49,134.54 237.65,135.38 237.65,138.45 v3(237.65,138.45)
  BOTTOM w0.076: U4555.AW41 198.29,95.87 198.38,95.87 198.68,96.16 v2(198.68,96.18)
  BOTTOM w0.178: v3(237.65,138.45) 237.65,138.46 236.33,139.78 236.33,140.52 235.7,141.15 CN4100.84
M_A_A<12>: length 73.1
  L6 w0.076: 203.4,106.23 203.2,106.02 203.2,105.5 197.97,100.27 197.97,95.59 v3(198.69,94.86)
  L6 w0.165: 203.4,106.23 203.5,106.32 203.5,109.34 211.54,117.38 213.86,117.38 218.31,121.83 229.44,121.83 237.96,130.35 237.96,134.32 237.11,135.16 237.11,137.6 v2(236.65,138.07)
  BOTTOM w0.076: v3(198.69,94.86) 198.39,94.57 198.23,94.57 U4555.AU41
  BOTTOM w0.178: CN4100.83 236,135.74 236.11,135.85 236.11,137.53 v2(236.65,138.07)
M_A_A<13>: length 74.6
  L6 w0.076: 193.02,106.28 193.05,106.25 193.05,99.28 193.1,99.23 193.22,99.11 193.22,95.55 193.58,95.19 194.12,95.19 194.66,94.65 194.66,93.7 v2(194.66,93.7)
  L6 w0.165: 193.02,106.28 193.02,113.64 193.84,114.46 193.84,114.78 193.55,115.06 193.55,115.36 193.8,115.6 194.03,115.6 194.38,115.25 194.61,115.25 194.77,115.42 194.77,115.65 194.42,116 194.42,116.23 194.59,116.39 194.82,116.39 195.17,116.04 195.4,116.04 195.56,116.21 195.56,116.44 195.21,116.79 195.21,117.02 195.38,117.18 195.61,117.18 195.96,116.83 196.19,116.83 196.35,117 196.35,117.23 196,117.58 196,117.81 196.17,117.98 196.4,117.98 196.75,117.63 196.98,117.63 197.14,117.79 197.14,118.02 196.79,118.37 196.79,118.6 196.96,118.77 197.19,118.77 197.54,118.42 197.77,118.42 197.94,118.58 197.94,118.81 197.59,119.16 197.59,119.39 210.34,132.15 210.79,132.15 210.95,132.31 210.95,132.61 211.12,132.77 211.35,132.77 211.51,132.61 211.51,132.31 211.68,132.15 212.9,132.15 213.07,132.31 213.07,132.62 213.23,132.78 213.46,132.78 213.62,132.62 213.62,132.31 213.79,132.15 215.19,132.15 215.35,132.31 215.35,132.65 215.51,132.81 215.74,132.81 215.91,132.65 215.91,132.31 216.07,132.15 221.87,132.15 225.25,135.53 225.25,135.82 v3(225.28,135.85)
  BOTTOM w0.076: U4555.AR35 194.26,93.4 194.56,93.7 v2(194.66,93.7)
  BOTTOM w0.178: v3(225.28,135.85) 225.28,134.35 CN4100.119
M_A_A<14>: length 73.8
  L6 w0.076: v2(198.68,98.51) 198.32,98.86 198.32,100.09 201.74,103.51 201.99,103.51 202.28,103.8
  L6 w0.165: 202.28,103.8 204.65,106.16 204.65,108.98 211.98,116.31 214.3,116.31 218.75,120.76 229.88,120.76 239.02,129.91 239.02,134.76 238.19,135.6 238.19,139.3 v3(237.65,139.85)
  BOTTOM w0.076: U4555.AV42 199.4,95.51 199.4,96.86 199.09,97.18 199.09,98.1 v2(198.68,98.51)
  BOTTOM w0.178: CN4100.80 236.9,140.59 v3(237.65,139.85)
M_A_A<15>: length 74.6
  L6 w0.076: v2(198.73,99.78) 198.73,100.19 201.88,103.34 202.22,103.34
  L6 w0.165: v3(237.59,141.22) 238.72,140.09 238.72,135.82 239.56,134.98 239.56,129.69 230.1,120.23 218.97,120.23 214.53,115.78 212.2,115.78 205.18,108.76 205.18,108.7 205.18,108.69 205.18,106.19 202.33,103.34 202.22,103.34
  BOTTOM w0.076: v2(198.73,99.78) 199,99.51 199.36,99.14 199.36,97.21 199.57,97 199.57,94.97 199.16,94.57 U4555.AU42
  BOTTOM w0.178: v3(237.59,141.22) 237.5,141.31 CN4100.78
M_A_BS0: length 74.9
  L6 w0.165: v2(193.93,100.36) 193.93,100.36 193.93,102.31 195.16,103.54 195.16,112.72 206.04,123.6 206.04,123.83 205.7,124.17 205.7,124.4 205.87,124.57 206.1,124.57 206.44,124.23 206.67,124.23 206.83,124.39 206.83,124.62 206.49,124.96 206.49,125.19 206.66,125.36 206.89,125.36 207.23,125.02 207.46,125.02 207.62,125.18 207.62,125.41 207.28,125.75 207.28,125.98 207.45,126.15 207.68,126.15 208.02,125.81 208.25,125.81 208.41,125.97 208.41,126.2 208.07,126.54 208.07,126.77 208.24,126.94 208.47,126.94 208.85,126.56 208.99,126.56 209.24,126.81 209.24,126.95 208.86,127.33 208.86,127.56 211.31,130.02 222.75,130.02 223.28,130.54 223.62,130.54 224.13,130.04 224.34,130.04 224.54,130.24 224.54,130.45 224.01,130.98 224.01,131.19 224.19,131.37 224.41,131.37 224.94,130.83 225.16,130.83 225.34,131.01 225.34,131.23 225.05,131.52 225.05,131.73 225.23,131.91 225.45,131.91 225.74,131.62 225.97,131.62 226.14,131.8 226.14,132.06 225.64,132.57 225.64,132.9 228.2,135.46 v3(228.2,136.23)
  BOTTOM w0.076: U4555.AU35 194.43,94.57 194.84,94.97 194.84,97.87
  BOTTOM w0.178: v2(193.93,100.36) 193.93,100.36 194.84,99.45 194.84,97.87 ; CN4100.109 v3(228.2,136.23)
M_A_BS1: length 75.2
  L6 w0.076: 193.76,102.73 193.55,102.51 193.55,99.48 v2(193.96,99.07)
  L6 w0.165: 193.76,102.73 194.62,103.59 194.62,111.64 194.62,112.95 202.01,120.33 202.01,120.56 201.63,120.94 201.63,121.17 201.79,121.34 202.02,121.34 202.4,120.96 202.63,120.96 202.8,121.12 202.8,121.35 202.42,121.73 202.42,121.96 202.58,122.13 202.81,122.13 203.19,121.75 203.42,121.75 203.59,121.91 203.59,122.14 203.21,122.52 203.21,122.75 203.37,122.92 203.6,122.92 203.98,122.54 204.21,122.54 204.38,122.7 204.38,122.93 204,123.31 204,123.54 204.16,123.71 204.39,123.71 204.77,123.33 205,123.33 205.17,123.49 205.17,123.72 204.79,124.1 204.79,124.33 211,130.55 222.53,130.55 222.84,130.86 222.84,130.86 227.63,135.65 227.63,138.72 v3(228.14,139.23)
  BOTTOM w0.076: U4555.AV35 194.68,95.51 194.68,97.61 194.49,97.8 194.49,98.54 v2(193.96,99.07)
  BOTTOM w0.178: v3(228.14,139.23) 228.71,139.8 228.71,141.12 228.5,141.33 CN4100.108
M_A_BS2: length 71.5
  L6 w0.165: v3(239.29,136.82) 239.8,136.82 240.08,136.55 240.08,136.22 239.93,136.07 239.78,136.07 239.62,135.91 239.62,135.68 239.78,135.52 239.78,135.51 239.93,135.51 240.08,135.36 240.08,129.47 230.31,119.71 219.19,119.71 214.74,115.26 212.42,115.26 205.7,108.54 205.7,106.35 205.71,106.34 205.71,106.33 202.38,103 201.96,103 199.17,100.21 199.17,97.61 v2(198.68,97.12)
  BOTTOM w0.076: v2(198.68,97.12) 198.29,96.73 198.29,96.52 U4555.AY41
  BOTTOM w0.178: v3(239.29,136.82) 239.05,137.06 237.89,137.06 237.2,136.37 CN4100.79
M_A_CAS#: length 75.4
  L6 w0.076: 192.49,106.31 192.49,106.11 192.89,105.71 192.89,99.21 193.05,99.04 193.05,95.23 193.53,94.75 v2(193.97,94.75)
  L6 w0.165: v3(225.23,137.27) 224.7,136.73 224.7,135.73 222.31,133.34 221.65,133.34 221.48,133.18 221.48,132.85 221.32,132.68 221.09,132.68 220.92,132.85 220.92,133.18 220.76,133.34 220.15,133.34 219.99,133.18 219.99,132.85 219.83,132.69 219.59,132.69 219.43,132.85 219.43,133.18 219.27,133.34 219.04,133.34 218.87,133.18 218.87,132.85 218.71,132.69 218.48,132.69 218.31,132.85 218.31,133.18 218.15,133.34 217.92,133.34 217.75,133.18 217.75,132.85 217.59,132.69 217.36,132.69 217.2,132.85 217.2,133.18 217.03,133.34 210.37,133.34 209.26,132.23 209.26,131.82 209.03,131.59 208.8,131.59 208.63,131.76 208.49,131.76 208.24,131.51 208.24,131.36 208.41,131.2 208.41,130.97 208.24,130.8 208.01,130.8 207.78,131.03 207.55,131.03 207.39,130.86 207.39,130.63 207.61,130.41 207.61,130.18 207.45,130.01 207.22,130.01 206.99,130.24 206.76,130.24 206.6,130.07 206.6,129.84 206.82,129.62 206.82,129.39 206.66,129.22 206.43,129.22 206.2,129.45 205.97,129.45 205.81,129.28 205.81,129.05 206.03,128.83 206.03,128.59 192.49,115.05 192.49,106.31
  BOTTOM w0.076: U4555.AU34 193.51,94.57 193.72,94.78 193.95,94.78 v2(193.97,94.75)
  BOTTOM w0.178: v3(225.23,137.27) 225.7,137.27 226.4,136.57 CN4100.115
M_A_DQ<0>: length 67.1
  L3 w0.102: v2(214.93,88.78) 215.08,88.93 218.57,88.93 222.34,92.7 222.34,94.19 224.23,96.09 224.53,96.09 225.57,97.13 225.57,98.79 224.95,99.41 224.95,104.88 223.75,106.07 223.75,123.1 222.34,124.51 222.34,124.66 222.44,124.76 222.59,124.76 223.57,123.79 223.71,123.79 223.82,123.89 223.82,124.04 222.25,125.6 222.25,132.83 222.03,133.05 222.03,133.4 222.13,133.5 222.36,133.5 222.46,133.61 222.46,133.76 222.36,133.86 222.13,133.86 222.03,133.96 222.03,134.11 222.13,134.21 222.36,134.21 222.46,134.32 222.46,134.47 222.36,134.57 222.13,134.57 222.03,134.67 222.03,134.82 222.13,134.93 222.36,134.93 222.46,135.03 222.46,135.18 222.36,135.28 222.13,135.28 222.03,135.38 222.03,135.54 222.13,135.64 222.36,135.64 222.47,135.74 222.47,135.89 222.36,135.99 222.13,135.99 222.03,136.09 222.03,136.38 v3(222.21,136.56)
  BOTTOM w0.076: U4555.AH63 212.16,89.17 212.23,89.23 212.81,89.23 212.85,89.19 213.51,89.19 213.58,89.26 214.45,89.26 v2(214.93,88.78)
  BOTTOM w0.114: CN4100.129 222.2,136.55 v3(222.21,136.56)
M_A_DQ<1>: length 67.9
  L3 w0.102: v3(222.17,138.08) 222.17,138.15 222.32,138.3 222.67,138.3 222.83,138.15 222.83,125.53 223.15,125.21 223.3,125.21 223.43,125.34 223.57,125.34 223.68,125.23 223.68,125.09 223.55,124.95 223.55,124.81 223.66,124.7 223.8,124.7 223.92,124.82 224.07,124.82 224.17,124.71 224.17,124.57 224.06,124.45 224.06,124.3 224.36,124 224.36,106.94 226.37,104.93 226.37,97.32 222.72,93.68 222.72,92.58 218.72,88.58 216.72,88.58 216.61,88.48 216.61,88.47 216.51,88.37 214.47,88.37 v2(214.19,88.64)
  BOTTOM w0.076: v2(214.19,88.64) 213.81,89.02 212.87,89.02 212.72,88.87 212.09,88.87 211.92,88.97 211.71,88.97 211.51,89.17 U4555.AH62
  BOTTOM w0.114: v3(222.17,138.08) 221.6,137.51 CN4100.131
M_A_DQ<2>: length 66.1
  L3 w0.102: v2(215,90.17) 215,91.67 215.52,92.19 215.52,92.83 216.3,93.61 219.03,93.61 219.92,94.49 219.92,95.23 222.53,97.84 222.53,103.76 220.76,105.53 220.76,118.01 220.87,118.11 221.29,118.11 221.43,118.25 221.43,118.36 221.33,118.47 220.87,118.47 220.76,118.57 220.76,118.72 220.87,118.82 221.35,118.82 221.45,118.93 221.45,119.07 221.35,119.18 220.87,119.18 220.76,119.28 220.76,119.43 220.87,119.53 221.35,119.53 221.45,119.64 221.45,119.78 221.35,119.89 220.87,119.89 220.76,119.99 220.76,120.14 220.87,120.24 221.35,120.24 221.45,120.35 221.45,120.5 221.35,120.6 220.87,120.6 220.76,120.7 220.76,120.85 220.87,120.95 221.37,120.95 221.46,121.04 221.46,121.22 221.37,121.31 220.87,121.31 220.76,121.41 220.76,121.63 220.87,121.73 221.28,121.73 221.38,121.84 221.38,121.98 221.28,122.09 220.87,122.09 220.76,122.19 220.76,122.66 219.96,123.47 219.96,123.93 219.85,124.03 219.36,124.03 219.26,124.13 219.26,124.29 219.36,124.39 219.85,124.39 219.96,124.49 219.96,124.64 219.85,124.74 219.37,124.74 219.26,124.85 219.26,124.99 219.37,125.1 219.85,125.1 219.96,125.2 219.96,131.35 219.26,132.04 219.26,134.92 218.6,135.58 v3(218.6,135.98)
  BOTTOM w0.076: U4555.AK63 212.16,90.51 212.68,90.51 212.88,90.72 214.81,90.72 215,90.53 v2(215,90.17)
  BOTTOM w0.114: CN4100.141 v3(218.6,135.98)
M_A_DQ<3>: length 66.8
  L3 w0.102: v3(218.58,137.53) 218.87,137.53 219.03,137.36 219.62,136.77 219.62,132.23 220.31,131.54 220.31,123.79 221.81,122.29 221.81,117.81 221.64,117.64 221.28,117.64 221.18,117.54 221.18,117.27 221.28,117.17 221.71,117.17 221.81,117.07 221.81,116.91 221.71,116.82 221.22,116.82 221.12,116.71 221.12,116.56 221.22,116.46 221.72,116.46 221.81,116.37 221.81,116.2 221.72,116.1 221.22,116.1 221.12,116 221.12,115.85 221.22,115.75 221.72,115.75 221.81,115.66 221.81,115.48 221.72,115.39 221.22,115.39 221.12,115.29 221.12,115.14 221.22,115.04 221.73,115.04 221.81,114.95 221.81,114.77 221.73,114.68 221.22,114.68 221.12,114.58 221.12,114.43 221.22,114.33 221.71,114.33 221.81,114.22 221.81,114.07 221.71,113.97 221.22,113.97 221.12,113.87 221.12,105.79 222.89,104.02 222.89,97.69 220.27,95.08 220.27,94.32 217.56,91.61 216.2,91.61 215.63,91.03 v2(215.63,90.75)
  BOTTOM w0.076: U4555.AK62 211.51,90.51 211.81,90.81 212.74,90.81 212.81,90.88 215.49,90.88
  BOTTOM w0.114: 215.49,90.88 v2(215.63,90.75) ; CN4100.143 218,136.94 v3(218.58,137.53)
M_A_DQ<4>: length 68.3
  L3 w0.102: v3(221.9,141.08) 223.21,139.77 223.21,126.21 224.71,124.71 224.71,107.09 226.8,105.01 226.8,97.25 224.76,95.21 223.15,93.6 223.15,92.5 218.75,88.11 217.83,88.11 217.8,88.07 214.01,88.07 213.45,88.64 v2(213.41,88.64)
  BOTTOM w0.076: U4555.AH61 210.86,89.17 211.25,88.78 211.91,88.78 212.05,88.71 213.34,88.71 v2(213.41,88.64)
  BOTTOM w0.114: CN4100.130 v3(221.9,141.08)
M_A_DQ<5>: length 68.8
  L3 w0.102: v3(222.03,139.5) 221.57,139.04 220.97,139.04 220.84,138.91 220.84,138.74 220.97,138.62 221.51,138.62 221.67,138.45 221.67,137.9 221.68,137.89 221.68,132.91 221.9,132.69 221.9,124.45 223.4,122.95 223.4,105.79 224.48,104.71 224.48,96.91 221.86,94.3 221.86,92.72 218.42,89.29 214.61,89.29 v2(213.73,90.17)
  BOTTOM w0.076: v2(213.73,90.17) 213.51,90.39 213.02,90.39 212.69,90.06 212.06,90.06 211.9,90.13 211.77,90.13 211.62,90.06 211.41,90.06 211.36,90.08 211.27,90.13 211.26,90.13 211.07,90.13 211.05,90.12 210.68,90.12 210.66,90.13 210.42,90.13 210.21,89.93 U4555.AH60
  BOTTOM w0.114: CN4100.132 221.3,139.91 221.71,139.5 v3(222.03,139.5)
M_A_DQ<6>: length 67.1
  L3 w0.102: v3(218.74,141.05) 218.74,141.22 218.64,141.33 218.25,141.33 218.15,141.22 218.15,135.53 218.91,134.77 218.91,132.13 218.91,132.13 218.91,131.9 219.6,131.2 219.6,128.54 218.91,127.85 218.91,127.62 219.01,127.52 219.37,127.52 219.47,127.42 219.47,127.27 219.37,127.16 219.01,127.16 218.91,127.06 218.91,126.91 219.01,126.81 219.37,126.81 219.47,126.7 219.47,126.56 219.37,126.45 219.01,126.45 218.91,126.35 218.91,126.2 219.01,126.1 219.35,126.1 219.45,125.99 219.45,125.85 219.35,125.74 219.01,125.74 218.91,125.64 218.91,123.82 220.41,122.32 220.41,105.38 222.02,103.77 222.02,102.76 222.02,102.76 222.02,97.83 219.03,94.84 216.42,94.84 215.08,93.5 215.08,92.26 214.39,91.56 v2(214.39,90.19)
  BOTTOM w0.076: v2(214.39,90.19) 214.39,90.21 214.05,90.55 212.95,90.55 212.62,90.22 212.1,90.22 212.05,90.25 211.94,90.3 211.74,90.3 211.68,90.27 211.6,90.23 211.58,90.22 211.45,90.22 211.4,90.25 211.34,90.27 211.13,90.49 210.94,90.49 210.86,90.41 U4555.AK61
  BOTTOM w0.114: v3(218.74,141.05) 218.9,141.21 CN4100.140
M_A_DQ<7>: length 67.8
  L3 w0.102: v2(216.5,90.85) 216.9,91.25 217.7,91.25 220.63,94.17 220.63,94.93 223.24,97.55 223.24,104.2 222.17,105.28 222.17,111.63 222.06,111.73 221.66,111.73 221.56,111.84 221.56,111.98 221.66,112.09 222.06,112.09 222.17,112.19 222.17,112.34 222.06,112.44 221.68,112.44 221.57,112.55 221.57,112.69 221.68,112.8 222.06,112.8 222.17,112.9 222.17,113.05 222.06,113.15 221.68,113.15 221.57,113.26 221.57,113.41 221.68,113.51 222.06,113.51 222.17,113.61 222.17,122.44 220.67,123.94 220.67,131.68 219.98,132.37 219.98,137.03 219.39,137.62 219.39,139.79 219.29,139.89 218.82,139.89 218.72,139.79 v3(218.72,139.56)
  BOTTOM w0.076: 214.57,91.07 214.55,91.05 212.75,91.05 212.67,90.97 211.56,90.97 211.29,90.7 210.51,90.7 210.21,90.41 U4555.AK60
  BOTTOM w0.114: v3(218.72,139.56) 218.3,139.97 CN4100.142 ; v2(216.5,90.85) 216.08,91.26 214.76,91.26 214.57,91.07
M_A_DQ<8>: length 84.1
  L6 w0.102: v2(213.98,91.76) 214.4,91.34 217.63,91.34 217.97,91 219.62,91 226.81,98.19 228.05,98.19 228.93,98.19 233.12,102.37 241.56,102.37 244.38,105.18 245.83,105.18 251.92,111.27 251.92,112.5 257.42,117.99 257.42,118.42 259.76,120.77 259.76,127.73 260.84,128.81 260.84,128.95 260.74,129.06 260.6,129.06 260.49,129.17 260.49,129.32 260.6,129.43 260.8,129.43 260.91,129.53 260.91,129.69 260.8,129.79 260.6,129.79 260.49,129.9 260.49,130.05 260.6,130.16 260.81,130.16 260.92,130.27 260.92,130.42 260.81,130.53 260.6,130.53 260.49,130.64 260.49,130.79 260.6,130.9 260.86,130.9 260.96,131.01 260.96,131.16 260.86,131.27 260.6,131.27 260.49,131.37 260.49,131.53 260.6,131.64 260.74,131.64 260.84,131.74 260.84,131.9 260.74,132 260.6,132 260.49,132.11 260.49,132.26 260.6,132.37 261.15,132.37 261.25,132.47 261.25,132.64 261.15,132.74 260.6,132.74 260.49,132.85 260.49,133.27 261.84,134.63 261.84,136.33 v3(261.94,136.42)
  BOTTOM w0.076: U4555.AM63 212.21,91.54 213.79,91.54 213.98,91.74 v2(213.98,91.76)
  BOTTOM w0.114: CN4100.5 261.8,136.28 v3(261.94,136.42)
M_A_DQ<9>: length 85.1
  L6 w0.102: v3(261.97,137.82) 261.71,137.82 261.49,137.6 261.49,134.78 260.13,133.42 260.13,128.6 259.41,127.88 259.41,120.91 257.06,118.57 257.06,118.14 251.44,112.52 251.44,111.3 249.57,109.42 248.67,109.42 248.49,109.24 248.49,109.09 248.57,109 248.57,108.85 248.47,108.74 248.31,108.74 248.23,108.83 248.07,108.83 247.41,108.16 247.41,107.64 245.31,105.54 244.23,105.54 241.42,102.73 232.97,102.73 228.79,98.54 228.2,98.54 228.2,98.54 226.66,98.54 219.48,91.36 218.12,91.36 217.78,91.7 216.53,91.7 v2(216.18,92.05)
  BOTTOM w0.076: v2(216.18,92.05) 216.09,91.96 214.75,91.96 214.17,91.38 212.61,91.38 212.54,91.3 212.49,91.3 211.8,91.3 U4555.AM62
  BOTTOM w0.114: CN4100.7 261.2,137.84 261.35,137.99 261.79,137.99 v3(261.97,137.82)
M_A_DQ<10>: length 83.3
  L6 w0.102: v3(258.46,137.86) 258.25,137.86 258.09,137.7 258.09,135.2 257.01,134.12 257.01,132.11 256.7,131.8 256.7,122.04 246.85,112.18 246.85,111.43 243.73,108.3 243.17,108.3 240.3,105.43 231.85,105.43 230.01,103.6 228.97,103.6 227.59,102.21 227.45,102.21 227.31,102.35 227.31,102.49 228.16,103.35 228.16,103.49 228.06,103.6 227.89,103.6 219.37,95.07 214.04,95.07 v2(213.77,95.35)
  BOTTOM w0.076: 214.57,94.75 214.85,94.47 214.85,94.16 214.25,93.56 213.17,93.56 212.56,92.95 212.16,92.95 U4555.AP63 ; 213.99,95.33 213.97,95.35
  BOTTOM w0.114: v3(258.46,137.86) 259.13,137.19 259.13,136.05 258.8,135.72 258.8,134.4 258.8,134.4 CN4100.15 ; 214.57,94.75 213.99,95.33 ; 213.97,95.35 v2(213.77,95.35)
M_A_DQ<11>: length 84.3
  L6 w0.102: v2(214.47,94.31) 214.87,94.72 219.52,94.72 226.06,101.26 226.27,101.26 226.38,101.37 226.38,101.55 226.49,101.66 226.64,101.66 226.75,101.55 226.75,101.37 226.86,101.26 227.01,101.26 227.12,101.37 227.12,101.75 227.22,101.86 227.38,101.86 227.48,101.75 227.48,101.37 227.59,101.26 228.18,101.26 229.45,102.53 229.45,102.68 229.34,102.79 229.19,102.79 228.13,101.73 227.98,101.73 227.87,101.84 227.87,101.99 229.12,103.24 230.16,103.24 232,105.07 240.44,105.07 243.27,107.9 243.83,107.9 247.21,111.28 247.21,112.04 257.06,121.89 257.06,129.41 257.17,129.52 257.46,129.52 257.56,129.62 257.56,129.79 257.46,129.89 257.17,129.89 257.06,129.99 257.06,130.15 257.17,130.26 257.53,130.26 257.63,130.36 257.63,130.52 257.53,130.62 257.17,130.62 257.06,130.73 257.06,130.88 257.17,130.99 257.49,130.99 257.6,131.1 257.6,131.25 257.49,131.36 257.17,131.36 257.06,131.47 257.06,131.65 257.37,131.96 257.37,132.48 257.47,132.59 257.65,132.59 257.76,132.7 257.76,132.85 257.65,132.96 257.47,132.96 257.37,133.07 257.37,133.22 257.47,133.33 257.65,133.33 257.76,133.44 257.76,133.59 257.65,133.7 257.47,133.7 257.37,133.81 257.37,133.98 258.45,135.06 258.45,136.09 v3(258.59,136.23)
  BOTTOM w0.076: U4555.AP62 211.51,92.95 211.81,93.24 212.62,93.24 213.32,93.94
  BOTTOM w0.114: 213.32,93.94 213.69,94.31 v2(214.47,94.31) ; CN4100.17 258.2,135.85 v3(258.59,136.23)
M_A_DQ<12>: length 85.4
  L6 w0.102: v3(262.01,139.24) 261.52,138.76 261.52,138.24 261.13,137.84 261.13,134.92 259.78,133.57 259.78,128.75 259.05,128.02 259.05,121.06 256.71,118.72 256.71,118.29 251.09,112.67 251.09,111.45 249.42,109.78 248.53,109.78 247.06,108.31 247.06,107.79 245.16,105.9 244.08,105.9 241.27,103.08 232.82,103.08 228.64,98.9 228.34,98.9 226.52,98.9 219.67,92.05 217.55,92.05 v2(217.47,92.13)
  BOTTOM w0.076: 214.69,91.64 214.27,91.21 212.68,91.21 212.61,91.14 212.56,91.14 212.56,91.14 211.98,91.14 211.98,91.14 211.55,91.14 210.99,91.7 U4555.AM61
  BOTTOM w0.114: v2(217.47,92.13) 216.98,91.65 214.7,91.65 214.69,91.64 ; v3(262.01,139.24) 262.44,139.67 262.44,140.91 262.1,141.25 CN4100.4
M_A_DQ<13>: length 86.2
  L6 w0.102: v3(261.96,140.66) 261.82,140.66 261.14,139.97 261.14,138.35 260.78,137.99 260.78,135.07 259.42,133.71 259.42,128.89 258.7,128.17 258.7,121.21 256.36,118.87 256.35,118.87 256.35,118.44 250.73,112.82 250.73,111.59 249.28,110.13 248.38,110.13 246.7,108.46 246.7,107.94 245.02,106.25 243.94,106.25 241.12,103.44 232.67,103.44 228.49,99.25 226.37,99.25 219.56,92.44 217.87,92.44 217.7,92.61 v2(216.53,92.61)
  BOTTOM w0.076: v2(216.53,92.61) 215.95,93.19 213.27,93.19 212.57,92.49 212.06,92.49 211.9,92.56 211.77,92.56 211.62,92.49 211.41,92.49 211.36,92.51 211.27,92.56 211.26,92.56 210.42,92.56 210.21,92.36 210.21,91.7 U4555.AM60
  BOTTOM w0.114: CN4100.6 261.5,141.11 v3(261.96,140.66)
M_A_DQ<14>: length 84.2
  L6 w0.102: v2(214.15,95.77) 214.48,95.44 219.23,95.44 227.74,103.95 229.87,103.95 231.7,105.78 239.95,105.78 244.68,110.52 245.44,110.52 246.5,111.57 246.5,112.33 256.35,122.18 256.35,131.95 256.66,132.26 256.66,134.27 257.74,135.35 257.74,140.51 257.59,140.66 257.21,140.66 257.08,140.79 257.08,141.21 257.29,141.41 258.27,141.41 258.5,141.19 v3(258.5,141.07)
  BOTTOM w0.076: 215.01,94.91 215.01,94.09 214.32,93.39 213.24,93.39 212.5,92.66 212.1,92.66 211.99,92.7 211.94,92.73 211.74,92.73 211.68,92.7 211.6,92.66 211.58,92.66 211.45,92.66 211.34,92.71 211.1,92.95 210.86,92.95 U4555.AP61
  BOTTOM w0.114: 215.01,94.91 v2(214.15,95.77) ; CN4100.16 v3(258.5,141.07)
M_A_DQ<15>: length 85.2
  L6 w0.102: v3(258.45,139.42) 258.82,139.42 259.02,139.22 259.02,135.13 258.14,134.25 258.14,129.43 257.41,128.7 257.41,121.74 249.16,113.49 249.16,113.33 249.43,113.07 249.43,112.91 249.32,112.8 249.17,112.8 248.9,113.07 248.74,113.07 248.15,112.48 248.15,112.33 248.49,111.99 248.49,111.84 248.38,111.73 248.23,111.73 247.89,112.07 247.74,112.07 247.62,111.94 247.62,111.19 243.98,107.55 243.42,107.55 240.59,104.72 232.14,104.72 228.33,100.9 226.2,100.9 219.08,93.78 213.7,93.78 v2(212.92,94.56)
  BOTTOM w0.076: 213.1,94.04 213.1,93.95 212.55,93.4 211.73,93.4 211.61,93.29 210.79,93.29 210.45,92.95 210.21,92.95 U4555.AP60
  BOTTOM w0.114: v3(258.45,139.42) 257.9,139.97 CN4100.18 ; 213.1,94.04 213.1,94.38 v2(212.92,94.56)
M_A_DQ<16>: length 61.4
  L3 w0.076: v2(209.44,93.13) 209.44,93.34 209.71,93.61 209.71,93.7
  L3 w0.102: 209.71,93.7 209.87,93.86 209.87,95.32 212.19,97.64 217.62,97.64 219.15,99.16 219.15,102.68 217.6,104.22 217.6,120.99 216.1,122.49 216.1,126.79 216,126.89 215.16,126.89 215.06,126.99 215.06,127.14 215.16,127.24 215.92,127.24 216.03,127.36 216.03,127.51 215.92,127.62 215.68,127.62 215.55,127.76 215.55,133.37 215.44,133.47 215,133.47 214.9,133.57 214.9,133.73 215,133.83 215.44,133.83 215.55,133.93 215.55,134.15 215.22,134.47 215.22,134.96 215.22,137.3 215.07,137.45 v3(214.85,137.45)
  BOTTOM w0.076: U4555.AP58 209.32,93.13 v2(209.44,93.13)
  BOTTOM w0.114: v3(214.85,137.45) 213.98,137.45 213.2,136.67 CN4100.159
M_A_DQ<17>: length 60.8
  L3 w0.102: v2(209.31,93.75) 209.4,93.84 209.4,95.27 212.13,98 217.35,98 218.72,99.37 218.72,102.6 217.25,104.07 217.25,120.59 215.75,122.09 215.75,125.75 214.54,126.96 214.54,127.8 214.64,127.9 214.98,127.9 215.09,128.01 215.09,128.15 214.98,128.26 214.64,128.26 214.54,128.36 214.54,128.51 214.64,128.61 215.05,128.61 215.15,128.72 215.15,128.87 215.05,128.97 214.64,128.97 214.54,129.07 214.54,129.22 214.64,129.33 215.09,129.33 215.19,129.43 215.19,129.58 215.09,129.68 214.64,129.68 214.54,129.78 214.54,129.94 214.64,130.04 215.09,130.04 215.19,130.14 215.19,130.29 215.09,130.39 214.64,130.39 214.54,130.49 214.54,130.65 214.64,130.75 215.09,130.75 215.19,130.85 215.19,131 215.09,131.1 214.64,131.1 214.54,131.21 214.54,131.36 214.64,131.46 215.09,131.46 215.19,131.56 215.19,131.71 215.09,131.81 214.76,131.81 214.66,131.92 214.66,132.07 214.76,132.17 215.09,132.17 215.19,132.27 215.19,132.76 214.51,133.44 214.51,135.7 v3(214.79,135.97)
  BOTTOM w0.114: v3(214.79,135.97) 214.08,135.97 213.8,135.69 CN4100.157 ; U4555.AR58 209.29,93.75 v2(209.31,93.75)
M_A_DQ<18>: length 63.5
  L3 w0.076: v2(208.47,91.85) 208.47,91.77 208.82,91.41 209.79,91.41
  L3 w0.102: 209.79,91.41 211.96,93.58 211.96,94.41 213.96,96.41 218.29,96.41 220.38,98.5 220.38,102.01 220.38,103.19 218.83,104.73 218.83,121.5 217.33,123 217.33,128.15 217.23,128.26 217.04,128.26 216.94,128.36 216.94,128.51 217.04,128.61 217.23,128.61 217.33,128.71 217.33,128.87 217.23,128.97 216.87,128.97 216.78,129.06 216.78,129.23 216.87,129.32 217.23,129.32 217.33,129.42 217.33,129.58 217.23,129.68 216.87,129.68 216.78,129.77 216.78,129.94 216.87,130.03 217.23,130.03 217.33,130.14 217.33,130.29 217.23,130.39 216.89,130.39 216.78,130.49 216.78,130.64 216.89,130.74 217.23,130.74 217.33,130.85 217.33,131 217.23,131.1 216.89,131.1 216.79,131.2 216.79,131.35 216.89,131.46 217.23,131.46 217.33,131.56 217.33,131.71 217.23,131.81 216.89,131.81 216.79,131.92 216.79,132.06 216.89,132.17 217.23,132.17 217.33,132.27 217.33,133.2 217.23,133.3 216.99,133.3 216.88,133.4 216.88,133.56 216.99,133.66 217.23,133.66 217.33,133.76 217.33,134.1 216.5,134.94 v3(216.5,136.41)
  BOTTOM w0.076: v2(208.47,91.85) 208.44,91.85 208.04,91.45 U4555.AM57
  BOTTOM w0.114: CN4100.149 216.2,136.11 v3(216.5,136.41)
M_A_DQ<19>: length 64.9
  L3 w0.102: v3(216.5,140.92) 216.53,140.92 217.64,139.81 217.64,135.31 218.4,134.56 218.4,134.3 218.4,131.69 219.09,130.99 219.09,128.76 218.4,128.06 218.4,123.44 219.9,121.94 219.9,105.17 221.51,103.56 221.51,102.97 221.51,98.04 218.82,95.34 216.05,95.34 214.24,93.53 213.54,93.53 212.6,92.6 212.6,91.73 210.87,90 208.9,90 208.51,90.39 208.5,90.39 v2(208.5,90.39)
  BOTTOM w0.114: CN4100.148 v3(216.5,140.92) ; v2(208.5,90.39) 208.28,90.39 208.04,90.15 U4555.AK57
M_A_DQ<20>: length 63.5
  L3 w0.102: v3(216.52,137.84) 216.75,137.84 216.93,137.65 216.93,135.02 217.69,134.26 217.69,130.88 217.79,130.77 218.26,130.77 218.36,130.67 218.36,130.52 218.26,130.42 217.79,130.42 217.69,130.31 217.69,130.17 217.79,130.06 218.26,130.06 218.36,129.96 218.36,129.81 218.26,129.71 217.79,129.71 217.69,129.61 217.69,129.45 217.79,129.35 218.26,129.35 218.36,129.25 218.36,129.1 218.26,128.99 217.79,128.99 217.69,128.89 217.69,123.15 219.19,121.65 219.19,104.88 220.8,103.27 220.8,98.34 218.52,96.05 215.08,96.05 212.08,93.05 211.89,93.05 209.86,91.01 209.39,91.01 209.38,91.02 v2(209.38,91.03)
  BOTTOM w0.114: CN4100.147 216.8,136.09 216.94,136.23 216.94,137.41 v3(216.52,137.84) ; U4555.AL58 208.94,90.8 209.17,91.03 v2(209.38,91.03)
M_A_DQ<21>: length 64.3
  L3 w0.102: v3(216.49,139.38) 216.49,139.54 216.64,139.7 217.14,139.7 217.29,139.54 217.29,139.15 217.19,139.05 217.02,139.05 216.91,138.95 216.91,138.79 217.02,138.69 217.19,138.69 217.29,138.59 217.29,135.17 218.05,134.41 218.05,131.54 218.74,130.85 218.74,128.9 218.05,128.21 218.05,123.3 219.55,121.8 219.55,105.03 221.16,103.41 221.16,103.12 221.16,98.19 218.67,95.7 215.22,95.7 212.1,92.58 211.85,92.58 209.72,90.45 v2(209.41,90.45)
  BOTTOM w0.114: CN4100.146 217.1,139.99 v3(216.49,139.38) ; v2(209.41,90.45) 209.24,90.45 208.94,90.15 U4555.AK58
M_A_DQ<22>: length 61.7
  L3 w0.102: v3(212.88,139.72) 213.55,139.05 213.55,126.38 213.65,126.27 213.92,126.27 214.02,126.17 214.02,126.02 213.92,125.92 213.65,125.92 213.55,125.81 213.55,125.67 213.65,125.56 213.92,125.56 214.02,125.46 214.02,125.31 213.92,125.21 213.65,125.21 213.55,125.1 213.55,124.96 213.65,124.85 213.92,124.85 214.02,124.75 214.02,124.6 213.92,124.5 213.65,124.5 213.55,124.39 213.55,124.24 213.65,124.14 213.87,124.14 213.97,124.04 213.97,123.89 213.87,123.78 213.65,123.78 213.55,123.68 213.55,123.28 216.54,120.29 216.54,103.78 218.01,102.3 218.01,100.01 216.79,98.79 211.89,98.79 208.44,95.34 208.44,94.26 208.44,94.26 v2(208.44,93.73)
  BOTTOM w0.114: CN4100.158 213.5,139.92 213.3,139.72 212.88,139.72 v3(212.88,139.72) ; v2(208.44,93.73) 208.37,93.73 208.05,93.4 U4555.AR57
M_A_DQ<23>: length 63.2
  L3 w0.102: v3(212.94,141.14) 212.95,141.14 214.16,139.93 214.16,126.84 214.55,126.45 214.55,125.95 214.65,125.84 214.96,125.84 215.06,125.74 215.06,125.59 214.96,125.49 214.65,125.49 214.55,125.38 214.55,125.24 214.65,125.13 214.96,125.13 215.06,125.03 215.06,124.88 214.96,124.78 214.65,124.78 214.55,124.67 214.55,124.53 214.65,124.42 214.96,124.42 215.06,124.32 215.06,124.17 214.96,124.07 214.65,124.07 214.55,123.96 214.55,123.82 214.65,123.71 214.96,123.71 215.06,123.61 215.06,123.46 214.96,123.36 214.65,123.36 214.55,123.25 214.55,122.78 216.89,120.44 216.89,103.93 218.37,102.45 218.37,99.86 216.94,98.44 212.06,98.44 208.85,95.23 208.85,92.84 v2(208.44,92.43)
  BOTTOM w0.114: v3(212.94,141.14) 212.9,141.18 CN4100.160 ; U4555.AN57 208.04,92.1 208.37,92.43 v2(208.44,92.43)
M_A_DQ<24>: length 82.9
  L6 w0.076: v2(207.63,93.1) 207.64,93.1 207.9,93.36 207.9,93.96 208.77,94.83 211.15,94.83 211.3,94.97
  L6 w0.102: v3(256.14,137.5) 256.24,137.5 256.5,137.24 256.5,135.86 255.12,134.48 255.12,123.08 243.25,111.21 243.25,110.82 240.17,107.75 238.86,107.75 238.13,107.02 231.15,107.02 229.84,105.71 227.75,105.71 226.03,104 225.88,104 225.64,104.24 225.49,104.24 225.38,104.13 225.38,103.98 225.62,103.74 225.62,103.59 225.51,103.48 225.36,103.48 225.12,103.72 224.97,103.72 224.86,103.61 224.86,103.46 225.1,103.22 225.1,103.06 224.99,102.96 224.84,102.96 224.6,103.2 224.45,103.2 224.34,103.09 224.34,102.94 224.58,102.7 224.58,102.54 218.71,96.67 215,96.67 214.76,96.91 212.85,96.91 211.98,96.04 211.98,95.65 211.3,94.97
  BOTTOM w0.076: U4555.AP55 207.44,93.1 v2(207.63,93.1)
  BOTTOM w0.114: CN4100.21 257,136.64 v3(256.14,137.5)
M_A_DQ<25>: length 82.3
  L6 w0.076: v2(207.51,93.7) 207.51,93.8 208.72,95.01 210.8,95.01 210.9,95.11
  L6 w0.102: 210.9,95.11 211.62,95.83 211.62,96.19 212.7,97.27 214.89,97.27 215.07,97.09 218.62,97.09 222.19,100.65 222.19,102.04 226.87,106.73 227.75,106.73 227.86,106.62 227.86,106.18 227.97,106.08 228.12,106.08 228.23,106.18 228.23,106.62 228.34,106.73 228.49,106.73 228.6,106.62 228.6,106.18 228.7,106.07 228.86,106.07 228.97,106.18 228.97,106.62 229.07,106.73 229.23,106.73 229.33,106.62 229.33,106.2 229.44,106.1 229.72,106.1 231,107.37 237.99,107.37 238.72,108.1 240.02,108.1 242.89,110.97 242.89,111.36 254.76,123.23 254.76,134.62 255.31,135.17 255.31,137.22 255.41,137.32 255.58,137.32 255.68,137.22 255.68,136.5 v3(256.07,136.11)
  BOTTOM w0.076: v2(207.51,93.7) 207.39,93.7 207.1,93.4 U4555.AR55
  BOTTOM w0.114: CN4100.23 256.4,135.78 v3(256.07,136.11)
M_A_DQ<26>: length 85.6
  L6 w0.102: v3(252.37,138.04) 252.37,138.04 252.77,137.64 252.77,128.88 252.66,128.77 252.25,128.77 252.14,128.66 252.14,128.51 252.25,128.4 252.66,128.4 252.77,128.29 252.77,128.14 252.66,128.03 252.22,128.03 252.11,127.92 252.11,127.77 252.22,127.66 252.66,127.66 252.77,127.56 252.77,127.4 252.66,127.3 252.38,127.3 252.28,127.19 252.28,127.03 252.38,126.93 252.66,126.93 252.77,126.82 252.77,124.99 251.97,124.19 251.22,124.19 246.61,119.58 246.61,118.71 242.42,114.52 242.42,114.01 241.13,112.72 240.38,112.72 237.07,109.41 230.09,109.41 229.41,108.73 222.39,108.73 218.89,105.22 217.17,105.22 211.49,99.54 211.49,98.67 209.59,96.78 207.32,96.78 205.81,95.27 205.81,92.96 206.24,92.53 206.24,92.12 206.57,91.79 v2(206.66,91.79)
  BOTTOM w0.114: CN4100.33 253.4,137.46 252.82,138.04 v3(252.37,138.04) ; v2(206.66,91.79) 206.48,91.79 206.15,91.45 U4555.AM54
M_A_DQ<27>: length 86.7
  L6 w0.076: 205.28,92.25 205.45,92.08 205.86,92.08 206.06,91.88 206.06,91 v2(206.59,90.48)
  L6 w0.102: 205.28,92.25 205.28,95.21 207.05,96.98 208.62,96.98 208.92,97.29 208.92,97.48 217.04,105.59 218.75,105.59 222.24,109.08 222.77,109.08 222.88,109.19 222.88,109.55 222.99,109.66 223.14,109.66 223.25,109.55 223.25,109.19 223.36,109.08 223.51,109.08 223.62,109.19 223.62,109.55 223.73,109.66 223.88,109.66 223.99,109.55 223.99,109.19 224.09,109.08 224.25,109.08 224.36,109.19 224.36,109.55 224.46,109.66 224.62,109.66 224.72,109.55 224.72,109.19 224.83,109.08 224.98,109.08 225.09,109.19 225.09,109.52 225.2,109.63 225.35,109.63 225.46,109.52 225.46,109.19 225.57,109.08 225.72,109.08 225.83,109.19 225.83,109.54 225.94,109.64 226.09,109.64 226.2,109.54 226.2,109.33 226.3,109.23 226.46,109.23 226.56,109.33 226.56,109.51 226.67,109.62 226.83,109.62 226.93,109.51 226.93,109.19 227.04,109.08 227.19,109.08 227.3,109.19 227.3,109.5 227.41,109.61 227.56,109.61 227.67,109.5 227.67,109.19 227.78,109.08 227.93,109.08 228.04,109.19 228.04,109.51 228.15,109.62 228.3,109.62 228.83,109.08 229.26,109.08 229.94,109.76 236.92,109.76 240.24,113.08 240.99,113.08 242.07,114.15 242.07,114.67 246.25,118.86 246.25,119.38 246.25,119.49 246.25,119.49 246.25,119.92 251.68,125.34 251.68,129.9 252.33,130.55 v3(252.33,136.72)
  BOTTOM w0.114: v2(206.59,90.48) 206.47,90.48 206.15,90.15 U4555.AK54 ; v3(252.33,136.72) 252.8,136.25 CN4100.35
M_A_DQ<28>: length 85.3
  L6 w0.076: 211.66,94.83 211.49,94.66 208.83,94.66 208.06,93.89 208.06,91.7 v2(207.49,91.13)
  L6 w0.102: v3(256.1,138.95) 256.34,138.95 256.86,138.43 256.86,135.71 255.47,134.33 255.47,122.94 243.6,111.07 243.6,110.97 243.6,110.68 239.59,106.66 239.42,106.66 239.31,106.77 239.31,107.08 239.2,107.19 239.05,107.19 238.94,107.08 238.94,106.77 238.84,106.66 231.29,106.66 229.99,105.36 227.9,105.36 218.86,96.32 215.07,96.32 214.83,96.56 213.39,96.56 211.66,94.83
  BOTTOM w0.076: U4555.AL55 207.42,91.13 v2(207.49,91.13)
  BOTTOM w0.114: v3(256.1,138.95) 256.7,139.55 CN4100.22
M_A_DQ<29>: length 86.1
  L6 w0.076: v2(207.54,90.48) 207.54,90.61 208.4,91.47 208.63,91.47 208.88,91.72 208.88,93.86 209.5,94.48 211.82,94.48 211.99,94.66
  L6 w0.102: v3(256.16,140.48) 256.21,140.48 257.22,139.47 257.22,135.57 255.83,134.18 255.83,122.4 245.98,112.55 245.98,111.79 245.22,111.04 244.47,111.04 239.73,106.3 231.48,106.3 229.65,104.47 229.37,104.47 229.27,104.58 229.27,104.82 229.16,104.93 229,104.93 228.9,104.82 228.9,104.58 228.79,104.47 227.53,104.47 219.02,95.96 214.97,95.96 214.76,96.17 214.32,96.17 213.51,96.17 211.99,94.66
  BOTTOM w0.076: v2(207.54,90.48) 207.42,90.48 207.1,90.15 U4555.AK55
  BOTTOM w0.114: v3(256.16,140.48) 256.1,140.55 CN4100.24
M_A_DQ<30>: length 83.5
  L6 w0.102: v2(206.55,93.7) 206.53,93.71 206.53,94.15 208.69,96.31 209.93,96.31 212.01,98.38 217.53,98.38 220.9,101.76 220.9,102.58 226.34,108.01 229.7,108.01 230.38,108.7 237.5,108.7 239.63,110.83 240.25,110.83 242.16,112.74 242.45,112.74 244.18,114.46 244.18,115.13 245.85,116.8 246.52,116.8 247.41,117.69 247.41,117.85 247.2,118.06 247.2,118.21 247.31,118.32 247.46,118.32 247.67,118.11 247.82,118.11 247.93,118.22 247.93,118.37 247.72,118.58 247.72,118.73 247.83,118.84 247.98,118.84 248.19,118.63 248.35,118.63 248.45,118.74 248.45,118.89 248.23,119.12 248.23,119.27 248.33,119.38 248.49,119.38 248.71,119.15 248.87,119.15 253.48,123.76 253.48,139.1 253.66,139.28 253.66,140.21 253.11,140.75 v3(252.52,140.75)
  BOTTOM w0.114: v2(206.55,93.7) 206.44,93.7 206.37,93.62 U4555.AR54 ; CN4100.34 253.1,141.33 v3(252.52,140.75)
M_A_DQ<31>: length 84.9
  L6 w0.102: v2(206.64,92.45) 206.14,92.95 206.14,95.08 207.48,96.43 208.52,96.43 208.61,96.51 209.83,96.51 212.07,98.76 217.4,98.76 220.55,101.91 220.55,102.72 226.19,108.37 229.55,108.37 230.24,109.05 237.35,109.05 239.48,111.18 240.1,111.18 242.78,113.86 242.78,114.37 246.96,118.56 246.96,119.35 251.45,123.84 252.12,123.84 253.12,124.84 253.12,139.25 253.13,139.25 253.3,139.42 253.3,140.08 253.2,140.18 252.96,140.18 252.86,140.07 252.86,139.61 252.63,139.39 v3(252.37,139.39)
  BOTTOM w0.114: U4555.AN54 206.15,92.1 206.49,92.45 v2(206.64,92.45) ; CN4100.36 252.5,141.35 251.82,140.67 251.82,139.67 252.1,139.39 v3(252.37,139.39)
M_A_DQ<32>: length 53.2
  L3 w0.102: v2(209.64,97.48) 209.64,98.26 211.65,100.27 211.65,101.18 215.32,104.85 215.32,119.79 211.84,123.26 211.84,125.81 211.84,125.81 211.84,125.95 211.95,126.05 212.13,126.05 212.24,126.16 212.24,126.3 212.13,126.41 211.95,126.41 211.84,126.51 211.84,126.66 211.95,126.76 212.2,126.76 212.31,126.87 212.31,127.01 212.2,127.12 211.95,127.12 211.84,127.22 211.84,127.37 211.95,127.47 212.2,127.47 212.31,127.58 212.31,127.72 212.2,127.83 211.95,127.83 211.84,127.93 211.84,128.08 211.95,128.18 212.2,128.18 212.31,128.29 212.31,128.44 212.2,128.54 211.95,128.54 211.84,128.64 211.84,128.79 211.95,128.9 212.2,128.9 212.31,129 212.31,129.15 212.2,129.25 211.95,129.25 211.84,129.36 211.84,129.5 211.95,129.61 212.2,129.61 212.31,129.71 212.31,129.86 212.2,129.96 211.95,129.96 211.84,130.07 211.84,130.21 211.95,130.32 212.2,130.32 212.31,130.42 212.31,130.57 212.2,130.67 211.95,130.67 211.84,130.78 211.84,130.93 211.95,131.03 212.2,131.03 212.31,131.13 212.31,131.28 212.2,131.39 211.95,131.39 211.84,131.49 211.84,131.64 211.95,131.74 212.2,131.74 212.31,131.84 212.31,131.99 212.2,132.1 211.95,132.1 211.84,132.2 211.84,133.5 211.95,133.6 212.2,133.6 212.31,133.7 212.31,133.85 212.2,133.95 211.95,133.95 211.84,134.06 211.84,134.21 211.95,134.31 212.2,134.31 212.31,134.41 212.31,134.56 212.2,134.67 211.95,134.67 211.84,134.77 211.84,134.92 211.95,135.02 212.23,135.02 212.33,135.12 212.33,135.28 212.23,135.38 211.95,135.38 211.84,135.48 211.84,135.73 v3(212,135.88)
  BOTTOM w0.076: v2(209.64,97.48) 209.64,97.42 208.97,96.76 208.97,96.52 U4555.AY58
  BOTTOM w0.114: CN4100.163 v3(212,135.88)
M_A_DQ<33>: length 54.1
  L3 w0.102: v3(212.03,137.35) 212.3,137.63 212.3,138.25 212.41,138.35 212.58,138.35 212.69,138.25 212.69,125.85 212.58,125.75 212.38,125.75 212.27,125.64 212.27,125.49 212.38,125.39 212.58,125.39 212.69,125.29 212.69,125.14 212.58,125.03 212.31,125.03 212.21,124.93 212.21,124.78 212.31,124.68 212.58,124.68 212.69,124.58 212.69,124.43 212.58,124.32 212.31,124.32 212.21,124.22 212.21,124.07 212.31,123.97 212.58,123.97 212.69,123.86 212.69,123.72 212.58,123.61 212.36,123.61 212.26,123.51 212.26,123.36 212.36,123.26 212.58,123.26 212.69,123.15 212.69,122.92 215.67,119.94 215.67,104.7 211.94,100.97 211.94,100.06 211.29,99.41 211.06,99.41 210.06,98.41 v2(210.06,98.02)
  BOTTOM w0.076: v2(210.06,98.02) 210.06,97.31 209.82,97.07 209.52,97.07 209.38,96.93 209.28,96.83 209.28,96.17 208.97,95.87 U4555.AW58
  BOTTOM w0.114: v3(212.03,137.35) 211.4,136.72 CN4100.165
M_A_DQ<34>: length 54
  L3 w0.102: v3(208.26,140.86) 208.33,140.86 208.83,140.37 208.83,136.88 209.9,135.8 209.9,128.17 209.8,128.07 209.36,128.07 209.25,127.97 209.25,127.82 209.36,127.71 209.8,127.71 209.9,127.61 209.9,127.46 209.8,127.36 209.36,127.36 209.25,127.25 209.25,127.11 209.36,127 209.8,127 209.9,126.9 209.9,122.47 213.73,118.64 213.73,105.51 210.25,102.03 210.25,101.48 209.48,100.71 v2(208.9,100.71)
  BOTTOM w0.076: v2(208.9,100.71) 208.52,100.71 207.86,100.05 207.86,98.35 207.78,98.27 207.78,98.03 207.38,97.63 207.38,97.23 207.5,97.11 207.5,96.64 207.62,96.52 U4555.AY56
  BOTTOM w0.114: CN4100.176 208.1,141.02 v3(208.26,140.86)
M_A_DQ<35>: length 54.8
  L3 w0.076: v2(209.21,102) 209.21,102
  L3 w0.102: 209.21,102 213.02,105.8 213.02,118.34 208.12,123.24 208.12,133.36 208.23,133.46 208.84,133.46 208.94,133.57 208.94,133.71 208.84,133.82 208.15,133.82 208.05,133.92 208.05,134.07 208.15,134.17 208.83,134.17 208.93,134.27 208.93,134.43 208.83,134.53 208.14,134.53 208.03,134.63 208.03,134.78 208.14,134.88 208.83,134.88 208.93,134.99 208.93,135.14 208.83,135.24 208.23,135.24 207.75,135.71 207.75,137.09 v3(208.24,137.57)
  BOTTOM w0.076: U4555.AW56 207.62,95.87 207.62,96.1 207.33,96.39 207.33,97.05 207.21,97.16 207.21,97.7 207.61,98.1 207.61,98.37 207.7,98.45 207.7,99.85 207.7,100.12 208.72,101.14 208.94,101.14 209.21,101.41 v2(209.21,102)
  BOTTOM w0.114: CN4100.175 208.4,135.67 208.65,135.92 208.65,137.17 v3(208.24,137.57)
M_A_DQ<36>: length 54.6
  L3 w0.102: 211.23,98.85 212.37,99.99 212.37,100.63 216.03,104.29 216.03,120.08 213.04,123.07 213.04,138.56 212.37,139.23 212.37,139.47 212.27,139.57 212.04,139.57 211.93,139.47 211.93,138.86 v3(212.02,138.77)
  L3 w0.114: v2(211.09,98.85) 211.23,98.85
  BOTTOM w0.076: U4555.AV58 208.97,95.22 208.97,95.37 208.98,95.39 208.98,95.41 209.76,96.19 210.42,96.19 210.61,96.38 210.61,96.77
  BOTTOM w0.114: CN4100.164 211.7,139.09 v3(212.02,138.77) ; v2(211.09,98.85) 211.15,98.78 211.15,97.3 210.61,96.77
M_A_DQ<37>: length 55.5
  L3 w0.102: v2(208.16,97.9) 208.97,97.9 211.42,100.34 211.42,101.45 214.96,105 214.96,119.64 211.49,123.12 211.49,139.55 210.97,140.06 v3(210,140.06)
  BOTTOM w0.076: U4555.AU58 208.18,94.56 208.01,94.74 208.01,94.77 208.01,95.01 208.02,95.03 208.02,95.4 207.99,95.44 207.99,95.57 208.01,95.62 208.06,95.71 208.08,95.76 208.08,95.97 208.01,96.13 208.01,96.26 208.06,96.36 208.06,96.36 208.08,96.41 208.08,97.2 208.14,97.26 208.14,97.88 v2(208.16,97.9)
  BOTTOM w0.114: CN4100.166 211.1,141.17 v3(210,140.06)
M_A_DQ<38>: length 55.4
  L3 w0.076: 209.39,102.84 208.14,101.59 208.14,98.47 207.76,98.09 v2(207.76,97.42)
  L3 w0.102: v3(208.2,139.41) 207.83,139.78 207.83,140.07 207.7,140.2 207.52,140.2 207.4,140.07 207.4,139.18 207.5,139.08 207.72,139.08 207.82,138.98 207.82,138.83 207.72,138.72 207.5,138.72 207.4,138.62 207.4,138.47 207.5,138.37 207.72,138.37 207.82,138.26 207.82,138.12 207.72,138.01 207.5,138.01 207.4,137.91 207.4,133.16 207.77,132.79 207.77,123.09 212.67,118.19 212.67,105.95 209.56,102.84 209.39,102.84
  BOTTOM w0.076: U4555.AV56 207.73,95.22 207.73,95.56 207.87,95.7 207.89,95.75 207.91,95.8 207.91,95.93 207.91,95.95 207.87,96.04 207.84,96.09 207.84,96.32 207.87,96.35 207.91,96.45 207.91,97.26 v2(207.76,97.42)
  BOTTOM w0.114: v3(208.2,139.41) 208.7,139.91 CN4100.174
M_A_DQ<39>: length 56.4
  L3 w0.102: v3(208.18,136.08) 208.94,136.08 209.54,135.47 209.54,132.5 208.49,131.44 208.49,131.19 208.59,131.08 209.29,131.08 209.39,130.98 209.39,130.83 209.29,130.73 208.59,130.73 208.49,130.62 208.49,130.48 208.59,130.37 209.29,130.37 209.39,130.27 209.39,130.12 209.29,130.02 208.59,130.02 208.49,129.91 208.49,129.76 208.59,129.66 209.29,129.66 209.39,129.56 209.39,129.41 209.29,129.3 208.59,129.3 208.49,129.2 208.49,129.05 208.59,128.95 209.25,128.95 209.35,128.84 209.35,128.7 209.25,128.59 208.59,128.59 208.49,128.49 208.49,123.38 213.38,118.49 213.38,105.66 209.88,102.16 209.88,102 209.43,101.55 v2(208.77,101.55)
  BOTTOM w0.076: U4555.AU56 207.73,94.57 207.43,94.87 207.43,95.63 207.17,95.9 207.17,96.98 207.04,97.11 207.04,97.75 207.45,98.17 207.45,98.44 207.53,98.52 207.53,100.18 208.77,101.43 v2(208.77,101.55)
  BOTTOM w0.114: v3(208.18,136.08) 207.8,135.69 CN4100.177
