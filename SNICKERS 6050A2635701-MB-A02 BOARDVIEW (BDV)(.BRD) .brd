# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_BS0: length 98.1
  L3 w0.076: v2(194.68,91.15) 194.68,91.15 195.04,91.52 195.04,94.06 194.57,94.53 194.57,101.47 194.8,101.69
  L3 w0.165: 194.8,101.69 195.34,102.24 195.34,110.7 179.27,126.77 154.09,126.77 153.35,127.51 153.12,127.51 152.77,127.16 152.55,127.16 152.39,127.32 152.39,127.55 152.73,127.9 152.73,128.12 152.57,128.28 152.35,128.28 152,127.93 151.78,127.93 151.62,128.1 151.62,128.32 151.96,128.67 151.96,128.89 151.81,129.05 151.81,129.26 151.98,129.43 152.19,129.43 154.27,127.35 154.49,127.35 154.66,127.52 154.66,127.74 152.3,130.1 151.34,130.1 151.18,129.95 151.18,129.16 151.03,129.01 150.78,129.01 150.62,129.16 150.62,130.1 150.25,130.48 149.48,131.25 149.48,135.5 150.02,136.04 150.02,136.68 v3(149.69,137.02)
  BOTTOM w0.076: v2(194.68,91.15) 194.61,91.15 194.26,90.8 U4555.AL35
  BOTTOM w0.178: v3(149.69,137.02) 149.7,137.02 150.19,137.51 150.87,137.51 151.2,137.18 CN4125.109
M_B_BS1: length 98.3
  L3 w0.076: 195.54,101.46 194.99,100.91 194.99,94.81 195.7,94.1 195.7,93.83 196.05,93.48 196.05,91.81 v2(195.66,91.42)
  L3 w0.165: 195.54,101.46 196.41,102.33 196.41,111.14 179.71,127.84 157.62,127.84 154.14,131.31 152.23,131.31 151.37,132.17 151.37,132.63 150.83,133.18 150.83,135.34 151.09,135.6 151.09,138.4 150.62,138.87 150.62,139.8 152.61,141.78 152.61,143.73 152.44,143.9 152.19,143.9 152.02,143.73 152.02,142.04 150.44,140.45 150.42,140.45 149.99,140.02 v3(149.99,139.3)
  BOTTOM w0.076: U4555.AM36 195.62,91.45 v2(195.66,91.42)
  BOTTOM w0.178: v3(149.99,139.3) 150.26,139.3 151.5,140.54 CN4125.108
M_B_BS2: length 93.4
  L3 w0.076: 205.03,105.62 205.03,105.49 202.77,103.23 202.77,102.27 202.27,101.76 202.27,96.09 v2(203.42,94.94)
  L3 w0.165: 205.03,105.62 205.03,114.71 195.66,124.08 195.66,127.31 185.9,137.07 185.9,140.89 185.9,141.33 185.05,142.18 166.05,142.18 165.21,141.33 165.21,139.82 163.79,138.4 163.65,138.4 163.41,138.64 163.41,138.78 164.59,139.96 164.59,140.1 164.35,140.33 164.21,140.33 162.84,138.97 162.84,138.18 163.14,137.88 163.14,137.66 162.99,137.5 162.77,137.5 162.47,137.8 161.8,137.8 v3(161.58,137.59)
  BOTTOM w0.076: U4555.AU49 202.96,94.57 203.33,94.94 v2(203.42,94.94)
  BOTTOM w0.178: v3(161.58,137.59) 161.09,137.09 161.09,136.37 160.2,135.47 CN4125.79
M_B_CAS#: length 97.7
  L3 w0.076: 193.38,102.13 193.32,102.08 193.32,92.1 v2(193.7,91.72)
  L3 w0.165: 193.38,102.13 193.59,102.35 193.59,110.18 178.6,125.17 152.26,125.17 151.95,125.48 148.39,129.04 148.16,129.04 148,128.88 148,128.66 151.1,125.56 151.1,125.34 150.93,125.17 150.72,125.17 147.45,128.44 147.45,133.08 147.88,133.51 147.88,137.47 147.19,138.16 v3(147.19,138.16)
  BOTTOM w0.076: v2(193.7,91.72) 193.52,91.72 193.26,91.45 U4555.AM33
  BOTTOM w0.178: v3(147.19,138.16) 147.32,138.16 148.49,136.99 148.49,136.6 149.4,135.69 CN4125.115
M_B_DQ<0>: length 87.9
  L3 w0.076: v2(192.16,101.67) 191.62,102.22 191.62,104.35 191.62,105.37 190.37,106.63
  L3 w0.102: 190.37,106.63 190.35,106.64 190.35,108.75 177.03,122.08 146.23,122.08 144.19,124.11 144.19,125.08 144.09,125.19 143.81,125.19 143.71,125.29 143.71,125.44 143.81,125.54 144.09,125.54 144.19,125.65 144.19,125.79 144.09,125.9 143.81,125.9 143.71,126 143.71,133.92 143.61,134.02 143.41,134.02 143.31,134.13 143.31,134.28 143.41,134.38 143.61,134.38 143.71,134.48 143.71,134.63 143.61,134.74 143.4,134.74 143.3,134.84 143.3,134.99 143.4,135.09 143.76,135.09 143.86,135.19 143.86,135.35 143.76,135.45 143.34,135.45 143.25,135.54 143.25,135.73 143.81,136.29 143.81,137.57 144.01,137.77 v3(144.36,137.77)
  BOTTOM w0.076: U4555.AY31 192.31,96.52 192.4,96.52 192.44,96.56 192.44,96.56 193.22,97.34 193.22,100.62 v2(192.16,101.67)
  BOTTOM w0.114: v3(144.36,137.77) 144.88,137.77 145.48,137.16 145.48,135.81 145.2,135.53 CN4125.129
M_B_DQ<1>: length 88.8
  L3 w0.076: 190.75,106.63 191.78,105.59 191.78,104.88 191.78,104.51 191.78,102.72 v2(192.16,102.34)
  L3 w0.102: 190.75,106.63 190.75,108.86 177.17,122.43 146.49,122.43 144.56,124.36 144.56,126.19 144.46,126.3 144.18,126.3 144.08,126.4 144.08,126.55 144.18,126.65 144.46,126.65 144.56,126.76 144.56,126.95 144.46,127.06 144.17,127.06 144.07,127.16 144.07,127.31 144.17,127.41 144.46,127.41 144.56,127.52 144.56,127.67 144.46,127.77 144.17,127.77 144.07,127.87 144.07,128.02 144.17,128.13 144.46,128.13 144.56,128.23 144.56,128.38 144.46,128.48 144.17,128.48 144.07,128.58 144.07,128.74 144.17,128.84 144.46,128.84 144.56,128.94 144.56,129.09 144.46,129.19 144.17,129.19 144.07,129.29 144.07,129.45 144.17,129.55 144.46,129.55 144.56,129.65 144.56,129.8 144.46,129.9 144.17,129.9 144.07,130.01 144.07,130.16 144.17,130.26 144.46,130.26 144.56,130.36 144.56,130.51 144.46,130.61 144.17,130.61 144.07,130.72 144.07,130.87 144.17,130.97 144.46,130.97 144.56,131.07 144.56,131.22 144.46,131.33 144.17,131.33 144.07,131.43 144.07,131.58 144.17,131.68 144.46,131.68 144.56,131.78 144.56,131.94 144.46,132.04 144.28,132.04 144.07,132.25 144.07,133.32 144.17,133.42 144.49,133.42 144.57,133.51 144.57,133.69 144.49,133.78 144.17,133.78 144.07,133.88 144.07,134.03 144.17,134.13 144.46,134.13 144.56,134.23 144.56,134.39 144.46,134.49 144.15,134.49 144.07,134.57 144.07,134.76 144.15,134.84 144.4,134.84 144.5,134.95 144.5,135.96 v3(144.44,136.03)
  BOTTOM w0.076: v2(192.16,102.34) 193.38,101.13 193.38,97.27 192.6,96.49 192.6,96.44 192.51,96.27 192.51,96.07 192.31,95.87 U4555.AW31
  BOTTOM w0.114: CN4125.131 144.6,135.87 v3(144.44,136.03)
M_B_DQ<2>: length 88.2
  L3 w0.076: v2(190.66,103.36) 190.62,103.4 190.28,103.74 190.28,104.63 188.32,106.59 188.32,106.63
  L3 w0.102: 188.32,106.63 188.32,108.03 176.22,120.14 145.42,120.14 141.77,123.79 141.77,131.86 141.31,132.32 141.31,138.95 141.15,139.11 139.84,139.11 139.74,139.21 139.74,139.54 139.86,139.66 v3(140.9,139.66)
  BOTTOM w0.076: U4555.AY29 190.96,96.52 190.96,97.58 191.45,98.06 191.45,102.6 190.69,103.36 v2(190.66,103.36)
  BOTTOM w0.114: CN4125.140 141.9,140.66 v3(140.9,139.66)
M_B_DQ<3>: length 89.1
  L3 w0.076: v2(190.66,102.11) 190.26,102.51 190.26,103.52 190.11,103.67 190.11,104.56 188.41,106.27 188.32,106.27 187.97,106.63
  L3 w0.102: v3(140.87,136.09) 140.95,136.02 140.95,132.17 140.7,131.92 140.7,128.29 140.8,128.19 140.95,128.19 141.06,128.29 141.06,131.69 141.16,131.79 141.31,131.79 141.41,131.69 141.41,123.64 145.27,119.78 176.04,119.78 187.97,107.85 187.97,106.63
  BOTTOM w0.076: U4555.AW29 190.96,95.87 190.96,96.1 190.67,96.39 190.67,96.84 190.8,96.97 190.8,97.65 191.28,98.13 191.28,101.64 190.81,102.11 v2(190.66,102.11)
  BOTTOM w0.114: CN4125.143 141,135.97 v3(140.87,136.09)
M_B_DQ<4>: length 89.3
  L3 w0.102: v3(144.16,139.3) 144.24,139.3 144.37,139.42 144.37,139.43 144.92,139.97 145.06,139.97 145.27,139.77 145.27,139.62 144.81,139.17 144.81,136.41 144.93,136.3 144.93,124.5 146.64,122.79 177.32,122.79 191.14,108.97 191.14,106.64 192.56,105.22 192.56,103.57 192.49,103.5 v2(192.16,103.5)
  BOTTOM w0.076: v2(192.16,103.5) 192.72,102.95 192.72,102.37 193.55,101.53 193.55,100.53 193.55,100.52 193.55,97.18 192.77,96.4 192.7,96.26 192.7,95.6 192.31,95.22 U4555.AV31
  BOTTOM w0.114: CN4125.130 144.9,139.71 144.49,139.3 v3(144.16,139.3)
M_B_DQ<5>: length 90.1
  L3 w0.076: v2(192.16,100.35) 191.45,101.05 191.45,105.08 189.91,106.63
  L3 w0.102: 189.91,106.63 189.91,108.69 176.88,121.72 146.08,121.72 143.35,124.45 143.35,124.74 143.35,133.3 143.08,133.58 142.89,133.76 142.89,135.96 143.46,136.52 143.46,139.86 143.36,139.96 142.75,139.96 142.65,140.06 142.65,140.22 142.75,140.32 143.69,140.32 v3(144.21,140.84)
  BOTTOM w0.076: U4555.AU31 191.52,94.56 191.34,94.74 191.34,94.77 191.34,95.01 191.36,95.03 191.36,95.4 191.34,95.42 191.34,95.6 191.35,95.62 191.39,95.71 191.39,95.71 191.42,95.76 191.42,95.97 191.34,96.13 191.34,96.26 191.39,96.36 191.42,96.41 191.42,96.91 191.31,97.01 191.31,97.46 191.78,97.93 191.78,99.99 192.13,100.35 v2(192.16,100.35)
  BOTTOM w0.114: v3(144.21,140.84) 144.21,140.93 144.3,141.02 CN4125.132
M_B_DQ<6>: length 89.4
  L3 w0.076: 188.68,106.63 188.68,106.51 190.54,104.65 v2(190.66,104.65)
  L3 w0.102: v3(140.9,141.08) 140.9,141.93 141.01,142.03 141.56,142.03 141.66,141.93 141.66,132.47 142.12,132 142.12,123.94 145.57,120.49 176.37,120.49 188.68,108.18 188.68,106.63
  BOTTOM w0.076: U4555.AV29 191.07,95.22 191.07,95.56 191.2,95.7 191.25,95.8 191.25,95.93 191.24,95.95 191.2,96.04 191.18,96.09 191.18,96.29 191.25,96.45 191.25,96.84 191.15,96.94 191.15,97.48 191.15,97.48 191.15,97.53 191.61,98 191.61,103.7 v2(190.66,104.65)
  BOTTOM w0.114: v3(140.9,141.08) 141.3,141.48 CN4125.142
M_B_DQ<7>: length 90.2
  L3 w0.076: 187.61,106.63 187.61,106.6 188.11,106.11 188.32,106.11 189.95,104.48 189.95,103.6 190.1,103.45 190.1,101.99 190.37,101.72 v2(190.66,101.43)
  L3 w0.102: 187.61,106.63 187.61,107.7 175.89,119.43 145.13,119.43 141.06,123.5 141.06,127.5 140.95,127.6 140.8,127.6 140.7,127.5 140.7,126.04 140.6,125.93 140.45,125.93 140.34,126.04 140.34,132.19 140.03,132.5 140.03,132.94 140.34,133.26 140.34,137.03 v3(140.82,137.51)
  BOTTOM w0.076: U4555.AU29 191.07,94.57 190.77,94.86 190.77,95.34 190.79,95.36 190.79,95.62 190.67,95.74 190.67,96.16 190.5,96.33 190.5,96.91 190.57,96.98 190.57,97.66 191.12,98.2 191.12,100.97 v2(190.66,101.43)
  BOTTOM w0.114: v3(140.82,137.51) 140.82,137.47 141.6,136.69 CN4125.141
M_B_DQ<8>: length 54
  L6 w0.102: v2(190.66,100.16) 190.88,100.16 191.14,100.42 191.14,104.84 189.69,106.29 189.69,110.78 183.18,117.28 183.18,130.73 184.93,132.48 184.93,136.05 184.83,136.15 184.66,136.15 184.56,136.05 184.56,133.44 184.45,133.34 184.3,133.34 184.19,133.44 184.19,136.51 184.42,136.74 v3(184.77,136.74)
  BOTTOM w0.076: v2(190.66,100.16) 190.67,100.16 190.08,99.56 190.08,97.27 189.88,97.07 189.88,96.52 U4555.AY27
  BOTTOM w0.114: CN4125.5 184.8,136.71 v3(184.77,136.74)
M_B_DQ<9>: length 54.8
  L6 w0.102: v3(184.75,139.61) 185.28,139.07 185.28,132.32 183.54,130.58 183.54,130.26 183.64,130.15 183.9,130.15 184.01,130.04 184.01,129.89 183.9,129.78 183.64,129.78 183.54,129.67 183.54,129.52 183.64,129.41 183.88,129.41 183.99,129.3 183.99,129.15 183.88,129.04 183.64,129.04 183.54,128.94 183.54,128.78 183.64,128.68 183.88,128.68 183.99,128.57 183.99,128.42 183.88,128.31 183.64,128.31 183.54,128.2 183.54,128.05 183.64,127.94 183.81,127.94 183.91,127.84 183.91,127.67 183.81,127.57 183.64,127.57 183.54,127.46 183.54,117.43 190.04,110.92 190.04,106.34 191.45,104.94 191.45,100.04 190.99,99.57 v2(190.66,99.57)
  BOTTOM w0.076: U4555.AW27 189.88,95.87 190.17,96.16 190.17,97.04 190.17,97.05 190.24,97.12 190.24,99.15 190.67,99.57 v2(190.66,99.57)
  BOTTOM w0.114: v3(184.75,139.61) 184.23,140.12 184.23,141.09 184.5,141.36 CN4125.6
M_B_DQ<10>: length 54.1
  L6 w0.076: v2(189.07,101.88) 189.66,102.46 189.66,104.57 188.05,106.17 188.05,106.41
  L6 w0.102: v3(182.28,136.86) 182.18,136.76 182.18,136.14 182.29,136.04 182.42,136.04 182.53,135.93 182.53,135.77 182.42,135.67 182.29,135.67 182.18,135.56 182.18,135.41 182.29,135.3 182.41,135.3 182.51,135.19 182.51,135.04 182.41,134.93 182.29,134.93 182.18,134.82 182.18,134.67 182.29,134.56 182.32,134.56 182.42,134.46 182.42,134.3 182.32,134.19 182.29,134.19 182.18,134.09 182.18,132.22 181.49,131.53 181.49,123.02 181,122.53 181,122.37 181.1,122.26 181.39,122.26 181.5,122.16 181.5,122 181.39,121.9 181.1,121.9 181,121.79 181,121.64 181.1,121.53 181.39,121.53 181.5,121.42 181.5,121.27 181.39,121.16 181.1,121.16 181,121.05 181,120.9 181.1,120.79 181.39,120.79 181.5,120.68 181.5,120.53 181.39,120.42 181.1,120.42 181,120.31 181,120.16 181.1,120.05 181.39,120.05 181.5,119.95 181.5,119.79 181.39,119.69 181.1,119.69 181,119.58 181,119.43 181.1,119.32 181.39,119.32 181.5,119.21 181.5,119.06 181.39,118.95 181.1,118.95 181,118.84 181,118.69 181.1,118.58 181.39,118.58 181.5,118.47 181.5,118.32 181.39,118.21 181.1,118.21 181,118.11 181,117.95 181.1,117.84 181.39,117.84 181.5,117.74 181.5,117.58 181.39,117.48 181.1,117.48 181,117.37 181,117.15 188.05,110.1 188.05,106.41
  BOTTOM w0.076: v2(189.07,101.88) 188.84,101.65 188.84,98.65 188.56,98.37 188.56,96.55 188.53,96.52 U4555.AY25
  BOTTOM w0.114: CN4125.15 181.8,136.38 v3(182.28,136.86)
M_B_DQ<11>: length 54.8
  L6 w0.076: 187.69,106.33 187.69,106.1 189.49,104.3 189.49,102.93 v2(189.07,102.51)
  L6 w0.102: 187.69,106.33 187.69,109.95 180.64,117 180.64,122.94 180.75,123.05 181.01,123.05 181.11,123.16 181.11,123.31 181.01,123.42 180.75,123.42 180.64,123.53 180.64,123.68 180.75,123.79 181.03,123.79 181.13,123.9 181.13,124.05 181.03,124.16 180.75,124.16 180.64,124.26 180.64,124.42 180.75,124.52 181.03,124.52 181.13,124.63 181.13,124.78 181.03,124.89 180.75,124.89 180.64,125 180.64,125.15 180.75,125.26 180.9,125.26 181,125.36 181,125.53 180.9,125.63 180.75,125.63 180.64,125.74 180.64,125.99 181.05,126.41 181.05,131.68 181.83,132.45 181.83,138.04 v3(182.13,138.35)
  BOTTOM w0.076: v2(189.07,102.51) 188.68,102.11 188.68,98.72 188.4,98.44 188.4,97.02 188.24,96.86 188.24,96.45 188.28,96.35 188.29,96.35 188.31,96.29 188.31,96.08 188.53,95.87 U4555.AW25
  BOTTOM w0.114: CN4125.17 181.2,138.03 181.51,138.35 v3(182.13,138.35)
M_B_DQ<12>: length 55.1
  L6 w0.102: v3(184.79,141.03) 185.03,141.03 185.64,140.42 185.64,132.18 184.37,130.91 184.37,126.55 184.26,126.45 184.08,126.45 183.97,126.34 183.97,126.18 184.08,126.08 184.26,126.08 184.37,125.97 184.37,125.82 184.26,125.71 184.03,125.71 183.93,125.61 183.93,125.44 184.03,125.34 184.26,125.34 184.37,125.23 184.37,125.08 184.26,124.97 184,124.97 183.89,124.87 183.89,124.71 184,124.6 184.26,124.6 184.37,124.5 184.37,124.34 184.26,124.24 184,124.24 183.89,124.13 183.89,117.58 190.4,111.07 190.4,106.44 191.73,105.12 191.73,99.2 190.93,98.41 v2(190.66,98.41)
  BOTTOM w0.076: v2(190.66,98.41) 190.67,98.39 190.67,98.08 190.41,97.82 190.41,97.05 190.34,96.98 190.34,96.97 190.34,95.91 189.99,95.56 189.99,95.43 189.77,95.22 U4555.AV27
  BOTTOM w0.114: CN4125.4 185.1,141.34 v3(184.79,141.03)
M_B_DQ<13>: length 55.9
  L6 w0.076: 186.98,106.51 186.98,106.3 188.69,104.59 188.69,98.75 v2(189.22,98.22)
  L6 w0.102: 186.98,106.51 186.98,109.66 179.83,116.81 179.83,129.82 179.94,129.93 180.2,129.93 180.3,130.04 180.3,130.19 180.2,130.3 179.94,130.3 179.83,130.41 179.83,130.56 179.94,130.67 180.2,130.67 180.3,130.78 180.3,130.93 180.2,131.04 179.94,131.04 179.83,131.14 179.83,131.46 181.11,132.74 181.11,138.99 180.62,139.49 v3(180.3,139.49)
  BOTTOM w0.076: U4555.AU27 189.12,94.56 189.09,94.6 189.08,94.6 188.91,94.77 188.91,94.77 188.89,94.79 188.89,95.56 188.92,95.62 188.96,95.71 188.96,95.71 188.99,95.76 188.99,95.97 188.91,96.13 188.91,96.26 188.99,96.41 188.99,96.91 188.91,96.99 188.91,97.9 v2(189.22,98.22)
  BOTTOM w0.114: v3(180.3,139.49) 181.5,140.7 CN4125.16
M_B_DQ<14>: length 55.3
  L6 w0.076: v2(189.22,98.8) 189.76,98.8 190.11,99.14 190.11,100.91 190.28,101.09 190.28,104.99 189.33,105.93 189.33,106.08
  L6 w0.102: v3(184.75,138.19) 184.3,138.64 184.3,139.47 184.2,139.57 183.94,139.57 183.84,139.47 183.84,133.12 184.15,132.81 184.15,132.2 182.8,130.85 182.8,117.17 189.33,110.63 189.33,106.08
  BOTTOM w0.076: U4555.AV25 188.53,95.22 188.53,95.45 188.77,95.7 188.82,95.8 188.82,95.93 188.81,95.95 188.77,96.04 188.75,96.09 188.75,96.29 188.82,96.45 188.82,96.84 188.73,96.93 188.73,98.31 v2(189.22,98.8)
  BOTTOM w0.114: v3(184.75,138.19) 184.2,137.63 CN4125.7
M_B_DQ<15>: length 56.2
  L6 w0.076: 187.34,106.46 187.34,106.2 189.07,104.47 v2(189.07,103.77)
  L6 w0.102: 187.34,106.46 187.34,109.81 180.19,116.95 180.19,126.32 180.3,126.43 180.43,126.43 180.53,126.53 180.53,126.7 180.43,126.8 180.3,126.8 180.19,126.91 180.19,127.06 180.3,127.17 180.55,127.17 180.65,127.28 180.65,127.43 180.55,127.54 180.3,127.54 180.19,127.64 180.19,127.8 180.3,127.9 180.55,127.9 180.65,128.01 180.65,128.16 180.55,128.27 180.3,128.27 180.19,128.38 180.19,128.53 180.3,128.64 180.55,128.64 180.65,128.75 180.65,128.9 180.55,129.01 180.3,129.01 180.19,129.12 180.19,129.33 180.7,129.84 180.7,131.83 181.47,132.6 181.47,139.25 180.53,140.18 v2(180.36,140.18)
  BOTTOM w0.076: U4555.AU25 188.53,94.57 188.15,94.95 188.15,96.26 188.1,96.36 188.1,96.36 188.07,96.41 188.07,96.92 188.23,97.09 188.23,98.51 188.51,98.79 188.51,103.21 v2(189.07,103.77)
  BOTTOM w0.114: CN4125.18 180.9,140.72 v2(180.36,140.18)
M_B_DQ<16>: length 95.3
  L3 w0.076: 186.75,107.03 186.75,106.92 187.89,105.78 188.18,105.78 189.62,104.33 189.62,103.47 189.77,103.32 189.77,101.85 190.04,101.59 190.04,97.81 191.84,96.01 191.84,92.33 v2(191.29,91.78)
  L3 w0.102: 186.75,107.03 186.75,107.35 186,108.09 186,108.09 175.53,118.56 144.7,118.56 139.48,123.78 139.48,131.83 139.11,132.2 139.11,133.74 139.21,133.84 139.35,133.84 139.45,133.95 139.45,134.09 139.35,134.2 139.21,134.2 139.11,134.3 139.11,134.53 139.21,134.63 139.37,134.63 139.48,134.74 139.48,134.89 139.37,134.99 139.21,134.99 139.11,135.09 139.11,135.24 139.21,135.34 139.37,135.34 139.48,135.45 139.48,135.6 139.37,135.7 139.21,135.7 139.11,135.8 139.11,135.95 139.21,136.06 139.37,136.06 139.48,136.16 139.48,136.31 139.37,136.41 139.21,136.41 139.11,136.52 139.11,136.66 139.21,136.77 139.37,136.77 139.48,136.87 139.48,137.02 139.37,137.12 139.21,137.12 139.11,137.23 139.11,137.37 139.21,137.48 139.37,137.48 139.48,137.58 139.48,137.73 139.37,137.83 139.21,137.83 139.11,137.94 139.11,140.56 139.21,140.67 v3(139.6,140.67)
  BOTTOM w0.076: v2(191.29,91.78) 191.22,91.78 190.9,91.45 U4555.AM29
  BOTTOM w0.114: CN4125.146 140.1,141.17 v3(139.6,140.67)
M_B_DQ<17>: length 96.9
  L3 w0.076: v2(191.29,90.48) 192,91.19 192,96.08 190.2,97.88 190.2,101.65 189.93,101.92 189.93,103.38 189.78,103.53 189.78,104.4 188.25,105.94 188.04,105.94 187.1,106.88 187.1,107.03
  L3 w0.102: 187.1,107.03 187.1,107.49 175.68,118.92 144.85,118.92 140.55,123.22 140.55,125.33 140.46,125.43 140.28,125.43 140.19,125.33 140.19,124.25 140.09,124.15 139.94,124.15 139.84,124.25 139.84,125.83 139.84,131.97 139.52,132.29 139.52,133.15 139.84,133.47 139.84,137.6 139.94,137.71 140.11,137.71 140.21,137.81 140.21,137.96 140.11,138.06 139.94,138.06 139.84,138.17 139.84,138.32 v3(139.55,138.6)
  BOTTOM w0.076: v2(191.29,90.48) 191.17,90.48 190.85,90.15 U4555.AK29
  BOTTOM w0.114: v3(139.55,138.6) 139.1,139.05 139.1,140.84 139.5,141.24 CN4125.148
M_B_DQ<18>: length 95.8
  L3 w0.076: v2(190.41,91.15) 189.98,91.59 189.98,92.35 189.78,92.55 189.78,93.89 187.29,96.38 187.29,97.79 187.89,98.39 187.89,101.11 187.74,101.26 187.74,104.07 185.17,106.64 185.03,106.78 183.44,106.78 183.33,106.89
  L3 w0.102: 183.33,106.89 174.38,115.84 143.63,115.84 135.18,124.28 135.18,132.96 135.71,133.5 135.71,138.62 135.84,138.75 v3(136.15,138.75)
  BOTTOM w0.076: U4555.AL28 189.94,90.8 190.29,91.15 190.4,91.15 v2(190.41,91.15)
  BOTTOM w0.114: CN4125.160 135.9,141.43 135.75,141.28 135.75,139.82 135.49,139.56 135.49,138.99 135.73,138.75 v3(136.15,138.75)
M_B_DQ<19>: length 96.3
  L3 w0.076: v2(190.39,90.39) 189.84,90.95 189.84,91.13 189.62,91.35 189.35,91.35 188.99,91.72 188.99,94.45 187.13,96.31 187.13,97.86 187.69,98.42 187.69,101.08 187.58,101.19 187.58,103.96 184.92,106.61 184.91,106.61 183.1,106.61 183.05,106.67
  L3 w0.102: v3(136.2,140.11) 135.36,139.27 135.36,133.64 134.83,133.11 134.83,124.14 143.48,115.48 174.23,115.48 183.05,106.67
  BOTTOM w0.076: U4555.AK28 189.94,90.15 190.18,90.39 v2(190.39,90.39)
  BOTTOM w0.114: CN4125.158 136.5,140.41 136.2,140.11 v3(136.2,140.11)
M_B_DQ<20>: length 93.4
  L3 w0.076: 185.25,107.81 185.35,107.81 188.69,104.47 188.69,103.52 188.69,101.72 188.84,101.57 188.84,97.98 188.91,97.92 188.91,97.45 189.98,96.38 190.22,96.38 191.29,95.31 191.29,93.71 v2(191.29,93.7)
  L3 w0.102: 185.25,107.81 175.28,117.78 144.43,117.78 138.06,124.15 138.06,124.9 138.16,125 138.59,125 138.69,125.1 138.69,125.26 138.59,125.36 138.16,125.36 138.06,125.46 138.06,125.61 138.16,125.71 138.62,125.71 138.72,125.82 138.72,125.97 138.62,126.07 138.16,126.07 138.06,126.17 138.06,126.32 138.16,126.42 138.62,126.42 138.72,126.53 138.72,126.68 138.62,126.78 138.16,126.78 138.06,126.88 138.06,127.03 138.16,127.14 138.62,127.14 138.72,127.24 138.72,127.39 138.62,127.49 138.16,127.49 138.06,127.6 138.06,131.98 137.84,132.2 137.84,137.39 137.94,137.49 138.52,137.49 v3(138.67,137.35)
  BOTTOM w0.076: U4555.AR29 191.19,93.7 v2(191.29,93.7) ; U4555.AR29 U4555.AR29
  BOTTOM w0.114: v3(138.67,137.35) 139.8,136.22 CN4125.147
M_B_DQ<21>: length 94.9
  L3 w0.076: 186.39,107.03 186.58,106.84 186.6,106.84 187.83,105.61 187.96,105.61 188.02,105.61 189.46,104.17 189.46,103.4 189.57,103.28 189.57,101.74 189.85,101.46 189.85,97.77 191.67,95.94 191.67,92.82 v2(191.29,92.43)
  L3 w0.102: v3(138.67,135.88) 138.75,135.8 138.75,134.13 138.65,134.03 138.47,134.03 138.37,133.93 138.37,133.78 138.47,133.67 138.65,133.67 138.75,133.57 138.75,132.46 138.41,132.13 138.41,128.06 138.52,127.96 138.67,127.96 138.77,128.06 138.77,131.68 138.87,131.78 139.02,131.78 139.13,131.68 139.13,123.59 144.58,118.13 175.43,118.13 186.39,107.17 186.39,107.03
  BOTTOM w0.076: v2(191.29,92.43) 191.22,92.43 190.9,92.1 U4555.AN29
  BOTTOM w0.114: v3(138.67,135.88) 138.69,135.88 138.73,135.93 138.92,135.93 139.2,135.64 CN4125.149
M_B_DQ<22>: length 93.2
  L3 w0.076: v2(190.34,93.7) 190.33,93.71 190.33,93.81 188.28,95.86 188.28,97.66 188.22,97.72 188.22,101.31 188.07,101.46 188.07,104.21 185.17,107.11 184.11,107.11 184.01,107.21
  L3 w0.102: 184.01,107.21 174.68,116.55 143.92,116.55 136.83,123.64 136.83,131.43 136.71,131.54 136.57,131.54 136.47,131.44 136.47,129.58 136.37,129.48 136.22,129.48 136.12,129.58 136.12,132.06 136.6,132.55 136.6,136.95 136.28,137.27 v3(136.18,137.27)
  BOTTOM w0.076: v2(190.34,93.7) 190.25,93.7 U4555.AR28
  BOTTOM w0.114: CN4125.157 136.8,136.8 136.32,137.27 v3(136.18,137.27)
M_B_DQ<23>: length 94.2
  L3 w0.076: v2(190.36,93.13) 189.94,93.54 189.94,93.96 187.46,96.45 187.46,97.72 188.06,98.32 188.06,101.24 187.91,101.39 187.91,104.14 185.1,106.94 183.78,106.94 183.69,107.03 ; 183.33,107.39 183.33,107.39
  L3 w0.102: 183.69,107.03 183.33,107.39 ; 183.33,107.39 174.53,116.19 143.78,116.19 136.47,123.49 136.47,128.48 136.37,128.59 136.14,128.59 136.03,128.48 136.03,125.26 135.93,125.16 135.69,125.16 135.59,125.26 135.59,132.87 136.17,133.45 v3(136.17,135.84)
  BOTTOM w0.076: v2(190.36,93.13) 190.32,93.13 U4555.AP28
  BOTTOM w0.114: CN4125.159 136.2,135.82 v3(136.17,135.84)
M_B_DQ<24>: length 58
  L6 w0.076: v2(189.38,92.43) 189.78,92.82 189.78,94.4 188.51,95.66 188.51,97.83 188.2,98.14 188.2,104.27 185.75,106.72
  L6 w0.102: 185.75,106.72 185.75,109.15 178.11,116.79 178.11,123 178.6,123.5 178.6,132.03 179.07,132.5 179.07,139.47 179.18,139.58 179.69,139.58 179.79,139.68 179.79,139.85 179.69,139.95 179.18,139.95 179.07,140.06 179.07,140.47 v3(178.5,141.04)
  BOTTOM w0.076: U4555.AN26 188.99,92.1 189.32,92.43 v2(189.38,92.43)
  BOTTOM w0.114: CN4125.24 179.1,141.39 178.75,141.04 v3(178.5,141.04)
M_B_DQ<25>: length 56.9
  L6 w0.076: 185.4,106.82 188.03,104.18 188.03,98.07 188.35,97.76 188.35,95.59 189.38,94.56 v2(189.38,93.73)
  L6 w0.102: v3(178.5,139.51) 178.5,135.96 178.39,135.85 178.1,135.85 177.99,135.74 177.99,135.59 178.1,135.48 178.39,135.48 178.5,135.38 178.5,135.22 178.39,135.12 177.97,135.12 177.87,135.01 177.87,134.85 177.97,134.75 178.39,134.75 178.5,134.64 178.5,133.95 178.25,133.7 178.25,123.64 177.75,123.15 177.75,116.64 185.4,109 185.4,106.82
  BOTTOM w0.076: U4555.AR26 189.32,93.73 v2(189.38,93.73)
  BOTTOM w0.114: v3(178.5,139.51) 179.7,140.71 CN4125.22
M_B_DQ<26>: length 56.3
  L6 w0.076: 186.81,104.25 186.81,98.79 187.08,98.53 187.08,95.16 188.44,93.8 v2(188.44,93.7)
  L6 w0.102: v3(176.33,136.56) 176.33,134.02 176.97,133.39 176.97,129.76 176.47,129.27 176.47,128.95 176.58,128.84 176.81,128.84 176.92,128.74 176.92,128.57 176.81,128.47 176.58,128.47 176.47,128.36 176.47,128.21 176.58,128.1 176.84,128.1 176.95,128 176.95,127.84 176.84,127.73 176.58,127.73 176.47,127.63 176.47,127.47 176.58,127.37 176.84,127.37 176.95,127.26 176.95,127.11 176.84,127 176.58,127 176.47,126.89 176.47,126.74 176.58,126.63 176.84,126.63 176.95,126.52 176.95,126.37 176.84,126.26 176.58,126.26 176.47,126.15 176.47,126 176.58,125.89 176.84,125.89 176.95,125.79 176.95,125.63 176.84,125.53 176.58,125.53 176.47,125.42 176.47,125.26 176.58,125.16 176.81,125.16 176.92,125.05 176.92,124.9 176.81,124.79 176.58,124.79 176.47,124.68 176.47,124.53 176.58,124.42 176.8,124.42 176.91,124.31 176.91,124.16 176.8,124.05 176.58,124.05 176.47,123.94 176.47,116.03 184.03,108.48 184.03,106.52 184.92,105.62 185.45,105.62 186.81,104.26 186.81,104.25
  BOTTOM w0.076: U4555.AR25 188.33,93.7 v2(188.44,93.7)
  BOTTOM w0.114: v3(176.33,136.56) 176.59,136.3 176.59,135.85 176.4,135.66 CN4125.33
M_B_DQ<27>: length 57.3
  L6 w0.076: v2(188.43,93.08) 188.04,93.47 188.04,93.96 187.01,95 186.91,95.09 186.91,98.46 186.65,98.72 186.65,103.89 186.58,103.96
  L6 w0.102: 186.58,103.96 185.35,105.19 184.85,105.19 184.14,105.9 183.45,106.59 183.45,108.55 176.12,115.88 176.12,129.66 176.22,129.77 176.4,129.77 176.51,129.88 176.51,130.03 176.4,130.14 176.22,130.14 176.12,130.25 176.12,130.4 176.22,130.51 176.4,130.51 176.51,130.62 176.51,130.77 176.4,130.88 176.22,130.88 176.12,130.99 176.12,131.14 176.22,131.25 176.45,131.25 176.56,131.35 176.56,131.51 176.45,131.61 176.22,131.61 176.12,131.72 176.12,131.9 176.61,132.39 176.61,133.24 175.82,134.03 175.82,137.61 v3(176.28,138.07)
  BOTTOM w0.076: U4555.AP25 188.37,93.08 v2(188.43,93.08)
  BOTTOM w0.114: CN4125.35 175.8,137.59 v3(176.28,138.07)
M_B_DQ<28>: length 59.6
  L6 w0.076: v2(189.47,90.34) 189.9,90.77 190.62,90.77 190.88,91.02 190.88,93.77 188.84,95.8 188.84,96.51 188.94,96.6 189.22,96.6 189.31,96.7 189.31,96.84 189.22,96.93 188.94,96.93 188.84,97.03 188.84,97.96 188.53,98.28 188.53,104.5 186.48,106.55
  L6 w0.102: v3(180.23,138.05) 180.59,137.68 180.59,133.48 179.78,132.67 179.78,132.2 179.31,131.73 179.31,116.59 186.46,109.44 186.46,106.57 186.48,106.55
  BOTTOM w0.076: v2(189.47,90.34) 189.18,90.34 188.99,90.15 U4555.AK26
  BOTTOM w0.114: v3(180.23,138.05) 179.4,137.22 CN4125.23
M_B_DQ<29>: length 58.9
  L6 w0.076: v2(189.45,91.82) 189.94,92.31 189.94,94.47 188.68,95.73 188.68,97.9 188.36,98.21 188.36,104.36 186.11,106.62 186.11,106.67
  L6 w0.102: 186.11,106.67 186.11,109.29 178.46,116.94 178.46,118.33 178.57,118.44 178.82,118.44 178.92,118.55 178.92,118.7 178.82,118.81 178.57,118.81 178.46,118.91 178.46,119.07 178.57,119.17 178.82,119.17 178.92,119.28 178.92,119.44 178.82,119.54 178.57,119.54 178.46,119.65 178.46,119.8 178.57,119.91 178.82,119.91 178.92,120.02 178.92,120.17 178.82,120.28 178.57,120.28 178.46,120.39 178.46,120.54 178.57,120.65 178.82,120.65 178.92,120.76 178.92,120.91 178.82,121.02 178.57,121.02 178.46,121.12 178.46,121.28 178.57,121.38 178.82,121.38 178.92,121.49 178.92,121.64 178.82,121.75 178.57,121.75 178.46,121.86 178.46,122.01 178.57,122.12 178.82,122.12 178.92,122.23 178.92,122.38 178.82,122.49 178.57,122.49 178.46,122.6 178.46,122.86 178.96,123.35 178.96,131.88 179.43,132.35 179.43,132.82 180.15,133.54 180.15,134.55 180.05,134.66 179.73,134.66 179.63,134.76 179.63,134.92 179.73,135.02 180.05,135.02 180.15,135.13 180.15,135.28 180.05,135.39 179.85,135.39 179.74,135.5 179.74,135.65 179.85,135.76 180.05,135.76 180.15,135.87 v3(180.15,136.62)
  BOTTOM w0.076: v2(189.45,91.82) 189.36,91.82 188.99,91.45 U4555.AM26
  BOTTOM w0.114: CN4125.21 180,136.47 v3(180.15,136.62)
M_B_DQ<30>: length 59.5
  L6 w0.076: 186.21,103.41 186.21,98.69 186.58,98.32 186.58,94.95 186.6,94.93 186.6,94.93 187.08,94.45 187.08,92.08 187.87,91.29 187.87,91.09 v2(188.48,90.48)
  L6 w0.102: 186.21,103.41 185.2,104.43 184.6,104.43 182.74,106.29 182.74,108.25 175.41,115.59 175.41,133.4 175.11,133.69 175.11,140.2 175.85,140.93 v3(176.29,140.93)
  BOTTOM w0.076: v2(188.48,90.48) 188.37,90.48 188.04,90.15 U4555.AK25
  BOTTOM w0.114: CN4125.34 176.1,141.13 v3(176.29,140.93)
M_B_DQ<31>: length 59.6
  L6 w0.076: v2(188.48,91.06) 188.48,91.08 187.87,91.69 187.87,93.9 186.77,95 186.75,95.02 186.75,98.39 186.48,98.65 186.48,103.6 186.38,103.71
  L6 w0.102: 186.38,103.71 185.27,104.81 184.73,104.81 183.1,106.44 183.1,108.4 175.76,115.74 175.76,132.05 176.25,132.54 176.25,133.09 175.47,133.88 175.47,139.42 175.73,139.69 176.08,139.69 v3(176.27,139.49)
  BOTTOM w0.076: U4555.AL25 188.04,90.8 188.3,91.06 v2(188.48,91.06)
  BOTTOM w0.114: CN4125.36 175.5,140.27 v3(176.27,139.49)
M_B_DQ<32>: length 92.1
  L3 w0.076: v2(187.2,102.52) 186.81,102.9 186.81,103.27 186.65,103.44 186.65,103.89 186.65,104.04 186.65,104.18 184.8,106.03 184.71,106.12 184.57,106.12 181.73,106.12 181.67,106.18
  L3 w0.102: 181.67,106.18 179.74,108.11 179.12,108.11 172.98,114.26 164.15,114.26 164.05,114.16 164.05,113.96 163.98,113.89 163.68,113.89 163.57,113.99 163.57,114.16 163.47,114.26 163.32,114.26 163.22,114.16 163.22,113.99 163.12,113.89 162.97,113.89 162.86,113.99 162.86,114.16 162.76,114.26 162.61,114.26 162.51,114.16 162.51,113.99 162.4,113.89 162.26,113.89 162.15,113.99 162.15,114.16 162.05,114.26 161.9,114.26 161.8,114.16 161.8,113.99 161.69,113.89 161.55,113.89 161.44,113.99 161.44,114.16 161.34,114.26 161.19,114.26 161.09,114.16 161.09,113.99 160.98,113.89 160.83,113.89 160.73,113.99 160.73,114.16 160.63,114.26 160.48,114.26 160.37,114.16 160.37,113.99 160.27,113.89 160.12,113.89 160.02,113.99 160.02,114.16 159.91,114.26 159.77,114.26 159.66,114.16 159.66,113.99 159.56,113.89 159.41,113.89 159.31,113.99 159.31,114.16 159.2,114.26 159.06,114.26 158.95,114.16 158.95,113.99 158.85,113.89 158.7,113.89 158.6,113.99 158.6,114.14 158.49,114.24 158.34,114.24 158.24,114.14 158.24,113.99 158.14,113.89 157.73,113.89 157.36,114.26 142.98,114.26 133.61,123.63 133.61,133.56 133.61,133.56 133.61,133.61 133.86,133.87 133.86,137.4 134.06,137.6 v3(134.32,137.6)
  BOTTOM w0.076: U4555.AY23 187.18,96.52 187.14,96.55 187.14,97.69 187.74,98.28 187.74,98.71 188.02,99 188.02,101.7 v2(187.2,102.52)
  BOTTOM w0.114: v3(134.32,137.6) 135,136.92 CN4125.163
M_B_DQ<33>: length 93.1
  L3 w0.076: 182.13,106.36 182.21,106.28 184.5,106.28 184.64,106.28 184.64,106.29 184.77,106.29 184.87,106.19 186.81,104.24 186.81,103.97 186.81,103.82 186.81,103.51 187.2,103.13 v2(187.2,103.09)
  L3 w0.102: 182.13,106.36 179.55,108.95 179.4,108.95 179.17,108.72 179.03,108.72 178.92,108.83 178.92,108.97 179.15,109.2 179.15,109.34 179.04,109.45 178.9,109.45 178.67,109.22 178.52,109.22 178.42,109.33 178.42,109.48 178.65,109.7 178.65,109.85 178.52,109.97 178.37,109.97 178.18,109.78 178.04,109.78 177.93,109.89 177.93,110.03 178.12,110.22 178.12,110.37 178.02,110.48 177.87,110.48 177.68,110.29 177.53,110.29 177.43,110.39 177.43,110.54 177.62,110.73 177.62,110.87 177.52,110.98 177.37,110.98 177.18,110.79 177.03,110.79 176.93,110.89 176.93,111.04 177.12,111.23 177.12,111.38 177.01,111.48 176.87,111.48 176.68,111.29 176.53,111.29 176.42,111.4 176.42,111.54 176.61,111.73 176.61,111.88 176.51,111.98 176.36,111.98 176.14,111.77 176,111.77 175.89,111.87 175.89,112.02 176.11,112.24 176.11,112.38 176.01,112.49 175.86,112.49 175.64,112.27 175.5,112.27 175.39,112.38 175.39,112.52 175.61,112.74 175.61,112.89 175.5,112.99 175.36,112.99 175.17,112.8 175.02,112.8 174.92,112.9 174.92,113.05 175.11,113.24 175.11,113.39 175,113.49 174.85,113.49 174.66,113.3 174.52,113.3 174.41,113.41 174.41,113.55 174.6,113.74 174.6,113.89 174.5,114 174.35,114 174.16,113.81 174.01,113.81 173.91,113.91 173.91,114.06 174.1,114.25 174.1,114.39 173.88,114.62 143.12,114.62 133.96,123.78 133.96,133.41 133.96,133.47 134.3,133.8 v3(134.3,136.17)
  BOTTOM w0.076: v2(187.2,103.09) 188.18,102.1 188.18,98.93 187.91,98.65 187.91,98.18 187.31,97.58 187.31,97 187.47,96.84 187.47,96.44 187.38,96.27 187.32,96.21 187.32,96 187.18,95.87 U4555.AW23
  BOTTOM w0.114: v3(134.3,136.17) 134.4,136.07 CN4125.165
M_B_DQ<34>: length 91.9
  L3 w0.076: v2(185.66,102.35) 185.57,102.35 185.1,102.81 185.1,103.33 185.1,103.46 183.78,104.78 177.55,104.78 176.77,105.57
  L3 w0.102: v3(130.97,136.41) 130.8,136.25 130.8,131.6 131.3,131.1 131.3,130.74 131.2,130.63 130.89,130.63 130.79,130.53 130.79,130.38 130.89,130.28 131.2,130.28 131.3,130.17 131.3,130.02 131.2,129.92 130.89,129.92 130.78,129.82 130.78,129.67 130.89,129.57 131.2,129.57 131.3,129.46 131.3,129.31 131.2,129.21 130.89,129.21 130.78,129.11 130.78,128.96 130.89,128.85 131.2,128.85 131.3,128.75 131.3,128.6 131.2,128.5 130.89,128.5 130.78,128.39 130.78,128.25 130.89,128.14 131.2,128.14 131.3,128.04 131.3,127.89 131.2,127.79 130.88,127.79 130.78,127.69 130.78,127.53 130.88,127.43 131.2,127.43 131.3,127.33 131.3,127.17 131.2,127.06 130.73,127.06 130.66,127 130.66,126.77 130.73,126.71 131.2,126.71 131.3,126.6 131.3,122.7 131.3,122.7 131.3,122.68 142.02,111.96 155.37,111.96 155.76,111.58 172.17,111.58 176.77,106.98 176.77,105.57
  BOTTOM w0.076: U4555.AY21 185.83,96.52 185.83,96.97 185.91,97.05 185.91,98.5 186.47,99.05 186.47,101.74 185.86,102.35 v2(185.66,102.35)
  BOTTOM w0.114: CN4125.175 131.4,135.98 v3(130.97,136.41)
M_B_DQ<35>: length 92.8
  L3 w0.076: v2(185.76,101.15) 184.94,101.98 184.94,103.4 183.71,104.62 177.48,104.62 177.48,104.62 177.41,104.62 176.44,105.6 176.42,105.6 176.27,105.74
  L3 w0.102: v3(130.93,137.82) 130.93,137.94 130.83,138.04 130.41,138.04 130.3,137.94 130.3,125.09 130.41,124.99 130.79,124.99 130.89,124.88 130.89,124.74 130.79,124.63 130.41,124.63 130.3,124.53 130.3,124.38 130.41,124.28 130.79,124.28 130.89,124.17 130.89,124.03 130.79,123.92 130.41,123.92 130.3,123.82 130.3,123.18 141.88,111.61 155.22,111.61 155.65,111.18 170.84,111.18 176.04,105.97 176.05,105.97 176.27,105.74
  BOTTOM w0.076: U4555.AW21 185.83,95.87 185.83,96.1 185.53,96.39 185.53,96.96 185.74,97.17 185.74,98.56 186.3,99.12 186.3,100.61 v2(185.76,101.15)
  BOTTOM w0.114: v3(130.93,137.82) 130.93,137.83 130.33,137.23 130.33,135.89 130.8,135.42 CN4125.177
M_B_DQ<36>: length 93.5
  L3 w0.076: 182.48,106.52 182.55,106.45 184.57,106.45 184.84,106.45 184.93,106.36 186.98,104.31 186.98,104.3 187.2,104.09 v2(187.2,103.67)
  L3 w0.102: 182.48,106.52 174.02,114.97 143.27,114.97 134.32,123.93 134.32,133.24 134.32,133.32 134.75,133.75 134.75,138.52 134.65,138.62 134.27,138.62 134.16,138.72 134.16,138.88 134.27,138.98 134.68,138.98 134.85,139.15 134.85,139.48 135.27,139.9 135.27,140.05 135.06,140.26 134.91,140.26 v3(134.14,139.49)
  BOTTOM w0.076: v2(187.2,103.67) 188.35,102.51 188.35,98.86 188.07,98.58 188.07,98.1 187.47,97.5 187.47,97.39 187.47,97.07 187.64,96.91 187.64,96.4 187.56,96.26 187.56,95.6 187.18,95.22 U4555.AV23
  BOTTOM w0.114: CN4125.164 134.7,140.06 134.14,139.5 v3(134.14,139.49)
M_B_DQ<37>: length 94.3
  L3 w0.076: 181.36,106.01 181.41,105.95 184.64,105.95 184.73,105.86 186.49,104.11 186.49,103.96 186.48,103.96 186.48,103.37 186.65,103.21 186.65,102.83 186.81,102.67 186.81,102.29 187.2,101.91 v2(187.2,101.91)
  L3 w0.102: 181.36,106.01 179.56,107.81 178.69,107.81 172.98,113.52 168.14,113.52 168.04,113.62 168.04,113.72 167.93,113.83 167.79,113.83 167.68,113.72 167.68,113.62 167.58,113.52 167.43,113.52 167.33,113.62 167.33,113.72 167.22,113.83 167.07,113.83 166.97,113.72 166.97,113.62 166.87,113.52 166.72,113.52 166.61,113.62 166.61,113.72 166.51,113.83 166.36,113.83 166.26,113.72 166.26,113.62 166.15,113.52 165.97,113.52 165.86,113.62 165.86,113.79 165.76,113.9 165.61,113.9 165.51,113.79 165.51,113.62 165.4,113.52 165.26,113.52 165.15,113.62 165.15,113.79 165.05,113.9 164.9,113.9 164.8,113.79 164.8,113.62 164.69,113.52 157.59,113.52 157.2,113.91 142.83,113.91 133.25,123.49 133.25,133.76 133.51,134.02 133.51,140.65 133.86,141 v3(134.1,141)
  BOTTOM w0.076: U4555.AU23 187.18,94.57 186.41,94.57 186.21,94.77 186.21,94.77 186.2,94.78 186.2,95.01 186.23,95.03 186.23,95.4 186.2,95.43 186.2,95.58 186.22,95.62 186.26,95.71 186.26,95.71 186.28,95.76 186.28,95.97 186.21,96.13 186.21,96.26 186.26,96.36 186.28,96.41 186.28,96.91 186.24,96.95 186.24,98.36 186.8,98.92 186.8,101.51 v2(187.2,101.91)
  BOTTOM w0.114: CN4125.166 v3(134.1,141)
M_B_DQ<38>: length 93
  L3 w0.076: 177.07,105.78 177.07,105.55 177.67,104.95 184.32,104.95 185.48,103.79 v2(185.48,103.54)
  L3 w0.102: v3(131.14,139.76) 131.29,139.76 131.42,139.64 131.42,136.15 131.16,135.89 131.16,131.75 131.66,131.25 131.66,122.83 142.17,112.32 155.51,112.32 155.9,111.93 172.32,111.93 177.14,107.11 177.27,106.98 177.27,106.58 177.12,106.44 177.12,106.09 177.07,106.04 177.07,105.78
  BOTTOM w0.076: v2(185.48,103.54) 185.77,103.54 186.63,102.68 186.63,98.99 186.07,98.43 186.07,96.88 186.12,96.84 186.12,96.45 186.07,96.35 186.05,96.29 186.05,96.09 186.07,96.04 186.11,95.95 186.12,95.93 186.12,95.8 186.09,95.75 186.07,95.7 185.93,95.56 185.93,95.22 U4555.AV21
  BOTTOM w0.114: v3(131.14,139.76) 131.7,140.32 CN4125.174
M_B_DQ<39>: length 94
  L3 w0.076: v2(185.76,100.57) 186.19,101 186.19,102.41 186.03,102.58 186.03,102.95 185.86,103.11 185.86,103.73 184.48,105.11 177.74,105.11 177.35,105.5 177.35,105.65
  L3 w0.102: v3(131.1,141.15) 131.54,141.15 131.77,140.92 131.77,136 131.52,135.74 131.52,131.89 132.01,131.39 132.01,122.98 142.32,112.68 155.66,112.68 156.05,112.29 172.47,112.29 172.55,112.21 177.62,107.13 177.62,106.45 177.35,106.18 177.35,105.65
  BOTTOM w0.076: U4555.AU21 185.93,94.57 185.64,94.86 185.64,95.64 185.37,95.91 185.37,97.03 185.58,97.24 185.58,98.63 186.14,99.19 186.14,100.19 v2(185.76,100.57)
  BOTTOM w0.114: CN4125.176 131.1,141.15 v3(131.1,141.15)
M_B_DQ<40>: length 54.7
  L6 w0.076: 182.2,106.51 182.2,106.39 185.1,103.49 185.1,101.72 185,101.62 184.79,101.41 184.79,100.38 v2(185.19,99.98)
  L6 w0.102: v3(174.54,136.53) 174.54,133.52 174.89,133.18 174.89,125.12 174.78,125.01 174.57,125.01 174.46,124.9 174.46,124.75 174.57,124.64 174.78,124.64 174.89,124.53 174.89,124.38 174.78,124.27 174.57,124.27 174.46,124.16 174.46,124.01 174.57,123.9 174.78,123.9 174.89,123.8 174.89,123.64 174.78,123.54 174.57,123.54 174.46,123.43 174.46,123.28 174.57,123.17 174.78,123.17 174.89,123.06 174.89,122.91 174.78,122.8 174.57,122.8 174.46,122.69 174.46,122.54 174.57,122.43 174.78,122.43 174.89,122.32 174.89,122.17 174.78,122.06 174.57,122.06 174.46,121.95 174.46,121.8 174.57,121.69 174.78,121.69 174.89,121.59 174.89,121.43 174.78,121.33 174.57,121.33 174.46,121.22 174.46,121.07 174.57,120.96 174.78,120.96 174.89,120.85 174.89,120.7 174.78,120.59 174.57,120.59 174.46,120.48 174.46,120.33 174.57,120.22 174.78,120.22 174.89,120.11 174.89,119.96 174.78,119.85 174.57,119.85 174.46,119.74 174.46,119.59 174.57,119.48 174.78,119.48 174.89,119.38 174.89,119.22 174.78,119.12 174.57,119.12 174.46,119.01 174.46,118.86 174.57,118.75 174.78,118.75 174.89,118.64 174.89,118.49 174.78,118.38 174.61,118.38 174.5,118.27 174.5,118.12 174.61,118.01 174.78,118.01 174.89,117.9 174.89,117.75 174.78,117.64 174.6,117.64 174.49,117.53 174.49,117.38 174.6,117.27 174.78,117.27 174.89,117.17 174.89,117.01 174.78,116.91 174.61,116.91 174.5,116.8 174.5,116.65 174.61,116.54 174.78,116.54 174.89,116.43 174.89,116.28 174.78,116.17 174.58,116.17 174.48,116.06 174.48,115.91 174.58,115.8 174.78,115.8 174.89,115.69 174.89,115.35 182.2,108.04 182.2,106.51
  BOTTOM w0.076: U4555.AY19 184.75,96.52 184.84,96.6 184.84,99.21 184.81,99.24 184.81,99.6 v2(185.19,99.98)
  BOTTOM w0.114: CN4125.39 174.6,136.47 v3(174.54,136.53)
M_B_DQ<41>: length 55.8
  L6 w0.076: 181.85,106.64 181.85,106.51 184.94,103.42 184.94,101.78 184.63,101.48 184.63,99.6 184.83,99.4 v2(185.19,99.4)
  L6 w0.102: v3(174.48,138.01) 174.21,138.01 174.11,137.91 174.11,133.37 174.53,132.95 174.53,130.59 174.04,130.1 174.04,129.74 174.15,129.63 174.37,129.63 174.48,129.52 174.48,129.37 174.37,129.26 174.15,129.26 174.04,129.15 174.04,129 174.15,128.89 174.37,128.89 174.48,128.78 174.48,128.63 174.37,128.52 174.15,128.52 174.04,128.41 174.04,128.26 174.15,128.15 174.37,128.15 174.48,128.05 174.48,127.89 174.37,127.79 174.15,127.79 174.04,127.68 174.04,127.53 174.15,127.42 174.37,127.42 174.48,127.31 174.48,127.16 174.37,127.05 174.15,127.05 174.04,126.94 174.04,126.79 174.15,126.68 174.37,126.68 174.48,126.57 174.48,126.42 174.37,126.31 174.15,126.31 174.04,126.2 174.04,126.05 174.15,125.94 174.37,125.94 174.48,125.84 174.48,125.68 174.37,125.58 174.15,125.58 174.04,125.47 174.04,115.7 181.85,107.89 181.85,106.64
  BOTTOM w0.076: v2(185.19,99.4) 185.19,97.39 185.04,97.25 185.04,96.16 184.75,95.87 U4555.AW19
  BOTTOM w0.114: CN4125.41 174,137.5 174.48,137.99 v3(174.48,138.01)
M_B_DQ<42>: length 54.6
  L6 w0.076: 177.16,105.73 177.16,105.64 177.91,104.89 181.08,104.89 182.29,103.68 182.29,102.68 182.93,102.04 182.93,98.95 v2(183.52,98.35)
  L6 w0.102: 177.16,105.73 177.16,107.03 176.99,107.2 174.45,109.74 174.45,110.33 170.98,113.8 170.98,114.32 170.98,116.26 170.98,116.26 170.98,132.92 169.88,134.02 169.88,140.39 170.62,141.13 170.96,141.13 v3(170.96,141.13)
  BOTTOM w0.076: U4555.AY17 183.4,96.52 183.4,96.87 183.31,96.95 183.31,98.14 v2(183.52,98.35)
  BOTTOM w0.114: v3(170.96,141.13) 170.95,141.13 170.7,141.39 CN4125.52
M_B_DQ<43>: length 55.4
  L6 w0.076: v2(183.83,100.04) 183.26,100.61 183.26,102.18 182.62,102.81 182.62,104.13 179.6,107.15 178.05,107.15 177.86,107.33
  L6 w0.102: v3(171.13,138.3) 170.75,138.3 170.6,138.14 170.6,134.32 171.69,133.22 171.69,115.97 171.69,114.09 172.91,112.87 173.06,112.87 173.16,112.97 173.31,112.97 173.42,112.86 173.42,112.71 173.32,112.61 173.32,112.46 173.43,112.35 173.58,112.35 173.68,112.45 173.83,112.45 173.94,112.34 173.94,112.19 173.84,112.09 173.84,111.94 173.95,111.83 174.11,111.83 174.2,111.93 174.36,111.93 174.46,111.82 174.46,111.67 174.37,111.57 174.37,111.42 175.16,110.62 175.16,110.03 177.86,107.33
  BOTTOM w0.076: v2(183.83,100.04) 183.42,99.63 183.42,98.81 183.1,98.5 183.1,96.45 183.18,96.29 183.18,96.08 183.4,95.87 U4555.AW17
  BOTTOM w0.114: v3(171.13,138.3) 170.4,137.57 CN4125.53
M_B_DQ<44>: length 56.3
  L6 w0.076: 181.52,106.7 181.52,106.58 184.77,103.32 184.77,101.85 184.46,101.54 184.46,99.53 184.97,99.02 185.38,99.02 v2(185.76,99.4)
  L6 w0.102: v3(174.41,139.6) 173.97,139.6 173.55,139.18 173.55,134.18 173.69,134.04 173.69,132.41 173.77,132.33 173.91,132.33 174.02,132.22 174.02,132.07 173.91,131.96 173.77,131.96 173.69,131.88 173.69,131.67 173.77,131.59 173.91,131.59 174.02,131.48 174.02,131.33 173.91,131.22 173.77,131.22 173.69,131.14 173.69,130.94 173.77,130.85 173.91,130.85 174.02,130.75 174.02,130.59 173.91,130.49 173.77,130.49 173.69,130.4 173.69,115.44 181.52,107.61 181.52,106.7
  BOTTOM w0.076: U4555.AV19 184.64,95.22 184.64,95.35 185.21,95.91 185.21,97.1 185.42,97.31 185.42,98.78 185.76,99.12 v2(185.76,99.4)
  BOTTOM w0.114: CN4125.40 174.3,139.71 v3(174.41,139.6)
M_B_DQ<45>: length 57.3
  L6 w0.076: v2(183.86,101.84) 184.61,102.59 184.61,103.25 181.15,106.71 181.15,106.81
  L6 w0.102: 181.15,106.81 181.15,107.47 173.33,115.29 173.33,133.9 173.19,134.04 173.19,134.97 173.08,135.08 172.63,135.08 172.52,135.19 172.52,135.34 172.63,135.45 173.08,135.45 173.19,135.55 173.19,135.71 173.08,135.81 172.63,135.81 172.52,135.92 172.52,136.07 172.63,136.18 173.08,136.18 173.19,136.29 173.19,139.34 v3(172.68,139.84)
  BOTTOM w0.076: v2(183.86,101.84) 184.25,101.45 184.25,99.92 184.18,99.86 184.18,98.67 184.07,98.55 184.07,97.92 183.64,97.5 183.64,97.15 183.85,96.94 183.85,96.41 183.83,96.36 183.83,96.36 183.78,96.25 183.78,96.12 183.85,95.97 183.85,95.76 183.83,95.71 183.79,95.62 183.77,95.6 183.76,95.58 183.76,94.77 183.96,94.57 184.64,94.57 U4555.AU19
  BOTTOM w0.114: CN4125.42 173.7,140.86 172.68,139.85 v3(172.68,139.84)
M_B_DQ<46>: length 55.8
  L6 w0.076: 177.61,107.08 177.71,106.98 178.02,106.98 179.53,106.98 182.46,104.06 182.46,102.74 183.09,102.11 183.09,99.58 v2(183.8,98.87)
  L6 w0.102: 177.61,107.08 177.14,107.55 174.81,109.89 174.81,110.47 171.34,113.94 171.34,114.46 171.34,133.07 170.24,134.17 170.24,139.53 170.53,139.82 171.02,139.82 v3(171.12,139.72)
  BOTTOM w0.076: U4555.AV17 183.4,95.25 183.5,95.36 183.5,95.56 183.64,95.69 183.69,95.8 183.69,95.93 183.68,95.95 183.64,96.03 183.61,96.09 183.61,96.29 183.69,96.45 183.69,96.45 183.69,96.87 183.48,97.08 183.48,97.21 183.48,97.21 183.48,97.56 183.9,97.99 183.9,98.77 v2(183.8,98.87)
  BOTTOM w0.114: CN4125.50 171.3,141.42 171.55,141.17 171.55,140.08 171.18,139.72 v3(171.12,139.72)
M_B_DQ<47>: length 56.5
  L6 w0.076: v2(183.83,100.62) 183.42,101.03 183.42,102.25 182.79,102.88 182.79,104.19 179.19,107.79 178.95,107.79 178.81,107.94
  L6 w0.102: v3(171.11,136.87) 171.11,134.3 172.05,133.37 172.05,115.82 172.05,115.82 172.05,114.75 175.52,111.28 175.52,110.18 177.66,108.04 177.81,108.04 177.92,108.15 177.92,108.3 176.37,109.85 176.37,110 176.48,110.12 176.63,110.12 178.34,108.4 178.81,107.94
  BOTTOM w0.076: U4555.AU17 183.4,94.57 183.1,94.86 183.1,95.61 183.01,95.7 183.01,96.26 182.96,96.36 182.96,96.36 182.94,96.41 182.94,98.56 183.26,98.88 183.26,99.78 183.45,99.96 183.45,100.24 v2(183.83,100.62)
  BOTTOM w0.114: CN4125.51 171,136.76 v3(171.11,136.87)
M_B_DQ<48>: length 96.8
  L3 w0.076: 184.46,94.75 184.67,94.55 185.06,94.55 185.68,93.92 185.68,93.71 v2(185.69,93.7)
  L3 w0.102: v3(125.7,141.1) 126.06,141.1 126.46,140.7 126.85,140.7 126.95,140.6 126.95,140.45 126.85,140.35 126.46,140.35 126.35,140.24 126.35,140.1 126.46,139.99 126.75,139.99 126.85,139.89 126.85,139.74 126.75,139.64 126.46,139.64 126.35,139.53 126.35,135.08 126.45,134.98 126.84,134.98 126.94,134.88 126.94,134.68 126.84,134.57 126.52,134.57 126.42,134.47 126.42,134.32 126.52,134.22 126.87,134.22 126.98,134.11 126.98,133.97 126.87,133.86 126.47,133.86 126.36,133.76 126.36,133.63 126.49,133.51 126.87,133.51 126.98,133.4 126.98,122.48 140.65,108.8 152.98,108.8 153.99,107.8 156.37,107.8 157.36,106.81 166.18,106.81 169.43,103.56 172.2,103.56 172.99,102.77 174.82,102.77 178.83,98.76 181.81,98.76 183.14,97.43 183.14,96.08 184.46,94.75
  BOTTOM w0.076: v2(185.69,93.7) 185.59,93.7 U4555.AR21
  BOTTOM w0.114: CN4125.194 v3(125.7,141.1)
M_B_DQ<49>: length 97.7
  L3 w0.076: v2(186.63,93.73) 186.63,93.73 186.63,94.68 185.09,96.22 185.09,96.8 184.46,97.43 184.27,97.62 184.27,103.1 183.41,103.96 174.84,103.96 174.75,104.04
  L3 w0.102: v3(129.26,140.97) 129.01,140.97 128.45,140.42 128.45,138.02 128.21,137.77 128.21,123.05 141.22,110.04 153.49,110.04 154.5,109.03 158.72,109.03 158.82,108.92 158.82,108.77 158.92,108.66 159.08,108.66 159.18,108.77 159.18,108.92 159.28,109.03 159.43,109.03 159.53,108.92 159.53,108.75 159.63,108.65 159.79,108.65 159.89,108.75 159.89,108.92 159.99,109.03 160.14,109.03 160.24,108.92 160.24,108.69 160.35,108.59 160.5,108.59 160.6,108.69 160.6,108.92 160.7,109.03 160.85,109.03 160.96,108.92 160.96,108.72 161.06,108.62 161.21,108.62 161.31,108.72 161.31,108.92 161.42,109.03 166.45,109.03 167.25,108.23 168.71,108.23 169.84,107.1 171.7,107.1 174.75,104.04
  BOTTOM w0.076: U4555.AR22 186.57,93.73 v2(186.63,93.73) ; U4555.AR22 186.24,93.4 U4555.AR22
  BOTTOM w0.114: CN4125.182 129.3,141.02 v3(129.26,140.97)
M_B_DQ<50>: length 99.7
  L3 w0.076: v2(185.76,91) 185.12,91.64 185.12,93.88 184.88,94.12 184.28,94.12 184.11,94.29 183.7,94.29 182.77,95.22 182.77,97.12 182.64,97.25
  L3 w0.102: v3(125.66,137.42) 125.02,136.79 125.02,132.14 125.13,132.03 125.4,132.03 125.5,131.93 125.5,131.78 125.4,131.68 125.13,131.68 125.02,131.57 125.02,131.43 125.13,131.32 125.4,131.32 125.5,131.22 125.5,131.07 125.4,130.97 125.13,130.97 125.02,130.86 125.02,130.71 125.13,130.61 125.4,130.61 125.5,130.51 125.5,130.36 125.4,130.26 125.13,130.26 125.02,130.15 125.02,130 125.13,129.9 125.38,129.9 125.49,129.8 125.49,129.65 125.38,129.54 125.13,129.54 125.02,129.44 125.02,129.08 125.13,128.98 125.35,128.98 125.46,128.88 125.46,128.73 125.35,128.62 125.13,128.62 125.02,128.52 125.02,128.37 125.13,128.27 125.35,128.27 125.46,128.16 125.46,128.02 125.35,127.91 125.13,127.91 125.02,127.81 125.02,127.66 125.13,127.56 125.33,127.56 125.43,127.46 125.43,127.3 125.33,127.2 125.13,127.2 125.02,127.1 125.02,126.95 125.13,126.85 125.35,126.85 125.46,126.74 125.46,124.03 126.16,123.32 126.16,122.28 140.36,108.09 152.69,108.09 153.7,107.09 156.08,107.09 157.06,106.1 165.89,106.1 169.16,102.82 171.9,102.82 172.65,102.07 174.43,102.07 178.31,98.19 181.71,98.19 182.64,97.25
  BOTTOM w0.076: U4555.AL21 185.49,91 v2(185.76,91)
  BOTTOM w0.114: v3(125.66,137.42) 126.6,136.49 CN4125.191
M_B_DQ<51>: length 99.9
  L3 w0.076: 176.82,104.51 177,104.51 177.21,104.29 183.54,104.29 184.6,103.23 184.6,97.76 187.86,94.5 187.86,93.37 187.1,92.61 187.1,92.24 v2(186.63,91.78) ; 175.69,105.11 175.69,105.11
  L3 w0.102: v3(129.29,136.15) 129.05,136.15 128.92,136.03 128.92,131.17 129.02,131.07 129.24,131.07 129.35,130.96 129.35,130.82 129.24,130.71 129.02,130.71 128.92,130.61 128.92,130.46 129.02,130.36 129.24,130.36 129.35,130.25 129.35,130.1 129.24,130 129.02,130 128.92,129.9 128.92,129.75 129.02,129.64 129.24,129.64 129.35,129.54 129.35,129.39 129.24,129.29 129.02,129.29 128.92,129.18 128.92,129.04 129.02,128.93 129.24,128.93 129.35,128.83 129.35,128.68 129.24,128.58 129.02,128.58 128.92,128.47 128.92,128.33 129.02,128.22 129.24,128.22 129.35,128.12 129.35,127.97 129.24,127.87 129.02,127.87 128.92,127.76 128.92,127.61 129.02,127.51 129.24,127.51 129.35,127.41 129.35,127.26 129.24,127.16 129.02,127.16 128.92,127.05 128.92,126.9 129.02,126.8 129.24,126.8 129.35,126.7 129.35,126.55 129.24,126.44 129.02,126.44 128.92,126.34 128.92,126.19 129.02,126.09 129.24,126.09 129.35,125.98 129.35,125.84 129.24,125.73 129.02,125.73 128.92,125.63 128.92,125.48 129.02,125.38 129.27,125.38 129.37,125.28 129.37,125.12 129.27,125.02 129.02,125.02 128.92,124.92 128.92,124.77 129.02,124.67 129.3,124.67 129.4,124.56 129.4,124.41 129.3,124.31 129.02,124.31 128.92,124.21 128.92,124.06 129.02,123.95 129.3,123.95 129.4,123.85 129.4,123.7 129.3,123.6 129.02,123.6 128.92,123.5 128.92,123.34 141.52,110.75 154.86,110.75 155.3,110.31 157.68,110.31 158.25,109.74 171.06,109.74 175.69,105.11 ; 175.69,105.11 176.29,104.51 176.82,104.51
  BOTTOM w0.076: U4555.AM22 186.57,91.78 v2(186.63,91.78)
  BOTTOM w0.114: CN4125.183 129,135.87 v3(129.29,136.15)
M_B_DQ<52>: length 99
  L3 w0.076: 176.94,104.18 177.09,104.18 177.14,104.13 183.48,104.13 184.44,103.16 184.44,97.69 184.53,97.59 184.53,97.59 185.33,96.8 185.33,96.59 187.06,94.85 187.06,92.93 186.63,92.5 v2(186.63,92.43)
  L3 w0.102: v3(129.29,139.3) 129.03,139.3 128.81,139.09 128.81,137.87 128.56,137.63 128.56,123.2 141.37,110.39 153.64,110.39 154.65,109.38 166.87,109.38 167.39,108.86 171.12,108.86 171.23,108.75 171.23,108.61 171.03,108.41 171.03,108.27 171.14,108.16 171.29,108.16 171.4,108.27 171.54,108.27 171.65,108.17 171.65,108.02 171.54,107.91 171.54,107.76 171.64,107.66 171.79,107.66 171.94,107.81 172.08,107.81 172.19,107.7 172.19,107.56 172.04,107.41 172.04,107.26 172.14,107.16 172.29,107.16 172.38,107.24 172.52,107.24 172.63,107.14 172.63,106.99 172.54,106.91 172.54,106.76 175.12,104.18 176.94,104.18
  BOTTOM w0.076: U4555.AN22 186.57,92.43 v2(186.63,92.43)
  BOTTOM w0.114: CN4125.180 129.9,139.91 v3(129.29,139.3)
