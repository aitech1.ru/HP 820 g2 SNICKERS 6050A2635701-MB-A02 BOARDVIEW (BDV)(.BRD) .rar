# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ON_OFF#: length 16
  TOP w0.102: TP292.1 104.85,129.19 CN290.3 104.85,137.69 104.85,139.35 108.35,142.84 Q115.2
ON_OFF#1: length 361.4
  TOP w0.102: v2(111.41,146.77) 111.41,143.82 Q115.3 111.09,139.87 v2(110.52,139.3) ; v2(131.1,71.74) 131.22,71.74 132.64,73.15 132.64,73.41 132.64,73.41 132.64,76.71 132.9,76.97 132.9,78.07 131.89,79.08 CN4941.11 ; R100.1 287.94,121.19 v2(287.94,121.78)
  L3 w0.102: CN3601.43 324.85,127.7 325.18,128.03 325.18,131.12 324.72,131.58 309.93,131.58 308.64,130.29 302.8,130.29 302.17,129.65 300.9,129.65 296.36,125.12 291.93,125.12 289.15,122.34 288.5,122.34 v2(287.94,121.78)
  L5 w0.102: v2(129.04,88.58) 129.04,88.91 128.3,89.65 125.93,89.65 124.18,91.4 124.14,91.4 124.11,91.43 120.67,91.43 119.91,92.19 119.28,92.19 117.23,94.24 117.23,94.57 117.22,94.58 117.22,94.87 115.88,96.21 115.88,112.74 113.56,115.05 113.56,127.37 109.21,131.72 109.21,132.01 109.21,138.12 110.4,139.3 v2(110.52,139.3)
  L6 w0.102: v2(111.41,146.77) 111.41,148.77 113.03,150.39 114,151.36 137.15,151.36 138.94,149.57 152.43,149.57 153.67,148.32 165.64,148.32 166.43,147.53 177.43,147.53 178.57,148.68 186.32,148.68 186.9,149.26 205.23,149.26 206.81,147.69 209.33,147.69 210.66,149.02 213.33,149.02 214.66,150.35 214.66,151.37 215.93,152.64 218.09,152.64 223.43,157.97 232.38,157.97 234.23,159.83 242.26,159.83 243.82,158.27 243.82,147.41 243.82,147.41 243.82,147.08 246.18,144.71 251.28,144.71 251.35,144.78 262.97,144.78 265.29,142.46 273.23,142.46 278.94,136.75 278.94,135.7 282.01,132.62 282.58,132.06 283.71,132.06 284.64,131.13 284.64,129.17 284.23,128.76 284.23,126.22 287.94,122.51 v2(287.94,121.78)
  BOTTOM w0.102: v2(129.04,88.58) 128.81,88.35 v1(128.81,82.03) 128.81,79.82 130.16,78.47 130.16,72.12 130.54,71.74 v2(131.1,71.74)
ON_OFF#_PB: length 21.8
  TOP w0.102: v4(277.48,33.9) 277.52,33.85 CN9100.4
  L6 w0.102: v4(277.48,33.9) 277.34,33.77 270.5,33.77 268.61,31.88 267.08,31.88 263.05,27.85 v4(263.05,25.69)
  BOTTOM w0.102: v4(263.05,25.69) 261.75,25.69 SW9100.3
OSC_IN: length 7.8
  TOP w0.102: C3072.1 92.71,83.23 X3065.3 92.28,82.87 91.47,83.68 89.16,83.68 v1(89.14,83.7) 89.22,83.77 89.22,84.53 88.99,84.76 88.94,84.76 88.29,85.42 U3065.33
OSC_OUT: length 6.6
  TOP w0.102: U3065.34 88.48,85.91 v1(89.14,85.24) 89.39,85 X3065.1 91.45,84.03 C3071.1
PCBEEP: length 2.2
  TOP w0.254: U501.12 298.26,57.86 297.54,57.14 v1(297.42,57.14) C518.1
PCBEEP_IC_C: length 3.7
  TOP w0.254: C518.2 295.23,57.14 v1(295,57.36) 295,57.72 C519.1 R510.1 292.77,58.18 R513.2
PCH_3A_SMCLK: length 32.1
  TOP w0.114: v2(151.26,90.83) 151.29,90.83 151.14,90.69 151.14,88.63 150.94,88.43 v2(150.94,85.21)
  L3 w0.102: v4(170.64,93.56) 168.31,91.24 164.68,91.24 163.92,90.48 158.23,90.48 157.88,90.83 v2(151.26,90.83)
  BOTTOM w0.076: v4(170.64,93.56) 170.83,93.38 173.9,93.38 174.18,93.1 174.19,93.1 U4555.AP2
  BOTTOM w0.114: R4830.2 149.38,85.38 Q4752.6 150.78,85.38 v2(150.94,85.21)
PCH_3A_SMDATA: length 24.5
  L3 w0.102: v3(152.81,84.22) 152.81,84.34 155.04,86.57 158.36,86.57 159.73,87.94 163.8,87.94 164.96,89.1 v2(168.35,89.1)
  BOTTOM w0.114: Q4752.3 152.67,84.08 v3(152.81,84.22) 153.1,83.93 R4792.2 ; v2(168.35,89.1) 169.38,89.1 169.56,88.92 170.79,88.92 171.26,89.39 173.49,89.39 U4555.AH1
PCH_3M_SMCLK: length 183.2
  TOP w0.114: v4(168.82,92.48) 168.82,94.73 168.44,95.11 168.44,103.98 167.42,105 v2(167.42,106.54) ; U400.28 293.77,113.89 v2(294.16,114.29)
  L3 w0.102: v2(150.21,92.06) 150.52,92.06 151.05,92.59 157.63,92.59 159.03,91.19 162.79,91.19 164.52,92.92 168.35,92.92 168.79,92.48 v4(168.82,92.48)
  BOTTOM w0.114: U4555.AN1 173.49,92.39 168.9,92.39 v4(168.82,92.48) ; v2(294.16,114.29) 293.15,115.3 289.08,115.3 286.54,112.75 276.74,112.75 275.98,113.52 266.37,113.52 265.88,114 265.1,114 264.6,114.5 264.6,114.84 262.74,116.7 259.37,116.7 259.36,116.72 259.35,116.72 258.72,117.35 255.3,117.35 255.08,117.57 252.98,117.57 252.24,116.83 250.25,116.83 243.81,116.83 242.97,116 212.48,116 211.5,115.02 207.89,115.02 207.89,115.02 171.71,115.02 167.29,110.59 167.29,106.67 v2(167.42,106.54) ; v2(150.21,92.06) 150.21,89.77 v1(150.34,89.65) Q4759.6 149.32,88.39 R4797.2
PCH_3M_SMDATA: length 177.3
  TOP w0.114: v2(168.3,106.32) 168.29,106.31 168.29,105.28 169.18,104.4 169.18,102.82 169.18,98.45 170.39,97.24 170.39,94.45 169.72,93.78 169.72,90.09 v2(169.81,90.01) ; U400.31 292.57,113.95 v2(292.49,114.03)
  L5 w0.114: v3(154.93,87.38) 154.95,87.38 156.25,88.68 159.42,88.68 160.15,87.95 162.62,87.95 163.81,89.14 163.81,89.98 164.75,90.92 168.9,90.92 v2(169.81,90.01)
  BOTTOM w0.076: v2(169.81,90.01) 169.89,90.1 173.54,90.1 U4555.AK1
  BOTTOM w0.114: v2(292.49,114.03) 291.86,114.67 289.08,114.67 286.8,112.39 276.59,112.39 275.83,113.14 275.4,113.14 275.39,113.15 266.21,113.15 266,113.36 265.73,113.63 264.95,113.63 263.86,114.72 263.28,114.72 262.06,115.94 260.01,115.94 259.11,115.94 259.06,115.99 259.05,115.99 258.58,116.46 244.46,116.46 243.27,115.27 212.28,115.27 211.65,114.65 207.74,114.65 172.37,114.65 167.71,109.98 167.71,107.3 168.3,106.71 v2(168.3,106.32) ; Q4759.3 153.29,87.09 R4884.2 154.09,87.66 154.67,87.66 154.93,87.4 v3(154.93,87.38)
PCH_3S_SMCLK: length 497.2
  TOP w0.114: v2(235.74,89.55) 235.74,89.23 235.95,89.02 CN4920.53 ; CN200.4 101.05,90.51 99.73,91.83 v3(99.73,92.44) ; v4(200.41,141.22) 200.45,141.22 201.84,142.61 217.08,142.61 218.53,144.06 218.53,144.71 220.61,146.78 231.83,146.78 233.17,145.44 239.89,145.44 240.96,144.37 243.97,144.37 245.17,145.57 245.48,145.57 248.79,145.57 249.68,144.69 250.06,144.69 251.01,143.74 259.9,143.74 261.3,142.34 264.05,142.34 v2(267.09,139.3) ; v2(76.49,90.28) R3082.1
  L3 w0.102: v2(267.09,139.3) 267.66,139.88 267.66,142.59 260.87,149.38 257.14,149.38 253.93,152.59 253.93,159.6 251.48,162.06 192.61,162.06 185.96,155.41 177.1,155.41 169.5,163 141.1,163 130.14,152.04 119.07,152.04 110.14,143.11 v2(110.14,141.84) 110.61,141.37 110.61,140.92 109.28,139.58 109.28,133.06 112.58,129.75 112.58,104.48 113.21,103.85 v2(113.47,103.85) ; v3(99.73,92.44) 98.29,91.01 94.77,91.01 94.35,91.43 90.51,91.43 89.02,89.94 80.21,89.94 80,89.73 80,89.73 79.65,89.38 76.75,89.38 76.49,89.65 v2(76.49,90.28)
  L5 w0.114: v2(240.91,97.67) 240.34,97.67 239.3,96.63 239.3,92.57 236.28,89.55 v2(235.74,89.55)
  L6 w0.114: v2(240.91,97.67) 239.92,98.66 239.92,99.54 240.92,100.54 241.28,100.54 242.91,102.17 244.58,102.17 245.65,103.24 246.79,103.24 247.05,103.49 247.05,104.14 254.47,111.56 254.47,112.36 262.03,119.92 262.03,124.65 267.74,130.36 267.74,138.65 v2(267.09,139.3) ; v2(113.47,103.85) 113.57,103.74 115.21,103.74 118.79,107.33 124.22,107.33 126.27,105.28 135.93,105.28 141.06,100.14 141.42,99.79 141.42,95.84 145.7,91.55 146.97,91.55 151.54,86.98 v2(151.54,85.1)
  BOTTOM w0.114: R4835.1 153.4,85.2 R4913.2 152.93,85.2 152.75,85.38 Q4752.1 151.82,85.38 v2(151.54,85.1) ; v2(110.14,141.84) 110.78,141.21 123.04,141.21 123.3,141.46 CN4125.202 ; v4(200.41,141.22) 200.3,141.33 CN4100.202 ; v3(99.73,92.44) 99.98,92.7 99.98,95.59 99.41,96.16 99.41,100.98 101.21,102.78 101.28,102.84 107.63,102.84 108.29,102.18 112.07,102.18 112.96,103.08 112.96,103.62 113.19,103.85 v2(113.47,103.85)
PCH_3S_SMCLK_SM: length 55.1
  TOP w0.114: v3(74.71,142.48) 74.2,142.99 74.2,147.43 73.28,148.35 CN9021.6 ; CN9000.4 73,106.48 72.42,105.9 v2(72.42,105.65)
  L3 w0.102: v3(74.71,142.48) 74.84,142.35 76.36,142.35 76.68,142.03 76.68,136.57 78.65,134.61 78.65,121.4 70.9,113.65 70.9,110.6 72.04,109.46 72.04,106.03 v2(72.42,105.65)
PCH_3S_SMDATA: length 502.1
  TOP w0.114: v2(74.28,90.36) 74.28,90 R3083.1 ; v4(201.1,141.12) 201.1,141.35 201.99,142.24 217.33,142.24 218.92,143.83 218.92,144.57 220.76,146.42 231.68,146.42 233.02,145.08 239.5,145.08 240.7,143.88 244,143.88 245.33,145.2 248.64,145.2 249.52,144.32 249.9,144.32 250.86,143.37 259.75,143.37 261.14,141.97 263.66,141.97 v2(267.09,138.54) ; v2(100.41,92.44) 100.41,91.83 101.55,90.69 CN200.5 ; CN4920.51 235.93,88.52 235.13,89.32 v2(235.13,89.55)
  L3 w0.102: v2(113.44,103.24) 113.06,103.24 112.2,104.1 112.2,128.99 108.92,132.27 108.92,139.86 v2(110.14,141.08) 109.63,141.59 109.63,143.11 118.92,152.4 119.22,152.4 130,152.4 140.7,163.1 140.96,163.36 169.65,163.36 177.24,155.76 185.81,155.76 192.46,162.41 251.62,162.41 254.29,159.75 254.29,152.74 257.29,149.74 261.02,149.74 268.01,142.74 268.01,139.55 267.09,138.62 v2(267.09,138.54) ; v2(100.41,92.44) 98.62,90.65 94.39,90.65 94,91.04 90.63,91.04 89.17,89.58 88.87,89.58 87.84,89.58 80.35,89.58 80,89.23 79.8,89.02 79.5,89.02 79.5,89.02 75.58,89.02 74.28,90.33 v2(74.28,90.36)
  L5 w0.114: v2(239.55,97.67) 238.69,96.81 238.69,92.85 236,90.16 235.57,90.16 235.13,89.72 v2(235.13,89.55)
  L6 w0.114: v2(239.55,97.67) 239.35,97.88 239.35,99.73 240.7,101.08 241.15,101.08 244.29,104.22 245.75,104.22 252.55,111.02 252.55,112.23 257.39,117.08 258.25,117.08 261.35,120.18 261.35,124.89 267.09,130.63 v2(267.09,138.54) ; v2(113.44,103.24) 113.58,103.38 115.36,103.38 118.93,106.94 123.88,106.94 125.92,104.91 135.77,104.91 141.05,99.63 141.05,95.57 145.57,91.04 146.76,91.04 150.47,87.33 150.47,84.63 v2(150.9,84.2)
  BOTTOM w0.114: v2(100.41,92.44) 100.36,92.49 100.36,95.73 99.78,96.31 99.78,100.75 101.51,102.47 107.35,102.47 108.01,101.81 112.27,101.81 113.44,102.98 v2(113.44,103.24) ; v2(110.14,141.08) 110.52,140.7 123.36,140.7 123.9,141.24 CN4125.200 ; v4(201.1,141.12) 200.9,141.32 CN4100.200 ; v2(150.9,84.2) 150.78,84.08 Q4752.4 148.94,84.08 R4828.2 148.45,84.54 R4836.1
PCH_3S_SMDATA_SM: length 55.6
  TOP w0.114: CN9000.5 73.5,106.98 v2(73.44,106.92) ; v3(74.71,141.21) 73.82,142.1 73.82,146.89 72.86,147.85 CN9021.7
  L3 w0.102: v2(73.44,106.92) 72.93,107.43 72.93,114.54 79.41,121.02 79.41,135.11 77.63,136.89 77.63,141.97 76.87,142.73 75.34,142.73 75.09,142.99 74.2,142.99 74.07,142.86 74.07,141.84 v3(74.71,141.21)
PCH_GPIO9: length 18.7
  BOTTOM w0.076: U4555.AM3 174.84,91.56 174.51,91.89 173.73,91.89 173.73,91.89 173.1,91.89 172.98,92 172.41,92 172.08,91.67
  BOTTOM w0.102: 172.08,91.67 167.55,91.67 167.19,92.03 166.59,92.03 165.04,93.57 164.7,93.91 v1(164.42,93.91) 164.33,93.82 161.85,93.82 161.45,94.22 161.45,94.85 160.69,95.62 159.15,95.62 R4736.2
PCH_JTAG: length 37.9
  TOP w0.102: v3(241.51,88.53) 241.18,88.86 241.18,89.72 R4823.2 240.62,90.28 R4822.1
  BOTTOM w0.102: U4555.AE63 212.16,87.81 217.27,87.81 221.39,91.93 223.91,91.93 226.78,94.8 232.75,94.8 238.66,88.89 239.18,88.89 239.54,88.53 v3(241.51,88.53)
PCH_KBC_SMCLK: length 164
  TOP w0.114: U300.89 266.48,111.36 266.1,111.75 266.1,111.86 v2(265.49,112.47) ; v3(146.01,106.22) 146.49,105.73 146.49,99.27 146.97,98.79 146.97,96.91 145.37,95.31 145.37,91.23 146.14,90.46 146.14,88.51 v2(146.13,88.5)
  L5 w0.114: v2(265.49,112.47) 265.49,114.23 264.96,114.76 264.96,116.36 263.74,117.58 263.74,121.63 263.2,122.17 v2(263.2,123.81)
  BOTTOM w0.114: v3(146.01,106.22) 146.01,108.54 153.06,115.59 157.31,115.59 158.16,116.44 165.28,123.56 206.15,123.56 207.75,125.15 226.73,125.15 233.67,125.15 235.54,125.15 238.82,125.15 240.23,126.55 258.44,126.55 261.6,123.4 262.79,123.4 v2(263.2,123.81) ; v2(146.13,88.5) 146.12,88.49 145.74,88.49 Q5314.6 144.59,88.27 R310.1
PCH_KBC_SMDATA: length 165.5
  TOP w0.114: v2(146.77,87.36) 147.15,87.74 147.15,90.51 146.69,90.97 146.69,95.77 147.35,96.43 147.35,98.96 147.01,99.3 v2(147.01,105.4) ; v2(266.75,111.8) 266.88,111.66 U300.88
  L5 w0.114: v2(263.75,123.05) 264.56,122.24 264.56,117.79 266.2,116.15 266.2,114.72 266.75,114.17 v2(266.75,111.8)
  BOTTOM w0.114: R311.1 144.75,86.58 147.03,86.58 Q5314.3 147.16,86.96 v2(146.77,87.36) ; v2(263.75,123.05) 263.7,123 261.48,123 258.29,126.18 240.38,126.18 238.97,124.78 237.2,124.78 235.39,124.78 235.39,124.78 235.03,124.78 229.5,124.78 229.49,124.78 226.58,124.78 207.9,124.78 206.29,123.18 165.42,123.18 158.53,116.29 157.47,115.22 157.16,115.22 153.21,115.22 147.01,109.02 v2(147.01,105.4)
PCH_PWROK: length 46.1
  TOP w0.102: v3(151.73,96.42) 151.73,92.93 152.44,92.21 152.44,90.12 153.05,89.52 154.03,89.52 154.34,89.22 154.34,89.06 R4925.1 154.76,88.97 156.24,87.49 156.24,84.53 157.48,83.29 R4722.1
  L3 w0.102: v2(174.14,99.75) 172.67,98.29 158.91,98.29 157.51,96.89 154.8,96.89 154.34,96.42 v3(151.73,96.42)
  BOTTOM w0.076: U4555.AY7 177.66,96.52 177.66,96.81 177.53,96.94 177.53,97.21 177.53,97.54 176.88,98.19 176.15,98.93 175.32,99.75 v2(174.14,99.75)
PCH_SLP_SUS#: length 152.5
  TOP w0.102: U300.75 272.08,112.24 v2(271.94,112.38)
  L5 w0.102: v2(266.22,120.64) 266.22,117.64 268.31,115.55 268.61,115.55 268.61,115.56 271.72,115.56 272.14,115.13 272.14,112.58 v2(271.94,112.38)
  BOTTOM w0.102: v2(266.22,120.64) 265.77,120.18 260.3,120.18 259.44,121.04 258.55,121.04 242.41,121.04 241.61,120.25 209.52,120.25 208.49,119.21 168.02,119.21 158.42,109.61 157.05,109.61 154.82,107.38 154.82,101.1 155.99,99.93 162.97,99.93 163.33,99.58 164.28,99.58 164.62,99.24 164.62,98.62 R340.1 163.48,97.31 163.48,96.59 R4860.2
PCH_SML1CLK: length 37.1
  L5 w0.114: v2(172.02,94.86) 171.84,94.68 166.68,94.68 163.33,91.32 163.33,89.32 162.33,88.31 160.39,88.31 159.59,89.11 154.16,89.11 152.66,87.62 149.49,87.62 v3(148.09,86.22)
  BOTTOM w0.076: v2(172.02,94.86) 172.33,95.16 172.98,95.16 173.27,94.88 174.05,94.88 174.1,94.83 174.4,94.83 174.69,94.53 U4555.AU3
  BOTTOM w0.114: R4827.2 144.8,86.17 148.04,86.17 ; Q4753.1 147.6,85.73 148.04,86.17 ; 148.04,86.17 v3(148.09,86.22)
PCH_SML1DATA: length 35.9
  L6 w0.114: v3(170.1,88.5) 169.46,87.87 167.93,87.87 167.42,88.38 163.83,88.38 162.68,89.52 160.88,89.52 158.48,87.12 158.48,86.54 157.43,85.48 156.9,85.48 v2(155.01,83.59)
  BOTTOM w0.076: U4555.AH3 174.83,89.39 174.58,89.64 174.06,89.64 173.83,89.41 173.83,89.23 173.66,89.06 173.16,89.06 173.05,89.17 171.36,89.17 170.7,88.5 v3(170.1,88.5)
  BOTTOM w0.114: v2(155.01,83.59) 154.86,83.44 150.9,83.44 150.35,82.89 147.89,82.89 146.35,84.42 Q4753.4 144.75,84.42 R4856.1
PCH_TCK: length 37
  TOP w0.102: CN4920.55 238.58,89.53 239.48,88.63 R4808.1 239.89,88.8 v2(239.15,89.54)
  BOTTOM w0.114: v2(239.15,89.54) 238.5,89.54 233.03,95.01 226.69,95.01 224,92.31 221.27,92.31 217.07,88.12 211.91,88.12 211.6,87.81 211.51,87.81 U4555.AE62
PCH_TDI: length 34.4
  TOP w0.076: R4891.2 212.55,88.5 v1(213.42,87.64) 214.07,86.99 v2(214.07,86.86)
  TOP w0.102: v2(232.8,91.41) 233.42,90.78 233.42,89.77 233.17,89.53 CN4920.56 ; v2(225.08,89.83) 225.08,89.91 226.84,91.66 Q4921.6
  L6 w0.102: v2(232.8,91.41) 231.19,91.41 230.41,92.19 227.82,92.19 225.46,89.83 v2(225.08,89.83) 222.46,89.83 219.92,87.29 214.5,87.29 v2(214.07,86.86)
  BOTTOM w0.076: U4555.AD61 211.12,86.77 211.64,86.77 211.8,86.93 211.81,86.93 211.81,87.12 212.04,87.35 212.56,87.35 212.56,87.35 212.59,87.35 212.69,87.45 213.48,87.45 v2(214.07,86.86)
PCH_TDO: length 35.2
  TOP w0.076: R4807.2 211.32,87.31 v3(211.18,87.44)
  TOP w0.102: v2(233.59,92.49) 233.82,92.25 233.82,89.4 232.95,88.52 CN4920.52 ; v2(224.95,91.66) Q4920.6
  L5 w0.102: v2(224.95,91.66) 224.02,91.66 219.87,87.51 211.25,87.51 v3(211.18,87.44)
  L6 w0.102: v2(233.59,92.49) 233.59,93.79 232.47,94.9 229.29,94.9 226.05,91.66 v2(224.95,91.66)
  BOTTOM w0.076: U4555.AE61 210.86,87.76 v3(211.18,87.44)
PCH_TMS: length 33.7
  TOP w0.076: R4886.2 212.29,89.21 213.36,88.13 214.4,88.13 v1(214.79,87.74) 214.79,87.01 v2(214.64,86.86)
  TOP w0.102: Q4921.3 229.76,92.96 230.51,92.21 v2(230.51,91.34) 230.88,90.98 232.91,90.98 233.21,90.67 233.21,90.17 233.07,90.02 CN4920.58
  L6 w0.102: v2(214.64,86.86) 214.82,87.04 220.06,87.04 222.44,89.42 225.82,89.42 228.2,91.81 230.05,91.81 v2(230.51,91.34)
  BOTTOM w0.076: U4555.AD62 211.97,87.52 212.52,87.52 212.62,87.62 213.88,87.62 v2(214.64,86.86)
PCH_WAKE#: length 127.6
  TOP w0.102: U300.105 260.94,105.73 260.89,105.67 260.4,105.67 260.1,105.98 260.1,105.98 v1(259.32,106.77) 258.93,106.38 257.73,106.38 256.83,105.48 v2(256.83,105.14)
  L3 w0.076: v2(184.31,84.57) 183.42,85.46 183.42,85.9 183.04,86.28 182.26,86.28 180.32,88.22 178.49,88.22 177.96,88.76 177.1,88.76 176.56,89.29 v2(176.56,89.29)
  L3 w0.102: v2(236.89,93.38) 238.13,93.38 239.66,94.91 241.23,94.91 243.34,92.8 246.87,92.8 252.64,98.56 v2(252.86,98.56)
  L5 w0.102: v2(236.89,93.38) 236.45,92.95 235.36,92.95 233.74,94.57 229.55,94.57 225.72,90.74 225.72,87.7 222.59,84.57 214.13,84.57 212.16,86.54 210.47,86.54 208.75,88.25 207.8,88.25 207.4,87.84 189.21,87.84 187.1,85.74 185.48,85.74 v2(184.31,84.57)
  L6 w0.102: v2(159.67,93.1) 160.1,92.67 163.53,92.67 164.65,91.55 170.42,91.55 171.66,90.31 173.36,90.31 174.02,89.65 176.2,89.65 v2(176.56,89.29)
  BOTTOM w0.076: v2(176.56,89.29) 176.56,89.36 176.17,89.75 U4555.AJ5
  BOTTOM w0.102: v2(256.83,105.14) 256.7,105.01 256.7,101.58 256.21,101.1 255.7,101.1 253.17,98.56 v2(252.86,98.56) ; v2(159.67,93.1) 159.34,93.43 R4747.2
PCI_3S_CLKRUN#: length 180.8
  TOP w0.102: v4(162.03,83.47) 162.03,83.97 162.52,84.46 162.52,89.8 v1(162.19,90.13) 162.52,90.46 162.52,96.19 160.28,98.43 158.85,98.43 158.85,98.43 158.55,98.43 156.85,100.14 156.48,100.5 156.48,103.14 159.4,106.06 159.4,107.95 v2(159.39,107.96) ; U300.55 277.59,105.42 276.36,105.42 275.88,105.9 v2(275.88,106.28)
  L5 w0.102: v2(266.66,115.56) 267.11,115.1 267.11,112.76 269.22,110.66 271.16,110.66 275.53,106.28 v2(275.88,106.28)
  L6 w0.102: v2(175.97,83.54) 175.95,83.57 172.22,83.57 171.46,82.81 171.46,82.74 171.1,82.38 170.46,82.38 170.13,82.7 166.71,82.7 166.18,82.17 163.89,82.17 162.59,83.47 v4(162.03,83.47)
  BOTTOM w0.076: v2(175.97,83.54) 175.97,83.83 U4555.V5
  BOTTOM w0.102: v4(162.03,83.47) 160.99,83.47 160.02,84.44 159.16,84.44 R4727.1 ; v2(266.66,115.56) 266.66,116.16 263.71,119.11 259.86,119.11 259,119.97 251.98,119.97 251.24,119.24 242.81,119.24 242.38,118.81 235.15,118.81 235.13,118.8 211.37,118.8 210.35,117.78 209.03,117.78 168.91,117.78 159.39,108.26 v2(159.39,107.96)
PCI_3S_SERIRQ: length 312.6
  TOP w0.102: v2(279.41,102.97) 279.69,102.97 279.99,102.66 280.79,102.66 R333.2 ; v4(161.28,81.44) 161.28,80.21 160.81,79.74 160.81,78.42 v1(160.86,78.37) 160.86,74.33 160.05,73.52 160.05,69.71 159.67,69.33 158.15,69.33 157.36,68.54 157.36,67.65 157.13,67.42 155.89,67.42 v2(155.38,67.93)
  L3 w0.102: v2(155.38,67.93) 147.61,67.93 143.39,72.15 143.39,73.42 v2(143.75,73.77)
  L5 w0.102: v2(258.32,77.38) 257.49,78.22 250.62,78.22 249.45,77.05 239.13,77.05 238.55,77.63 233.08,77.63 232.65,77.2 228.38,77.2 227.01,75.83 224.04,75.83 222.7,74.48 208.15,74.48 207.03,75.6 206.6,75.6 205.35,76.85 203.7,76.85 203.36,77.19 187.24,77.19 186.5,77.93 186.5,78.28 184.99,79.79 179.39,79.79 178.67,80.51 178.67,81.6 178.09,82.18 175.72,82.18 175.16,82.74 v2(175.16,82.95) ; v2(107.22,139.43) 108.86,137.8 108.86,132.16 108.86,131.57 113.21,127.22 113.21,114.91 115.53,112.59 115.53,96.06 116.87,94.72 116.87,94.1 119.13,91.83 119.76,91.83 120.55,91.04 124.03,91.04 126.98,88.1 130.36,88.1 132.11,86.35 132.11,84.82 137.93,79.01 137.93,76.49 140.75,73.67 143.64,73.67 v2(143.75,73.77)
  L6 w0.102: v2(175.16,82.95) 174.66,82.45 174.11,82.45 173.57,81.91 171.57,81.91 171.28,81.62 169.65,81.62 168.66,80.63 162.65,80.63 161.84,81.44 v4(161.28,81.44)
  BOTTOM w0.076: U4555.T4 175.49,82.57 175.16,82.89 v2(175.16,82.95)
  BOTTOM w0.102: v2(107.22,139.43) 107.48,139.69 107.48,141.98 112.17,146.67 112.17,149.09 117.33,154.24 119.17,154.24 119.57,154.64 119.57,156.48 120.43,157.34 125.8,157.34 127.09,156.04 127.3,155.83 127.3,152.91 127.05,152.66 127.05,151.63 U3500.27 ; v2(258.32,77.38) 258.6,77.66 260.84,77.66 262.92,79.74 262.92,81.65 265.21,83.93 267.11,83.93 268.28,82.76 271.66,82.76 274.1,85.2 274.1,86.85 274.86,87.62 274.86,91.68 274.61,91.93 274.61,97.01 279.41,101.82 v2(279.41,102.97) ; CN375.5 142.22,75.3 v2(143.75,73.77) ; v4(161.28,81.44) 160.99,81.73 159.49,81.73 R4912.1
PCIE_RX2_C_DN: length 130.2
  TOP w0.076: v3(182.09,70.63) 182.09,70.5 182.23,70.37 182.38,70.37 182.73,70.72 182.73,71.69 183.2,72.16 183.2,72.6 182.63,73.17 182.63,77 182.58,77.06 182.38,77.06 182.24,76.93 v2(182.24,76.81)
  TOP w0.114: v2(288.47,72.86) 288.2,73.14 288.2,73.26 288.32,73.39 289,73.39 289.17,73.22 C811.1
  L3 w0.102: v2(288.47,72.86) 288.17,73.16 288.17,73.27 287.88,73.56 286.83,73.56 286.56,73.29 285.68,73.29 285.32,72.93 285.32,71.7 282.17,68.55 278.85,68.55 277.08,66.77 270.14,66.77 269.68,66.32 263.61,66.32 261.75,64.46 256.42,64.46 255.18,63.21 239.69,63.21 239.46,62.99 228.97,62.99 227.73,61.75 219.74,61.75 219.56,61.75 218,60.19 198.64,60.19 197.25,61.59 191.08,61.59 190.12,62.55 186.69,62.55 185.67,63.57 185.67,66.38 183.06,68.99 183.06,69.97 182.63,70.4 182.32,70.4 v3(182.09,70.63)
  BOTTOM w0.076: U4555.F15 181.9,77.16 v2(182.24,76.81)
PCIE_RX2_C_DP: length 130.2
  TOP w0.076: v2(182.25,77.48) 182.5,77.23 182.65,77.23 182.8,77.07 182.8,73.24 183.37,72.67 183.37,72.09 182.9,71.62 182.9,70.66 182.19,69.94 v2(182.15,69.94)
  TOP w0.114: v2(287.86,72.88) 287.97,72.98 287.97,73.36 288.23,73.62 289.01,73.62 C813.1
  L3 w0.102: v2(287.86,72.88) 287.96,72.97 287.96,73.18 287.79,73.35 286.92,73.35 286.65,73.07 285.77,73.07 285.53,72.84 285.53,71.61 282.26,68.33 278.94,68.33 277.17,66.56 270.23,66.56 269.77,66.1 263.7,66.1 261.84,64.24 256.51,64.24 255.27,63 239.78,63 239.55,62.77 229.06,62.77 227.82,61.54 219.65,61.54 218.09,59.98 198.56,59.98 197.16,61.38 190.99,61.38 190.03,62.34 186.6,62.34 185.45,63.49 185.45,66.29 182.84,68.9 182.84,69.88 182.54,70.18 182.39,70.18 v2(182.15,69.94)
  BOTTOM w0.076: v2(182.25,77.48) 181.93,77.81 U4555.G15
PCIE_RX2_DN: length 2.5
  TOP w0.114: C811.2 290.02,73.16 290.29,73.43 290.42,73.43 290.74,73.75 291.56,73.75 291.75,73.56 U800.8
PCIE_RX2_DP: length 2.5
  TOP w0.114: C813.2 290.56,73.9 290.64,73.98 291.66,73.98 291.87,73.76 292.02,73.76 292.15,73.63 U800.7
PCIE_RX3_C_DN: length 186.1
  TOP w0.114: C407.1 288.94,115.9 288.94,116.17 290.13,117.36 291.78,117.36 292.06,117.64 292.06,117.75 v3(291.8,118) ; v2(180.4,77.45) 180.29,77.34 179.94,77.34 179.5,76.9 179.5,73.25 180.01,72.74 180.01,70.62 180.11,70.53 v2(180.11,70.28)
  L3 w0.102: v3(291.8,118) 292.04,117.76 292.04,117.37 291.22,116.54 291.22,112.96 289.95,111.69 289.95,108.47 290.25,108.17 290.25,106.82 290.02,106.59 290.02,102.33 291.04,101.32 291.04,98.65 291.9,97.79 291.9,80.54 289.9,78.53 289.9,72.4 288.16,70.67 287.3,70.67 284,67.37 283.32,67.37 282.37,66.42 278.8,66.42 276.4,64.02 274.84,64.02 271.3,64.02 271.14,64.18 264.03,64.18 262.03,62.19 257.76,62.19 257.35,61.78 240.28,61.78 240.1,61.59 229.6,61.59 228.32,60.32 220.39,60.32 220.39,60.32 220.21,60.32 218.64,58.75 198.12,58.75 196.67,60.2 187.62,60.2 184.82,63 184.82,66.24 181.62,69.44 181.62,70.72 181.2,71.14 180.44,71.14 180.13,70.83 180.13,70.31 v2(180.11,70.28)
  BOTTOM w0.114: U4555.G11 179.95,77.8 180.3,77.45 v2(180.4,77.45)
PCIE_RX3_C_DP: length 186.1
  TOP w0.114: C408.1 289.17,115.77 289.17,116.08 290.22,117.13 291.87,117.13 292.28,117.54 292.28,117.84 v2(292.49,118.04) ; v2(180.37,76.83) 180.37,76.92 180.18,77.11 180.04,77.11 179.73,76.8 179.73,73.34 180.24,72.83 180.24,70.72 180.53,70.42 v3(180.76,70.42)
  L3 w0.102: v2(292.49,118.04) 292.26,117.81 292.26,117.28 291.43,116.45 291.43,112.87 290.16,111.6 290.16,108.56 290.47,108.26 290.47,106.73 290.24,106.5 290.24,102.42 291.26,101.41 291.26,98.74 292.12,97.88 292.12,80.45 290.11,78.44 290.11,72.31 288.25,70.45 287.39,70.45 284.09,67.16 283.41,67.16 282.46,66.2 278.89,66.2 276.49,63.8 274.93,63.8 271.22,63.8 271.05,63.97 264.12,63.97 262.12,61.97 257.85,61.97 257.44,61.56 240.37,61.56 240.19,61.38 229.69,61.38 228.41,60.1 220.3,60.1 218.73,58.53 198.03,58.53 196.58,59.98 187.53,59.98 184.6,62.91 184.6,66.15 181.4,69.35 181.4,70.63 181.11,70.92 180.53,70.92 180.35,70.74 180.35,70.6 180.53,70.42 v3(180.76,70.42)
  BOTTOM w0.114: v2(180.37,76.83) 180.27,76.83 179.95,77.15 U4555.F11
PCIE_RX3_DN: length 4
  TOP w0.114: U400.39 289.01,111.75 288.74,112.02 288.74,114.44 C407.2
PCIE_RX3_DP: length 3.9
  TOP w0.114: U400.38 289.49,112.15 289.32,111.98 289.11,111.98 288.97,112.11 288.97,114.33 289.3,114.65 C408.2
PCIE_RX4_C_DN: length 207.4
  TOP w0.076: v2(181.29,76.81) 181.29,76.97 181.37,77.04 181.62,77.04 181.68,76.99 181.68,75.79 181.6,75.72 181.6,72.31 181.41,72.12 181.41,69.63 181.14,69.35 180.78,69.35 180.7,69.44 180.7,69.57 v2(180.87,69.75)
  L3 w0.102: v2(180.87,69.75) 180.73,69.6 180.73,69.34 183.88,66.19 183.88,59.12 184.36,58.63 195.8,58.63 197.09,57.35 219.89,57.35 221.21,58.67 228.65,58.67 230.18,60.2 240.77,60.2 240.96,60.38 258.11,60.38 258.53,60.79 262.63,60.79 263.79,61.96 271.23,61.96 271.89,62.62 277.24,62.62 278.34,63.71 283.12,63.71 285.12,65.72 285.12,66.23 288.07,69.17 288.84,69.17 291.47,71.81 291.47,76.54 294.25,79.32 294.25,95.25 297.28,98.27 297.28,104.36 297.53,104.62 297.53,106.52 296.83,107.22 296.83,112.16 296.32,112.67 296.32,117.84 297.8,119.32 298.4,119.32 301.09,122.01 309.06,122.01 309.3,122.26 v3(309.3,122.34)
  BOTTOM w0.076: U4555.F13 180.9,77.15 180.86,77.15 180.75,77.05 180.75,76.91 180.85,76.81 v2(181.29,76.81)
  BOTTOM w0.114: CN1300.43 314.62,121.15 314.48,121.01 313.95,121.01 312.93,122.03 309.55,122.03 309.3,122.28 v3(309.3,122.34)
PCIE_RX4_C_DP: length 207.6
  TOP w0.076: v2(180.32,69.58) 180.71,69.19 181.21,69.19 181.58,69.56 181.58,72.05 181.77,72.24 181.77,75.65 181.84,75.72 181.84,77.06 181.39,77.52 181.38,77.52 v3(181.38,77.51)
  L3 w0.102: v2(180.32,69.58) 180.51,69.39 180.51,69.25 183.66,66.1 183.66,59.03 184.27,58.42 195.71,58.42 197,57.13 219.98,57.13 221.3,58.45 228.74,58.45 230.27,59.98 240.86,59.98 241.05,60.16 258.2,60.16 258.62,60.58 262.72,60.58 263.88,61.75 271.32,61.75 271.98,62.41 277.33,62.41 278.43,63.5 283.2,63.5 285.34,65.63 285.34,66.14 288.16,68.96 288.93,68.96 291.69,71.72 291.69,76.45 294.47,79.23 294.47,95.16 297.49,98.18 297.49,104.27 297.75,104.53 297.75,106.61 297.05,107.31 297.05,112.25 296.54,112.76 296.54,117.75 297.89,119.1 298.49,119.1 301.18,121.8 309.18,121.8 v2(309.3,121.68)
  BOTTOM w0.076: U4555.G13 180.9,77.8 181.19,77.51 v3(181.38,77.51)
  BOTTOM w0.114: v2(309.3,121.68) 309.43,121.8 312.84,121.8 313.86,120.79 314.48,120.79 314.62,120.65 CN1300.41
PCIE_RX6_L0_C_DN: length 174.8
  TOP w0.076: v2(176.53,76.83) 176.53,76.71 176.69,76.55 176.91,76.55 177.1,76.37 177.1,76.03 177.59,75.54 177.59,71.55 176.82,70.77 176.82,69.9 176.96,69.76 177.13,69.76 177.41,69.47 177.41,69.08 177.46,69.04
  TOP w0.114: v2(177.57,68.93) 177.46,69.04
  L3 w0.102: v2(297.87,94.88) 297.87,94.7 297.69,94.51 297.16,94.51 295.13,92.48 295.13,78.98 292.17,76.02 292.17,71.44 291.22,70.49 291.22,68.44 287.8,65.02 286.81,65.02 284.79,63 278.66,63 277.58,61.92 275.66,61.92 275.11,61.38 272.12,61.38 271.2,60.46 264.38,60.46 264.01,60.09 258.84,60.09 258.39,59.64 241.48,59.64 241.26,59.64 241.07,59.45 230.47,59.45 228.99,57.97 221.8,57.97 220.48,56.65 196.8,56.65 195.58,57.87 184.13,57.87 183.08,58.93 183.08,65.96 180.83,68.21 177.53,68.21 177.29,68.45 177.29,68.64 v2(177.57,68.93)
  BOTTOM w0.076: U4555.F5 176.14,77.15 176.46,76.83 v2(176.53,76.83)
  BOTTOM w0.114: v2(297.87,94.88) 297.87,94.78 298.05,94.6 298.29,94.6 299.19,93.7 301.52,93.7 302.23,94.41 303.28,94.41 303.42,94.55 CN1951.43
PCIE_RX6_L0_C_DP: length 174.7
  TOP w0.076: 176.99,69.04 177.25,69.29 177.25,69.4 177.06,69.59 176.89,69.59 176.65,69.84 176.65,70.84 177.43,71.62 177.43,75.47 176.93,75.97 176.93,76.3 176.85,76.39 176.71,76.39 176.53,76.21 v2(176.53,76.17)
  TOP w0.114: v2(176.88,68.93) 176.99,69.04
  L3 w0.102: v2(176.88,68.93) 177.07,68.74 177.07,68.36 177.44,67.99 180.74,67.99 182.86,65.87 182.86,58.84 184.04,57.66 195.49,57.66 196.71,56.44 220.57,56.44 221.89,57.75 229.08,57.75 230.56,59.23 241.16,59.23 241.35,59.43 241.39,59.43 241.39,59.43 258.48,59.43 258.93,59.88 264.1,59.88 264.47,60.25 271.29,60.25 272.21,61.16 275.2,61.16 275.75,61.71 277.67,61.71 278.75,62.79 284.88,62.79 286.9,64.81 287.89,64.81 291.43,68.35 291.43,70.4 292.39,71.35 292.39,75.93 295.35,78.89 295.35,92.39 297.25,94.3 297.73,94.3 v2(297.88,94.15)
  BOTTOM w0.076: U4555.E5 176.32,76.5 176.53,76.29 v2(176.53,76.17)
  BOTTOM w0.114: CN1951.41 303.42,94.05 303.28,94.19 302.33,94.19 301.61,93.47 299.1,93.47 298.19,94.37 298,94.37 297.88,94.25 v2(297.88,94.15)
PCIE_RX6_L1_C_DN: length 184.8
  TOP w0.076: v3(177.58,78.85) 177.66,78.85 178.13,78.38 178.13,77.86 178.24,77.76
  TOP w0.114: 178.24,77.76 178.24,75.83 178.82,75.25 178.82,71.9 177.62,70.7 177.62,70.6 177.82,70.4 v3(177.86,70.4)
  L3 w0.102: v2(299.29,91.41) 299.02,91.41 297.63,90.03 297.63,77.35 296.12,75.84 296.12,74.08 295.31,73.26 295.31,65.54 294.2,64.44 290.85,64.44 289.02,62.61 288.41,62.61 285.48,59.68 285.27,59.68 283.66,58.06 282.43,58.06 282.15,57.78 277.67,57.78 276.68,56.79 267.78,56.79 267.29,57.29 260.59,57.29 260.31,57.01 257.16,57.01 256.04,55.89 256.04,54.97 255.47,54.4 244.27,54.4 241.54,57.14 231.43,57.14 229.75,55.46 223.53,55.46 222.31,54.24 194.71,54.24 193.91,55.04 187.97,55.04 187.35,54.42 182.66,54.42 179.99,57.08 179.99,61 177.22,63.76 177.22,67.17 176.2,68.19 176.2,69.3 176.45,69.54 176.45,70.53 176.78,70.86 177.36,70.86 177.82,70.4 v3(177.86,70.4)
  BOTTOM w0.076: v3(177.58,78.85) 177.32,79.11 U4555.J6
  BOTTOM w0.114: CN1951.29 303.42,91.05 303.28,91.19 301.88,91.19 301.41,91.65 299.54,91.65 v2(299.29,91.41)
PCIE_RX6_L1_C_DP: length 184.8
  TOP w0.076: 177.97,77.76 177.97,78.31 177.9,78.38 177.67,78.38 177.58,78.29 v2(177.58,78.17)
  TOP w0.114: 177.97,77.76 178.01,77.72 178.01,75.73 178.59,75.15 178.59,71.99 177.34,70.74 177.34,70.3 v2(177.23,70.19)
  L3 w0.102: v2(177.23,70.19) 177.43,70.39 177.43,70.46 177.24,70.65 176.87,70.65 176.66,70.44 176.66,69.45 176.42,69.21 176.42,68.28 177.44,67.26 177.44,63.85 180.21,61.09 180.21,57.17 182.75,54.63 187.26,54.63 187.88,55.26 194,55.26 194.8,54.46 222.22,54.46 223.44,55.67 229.66,55.67 231.34,57.35 241.62,57.35 244.36,54.62 255.38,54.62 255.82,55.06 255.82,55.98 257.07,57.22 260.22,57.22 260.5,57.5 267.38,57.5 267.87,57.01 276.59,57.01 277.58,58 282.06,58 282.34,58.28 283.57,58.28 285.18,59.89 285.39,59.89 288.32,62.82 288.93,62.82 290.76,64.65 294.11,64.65 295.09,65.63 295.09,73.35 295.9,74.17 295.9,75.93 297.41,77.44 297.41,90.12 299.29,92 v2(299.29,92.25)
  BOTTOM w0.076: v2(177.58,78.17) 177.52,78.11 176.98,78.11 176.94,78.16 176.94,78.34 177.05,78.46 U4555.H6
  BOTTOM w0.114: v2(299.29,92.25) 299.66,91.88 301.5,91.88 301.97,91.41 303.28,91.41 303.42,91.55 CN1951.31
PCIE_TX2_C_DN: length 125.5
  TOP w0.114: C4822.1 192.86,61.03 193.25,60.64 193.68,60.64 197.14,57.19 197.14,55.87 200.82,52.18 225.71,52.18 226.73,53.2 226.73,55.99 235.36,64.63 235.36,64.88 235.85,65.36 236.65,65.36 v3(237.07,64.95) ; U800.4 293.43,73.34 293.43,74.06 290.97,76.52 288.32,76.52 288.21,76.41 288.21,76.27 288.42,76.06 v2(288.5,76.06)
  L3 w0.102: v2(288.5,76.06) 288.21,76.36 288.21,76.5 287.94,76.77 287.1,76.77 285.95,77.92 280.87,77.92 278.67,75.73 278.67,71.26 276.71,69.3 274.96,69.3 274.48,68.82 265.13,68.82 264.24,67.93 261.35,67.93 259.41,65.99 255.33,65.99 254.51,66.82 245.22,66.82 243.48,65.07 241.96,65.07 241.42,65.61 239.96,65.61 238.87,64.51 237.5,64.51 v3(237.07,64.95)
PCIE_TX2_C_DP: length 125.7
  TOP w0.114: C4823.1 193.09,60.41 193.59,60.41 196.91,57.09 196.91,55.77 200.72,51.95 225.81,51.95 226.96,53.1 226.96,55.9 235.59,64.53 235.59,64.79 235.94,65.14 236.24,65.14 236.41,64.97 v2(236.41,64.95) ; U800.3 293.66,73.35 293.66,74.15 291.07,76.74 288.22,76.74 287.98,76.51 287.98,76.15 v2(287.86,76.03)
  L3 w0.102: v2(236.41,64.95) 237.06,64.3 238.96,64.3 240.05,65.39 241.33,65.39 241.87,64.86 243.56,64.86 245.31,66.6 254.42,66.6 255.24,65.78 259.5,65.78 261.44,67.71 264.33,67.71 265.22,68.6 274.57,68.6 275.05,69.09 276.8,69.09 278.89,71.17 278.89,75.64 280.96,77.71 285.86,77.71 287.01,76.55 287.85,76.55 287.99,76.41 287.99,76.16 v2(287.86,76.03)
PCIE_TX2_DN: length 15.7
  TOP w0.076: 192.16,69.04 192.16,69.05 192.11,69.09 192.11,69.11 192.09,69.13 192.09,69.37 192.39,69.66 192.39,70.75 191.9,71.24 191.9,72.38 v3(191.45,72.83)
  TOP w0.114: C4822.2 191.78,60.84 191.4,60.84 191.06,61.18 191.06,61.46 191.83,62.23 191.83,67.25 192.16,67.58 192.16,69.04
  BOTTOM w0.076: v3(191.45,72.83) 191.5,72.88 191.5,74.15 U4555.B31
PCIE_TX2_DP: length 15.5
  TOP w0.076: 191.93,69.04 191.93,69.44 192.22,69.73 192.22,70.69 191.74,71.17 191.74,71.85 v2(191.5,72.1)
  TOP w0.114: C4823.2 191.58,60.61 191.3,60.61 190.83,61.08 190.83,61.55 191.6,62.32 191.6,67.35 191.93,67.68 191.93,69.04
  BOTTOM w0.076: U4555.A31 191.66,73.66 191.66,73.3 191.83,73.14 191.83,72.43 v2(191.5,72.1)
PCIE_TX3_C_DN: length 155.8
  TOP w0.114: C4834.1 187.58,60.22 187.19,59.84 187.19,59.6 187.34,59.44 188.33,59.44 189.16,60.28 189.16,61.06 v3(188.83,61.4) ; v2(289.08,106.76) 288.82,106.76 288.55,107.03 287.03,107.03 286.34,107.72 286.34,108.41 288.58,110.65 289.44,110.65 289.54,110.55 U400.42
  L3 w0.102: v2(289.08,106.76) 289.08,100.47 290.32,99.24 290.32,98.4 291.32,97.39 291.32,80.82 289.29,78.79 289.29,72.51 288.03,71.26 286.27,71.26 281.91,66.9 278.6,66.9 276.22,64.51 272.01,64.51 271.86,64.67 263.51,64.67 262.35,63.5 257.18,63.5 255.94,62.26 240.08,62.26 239.9,62.07 229.4,62.07 228.13,60.8 220.59,60.8 219.9,60.8 218.38,59.28 198.84,59.28 198.27,59.28 196.87,60.68 189.45,60.68 189.17,60.96 189.17,61.05 v3(188.83,61.4)
PCIE_TX3_C_DP: length 155.8
  TOP w0.114: U400.41 289.83,110.88 288.49,110.88 286.11,108.51 286.11,107.62 286.93,106.81 288.09,106.81 v3(288.35,106.55) ; v2(189.51,61.4) 189.5,61.4 189.39,61.29 189.39,60.18 188.42,59.22 187.25,59.22 186.96,59.5 186.96,59.96 C4831.1
  L3 w0.102: v3(288.35,106.55) 288.67,106.55 288.87,106.35 288.87,100.38 290.1,99.15 290.1,98.31 291.1,97.3 291.1,80.91 289.07,78.88 289.07,72.6 287.94,71.47 286.18,71.47 281.82,67.12 278.51,67.12 276.13,64.73 272.1,64.73 271.95,64.88 263.42,64.88 262.26,63.72 257.09,63.72 255.85,62.47 239.99,62.47 239.81,62.29 229.31,62.29 228.04,61.02 220.68,61.02 219.81,61.02 218.29,59.5 198.76,59.5 198.36,59.5 196.96,60.89 189.54,60.89 189.39,61.05 189.39,61.29 189.5,61.4 v2(189.51,61.4)
PCIE_TX3_DN: length 18.6
  TOP w0.076: v1(191.75,70.11) 190.94,70.93 190.94,71.88 190.95,71.89 190.95,72.47 v2(190.61,72.81)
  TOP w0.114: v1(191.75,70.11) 191.24,69.6 191.24,68.18 191.11,68.05 191.11,62.53 190.57,62 187.53,62 187.4,61.86 187.4,61.28 C4834.2
  BOTTOM w0.076: U4555.C29 191,74.94 191,74.73 191.09,74.64 191.09,73.49 190.61,73.01 v2(190.61,72.81)
PCIE_TX3_DP: length 18.6
  TOP w0.076: v2(190.57,72.05) 190.57,72.02 190.77,71.81 190.77,70.86 190.89,70.74 190.89,70.52 v1(190.48,70.11)
  TOP w0.114: C4831.2 186.93,61.08 187.17,61.32 187.17,61.96 187.44,62.23 190.48,62.23 190.88,62.62 190.88,68.15 191.01,68.28 191.01,69.59 v1(190.48,70.11)
  BOTTOM w0.076: v2(190.57,72.05) 190.7,71.91 190.76,71.91 191.04,72.2 191.04,73.21 191.25,73.42 191.25,74.79 U4555.B30
PCIE_TX4_C_DN: length 191.1
  TOP w0.114: C4832.1 185.44,59.89 185.44,59.45 185.64,59.25 v2(185.77,59.25)
  L3 w0.102: v2(185.77,59.25) 185.75,59.23 185.42,59.23 185.32,59.32 185.32,59.42 185.62,59.71 186.56,59.71 186.99,59.28 195.84,59.28 197.29,57.83 219.35,57.83 220.92,59.4 228.7,59.4 229.98,60.68 240.48,60.68 240.66,60.86 240.76,60.86 257.89,60.86 258.3,61.27 262.41,61.27 264.41,63.27 268.85,63.27 269.51,62.61 271.19,62.61 271.41,62.82 271.69,63.1 276.84,63.1 278.35,64.62 282.52,64.62 284.36,66.46 284.59,66.46 287.88,69.75 288.59,69.75 290.99,72.15 290.99,78.33 292.87,80.21 292.87,99.69 294.16,100.99 294.16,102.53 295.84,104.2 295.84,118.25 300.17,122.58 303.61,122.58 303.95,122.92 306.17,122.92 306.84,123.59 309.93,123.59 311.12,122.41 312.35,122.41 313.85,120.92 313.85,119.77 313.54,119.46 312.3,119.46 312.17,119.6 312.17,119.79 312.25,119.87 v2(312.34,119.87)
  BOTTOM w0.114: v2(312.34,119.87) 312.34,119.62 312.45,119.51 314.53,119.51 314.67,119.65 CN1300.37
PCIE_TX4_C_DP: length 191.1
  TOP w0.114: C4833.1 185.21,59.88 185.21,59.39 185.06,59.24 v3(184.92,59.24)
  L3 w0.102: v2(312.33,119.06) 312.52,119.25 313.63,119.25 314.06,119.68 314.06,121.01 312.44,122.63 311.21,122.63 310.02,123.81 306.75,123.81 306.08,123.14 303.86,123.14 303.52,122.79 300.08,122.79 295.62,118.34 295.62,104.29 293.95,102.61 293.95,101.08 292.65,99.78 292.65,80.3 290.77,78.42 290.77,72.24 288.5,69.97 287.79,69.97 284.5,66.67 284.27,66.67 282.43,64.83 278.26,64.83 276.75,63.32 271.6,63.32 271.19,62.91 271.1,62.82 269.6,62.82 268.94,63.49 264.32,63.49 262.32,61.49 258.21,61.49 257.8,61.08 240.67,61.08 240.57,61.08 240.39,60.89 229.89,60.89 228.61,59.62 220.83,59.62 219.26,58.05 197.38,58.05 195.93,59.5 187.08,59.5 186.65,59.93 185.53,59.93 185.11,59.51 185.11,59.43 v3(184.92,59.24)
  BOTTOM w0.114: CN1300.35 314.67,119.15 314.53,119.29 312.55,119.29 v2(312.33,119.06)
PCIE_TX4_DN: length 19.3
  TOP w0.076: v2(189.8,72.76) 190.16,72.4 190.16,71.85 189.94,71.63 189.94,69.48 190.05,69.37
  TOP w0.114: C4832.2 185.61,61.25 185.61,62.51 185.89,62.8 186.17,62.8 v1(186.67,62.29) 187.08,62.7 187.16,62.7 187.19,62.72 190.18,62.72 190.38,62.93 190.38,67.46 190.05,67.79 190.05,69.37
  BOTTOM w0.076: U4555.B29 190.76,74.4 190.01,73.66 190.01,72.98 v2(189.8,72.76)
PCIE_TX4_DP: length 19.4
  TOP w0.076: v2(189.78,72.05) 189.78,69.41 189.85,69.34 189.85,69.31
  TOP w0.114: C4833.2 185.05,61.08 185.38,61.4 185.38,62.6 185.8,63.03 186.14,63.03 v1(186.67,63.56) 187.28,62.95 190.08,62.95 190.15,63.02 190.15,67.37 189.82,67.7 189.82,69.04 189.85,69.06 189.85,69.31
  BOTTOM w0.076: U4555.A29 190.76,73.88 190.66,73.98 190.57,73.98 190.18,73.59 190.18,72.92 190.18,72.92 190.18,72.61 190.18,72.6 190.18,72.04 190.05,71.92 189.85,71.92 189.78,72 v2(189.78,72.05)
PCIE_TX6_L0_C_DN: length 157
  TOP w0.114: v2(182.99,56.37) 183.32,56.7 183.32,59.94 C4818.2
  L3 w0.102: v2(182.99,56.37) 183.29,56.08 183.29,55.73 183.66,55.36 186.49,55.36 186.89,55.75 194.46,55.75 195.27,54.94 221.33,54.94 222.71,56.32 229.62,56.32 231.14,57.83 241.82,57.83 243.2,56.46 250.67,56.46 251.91,57.71 259.61,57.71 259.99,58.09 267.91,58.09 268.42,57.58 275.13,57.58 276.37,58.82 283.03,58.82 287.51,63.31 288.73,63.31 294.47,69.05 294.47,75.18 296.88,77.59 296.88,90.27 298.76,92.15 298.76,94.12 298.99,94.35 v2(299.22,94.35)
  BOTTOM w0.114: CN1951.47 303.44,95.55 303.31,95.69 302.36,95.69 301.15,94.47 299.35,94.47 v2(299.22,94.35)
PCIE_TX6_L0_C_DP: length 157.1
  TOP w0.114: v2(183.78,56.39) 183.55,56.61 183.55,60.02 183.75,60.23 C4819.2
  L3 w0.102: v2(299.23,95.01) 298.82,94.6 298.82,94.49 298.55,94.21 298.55,92.24 296.67,90.36 296.67,77.68 294.25,75.27 294.25,69.14 288.64,63.52 287.42,63.52 282.94,59.04 276.28,59.04 275.04,57.8 268.51,57.8 268,58.31 259.9,58.31 259.52,57.92 251.82,57.92 250.58,56.68 243.29,56.68 241.91,58.05 231.05,58.05 229.54,56.54 222.62,56.54 221.24,55.15 195.36,55.15 194.55,55.97 186.8,55.97 186.4,55.57 183.75,55.57 183.5,55.81 183.5,56.11 v2(183.78,56.39)
  BOTTOM w0.114: v2(299.23,95.01) 299.53,94.7 301.05,94.7 302.27,95.92 303.31,95.92 303.44,96.05 CN1951.49
PCIE_TX6_L0_DN: length 17.4
  TOP w0.114: v2(183.61,71.6) 183.83,71.39 183.83,70.62 182.97,69.77 182.97,68.63 184.62,66.99 184.62,63.9 183.37,62.65 183.37,61.41 C4818.1
  BOTTOM w0.076: 183.56,73.64 183.56,74.09 183.7,74.24 183.87,74.41 183.87,74.63 183.64,74.86 183.5,74.86 183.38,74.74 183.13,74.74 182.93,74.94 182.93,75.08 183.01,75.16 183.15,75.16 183.23,75.08 U4555.C17
  BOTTOM w0.114: 183.56,73.64 183.56,72.7 183.85,72.41 183.85,71.84 v2(183.61,71.6)
PCIE_TX6_L0_DP: length 17.3
  TOP w0.114: v2(184.24,71.64) 184.06,71.46 184.06,70.53 183.2,69.68 183.2,68.73 184.85,67.08 184.85,63.8 183.6,62.55 183.6,61.43 C4819.1
  BOTTOM w0.076: 183.76,73.64 183.76,73.72 183.73,73.76 183.73,74.02 183.77,74.07 184.04,74.34 184.04,74.7 183.06,75.67 182.85,75.67 U4555.D17
  BOTTOM w0.114: 183.76,73.64 183.76,72.78 184.06,72.49 184.06,71.82 v2(184.24,71.64)
PCIE_TX6_L1_C_DN: length 158.8
  L3 w0.102: v3(181.76,59.47) 181.98,59.25 181.98,57.48 182.62,56.84 195.09,56.84 196.28,55.65 220.82,55.65 222.19,57.02 229.34,57.02 230.85,58.53 259.11,58.53 259.73,59.15 270.72,59.15 271.06,58.81 275.07,58.81 276.18,59.93 283.01,59.93 287.09,64.01 288.41,64.01 293.35,68.95 293.35,75.05 296.18,77.88 296.18,91.39 297.14,92.34 297.72,92.34 v2(297.85,92.21)
  BOTTOM w0.114: CN1951.35 303.44,92.55 303.3,92.69 302.38,92.69 302.32,92.75 299.09,92.75 298.73,92.39 298.02,92.39 v2(297.85,92.21) ; v3(181.76,59.47) 181.97,59.69 181.97,60.39 184.39,62.8 184.39,64.38 C4820.2
PCIE_TX6_L1_C_DP: length 158.6
  L3 w0.102: v3(297.85,92.87) 297.85,92.79 297.62,92.56 297.05,92.56 295.97,91.48 295.97,77.97 293.14,75.14 293.14,69.04 288.32,64.22 287,64.22 282.93,60.14 276.09,60.14 274.98,59.03 271.15,59.03 270.81,59.37 259.64,59.37 259.02,58.75 230.76,58.75 229.25,57.23 222.1,57.23 220.73,55.87 196.37,55.87 195.18,57.06 182.71,57.06 182.19,57.57 182.19,59.25 v2(182.42,59.47)
  BOTTOM w0.114: C4821.2 184.61,64.38 184.61,62.7 182.2,60.29 182.2,59.69 v2(182.42,59.47) ; CN1951.37 303.44,93.05 303.3,92.91 302.48,92.91 302.42,92.97 298.99,92.97 298.64,92.62 298.02,92.62 297.85,92.8 v3(297.85,92.87)
PCIE_TX6_L1_DN: length 12.2
  BOTTOM w0.076: U4555.B14 181.83,74.53 182.03,74.7 182.14,74.69 182.19,74.63 182.19,74.42 181.9,74.13 181.9,73.75 181.62,73.47 181.62,72.32 181.41,72.12 181.41,69.27 181.65,69.04
  BOTTOM w0.114: 183.85,66.36 184.06,66.36 184.33,66.08 184.33,65.84 C4820.1 ; 183.85,66.36 184.33,66.84 184.33,67.07 184.22,67.19 183.5,67.19 181.65,69.04 ; 183.85,66.36 v1(183.78,66.36)
PCIE_TX6_L1_DP: length 12.3
  BOTTOM w0.076: U4555.C15 182.47,75.08 182.27,74.91 182.26,74.8 182.35,74.7 182.35,74.35 182.06,74.06 182.06,73.68 181.78,73.4 181.78,72.26 181.58,72.05 181.58,69.34 181.7,69.22 181.72,69.22 181.74,69.2 181.8,69.2 181.97,69.04
  BOTTOM w0.114: C4821.1 184.56,65.94 184.56,66.13 184.79,66.36 184.92,66.36 ; 184.92,66.36 184.56,66.71 184.56,67.17 184.32,67.42 183.59,67.42 181.97,69.04 ; 184.92,66.36 v1(185.05,66.36)
PCIE_WAKE#: length 231.6
  TOP w0.102: v2(285.68,103.49) 287.31,103.49 290.51,106.69 290.63,106.69 290.97,107.02 U400.2 ; v2(245.52,81.39) 245.52,80.37 244.41,79.26 244.41,76.83 244.77,76.46 245.2,76.46 245.26,76.46 246.54,75.19 246.54,74.03 245.7,73.19 245.7,69.99 245.93,69.76 245.93,67.75 245.32,67.14 243.92,67.14 243.57,67.5 v2(243.57,67.78) ; R4934.2 v1(158.4,90.92) 160.43,90.92 160.81,90.54 160.81,89.8 160.42,89.41 160.42,86.9 160.59,86.73 160.59,83.53 160.51,83.45 160.51,81.6 160.92,81.19 160.92,80.4 159.9,79.37 159.9,77.58 v2(159.67,77.35)
  L3 w0.102: v2(263.76,122.21) 263.18,121.63 263.18,112.1 262.29,111.21 262.29,108.06 261.63,107.4 259.14,107.4 258.35,108.19 256.89,108.19 256.32,107.62 256.32,103.49 255.3,102.47 v2(254.16,102.47)
  L5 w0.102: v2(285.68,103.49) 283.79,103.49 281.51,105.78 275.52,105.78 270.99,110.3 267.67,110.3 265.92,112.05 265.92,114.33 265.84,114.42 265.84,115.33 265.84,115.33 265.84,116 264.15,117.69 264.15,121.82 v2(263.76,122.21) ; v2(243.57,67.78) 243.82,68.03 243.82,69.89 239.84,73.87 232.86,73.87 232.4,74.33 229.84,74.33 228.08,72.58 225.53,72.58 224.28,71.33 214.97,71.33 214.36,71.94 207.26,71.94 206,73.19 203.6,73.19 203.02,73.77 188.45,73.77 187.42,72.74 184.06,72.74 183.84,72.96 183.84,73.42 182.92,74.34 182.45,74.34 182.45,74.34 179.02,74.34 178.08,73.41 174.64,73.41 172.7,75.35 170.8,75.35 170.34,75.8 166.7,75.8 166.37,75.47 161.55,75.47 v2(159.67,77.35) ; v2(245.52,81.39) 244.76,82.15 244.76,90.54 246.92,92.7 246.92,94.85 247.94,95.87 v2(248.06,95.87)
  L6 w0.102: v2(254.16,102.47) 251.75,102.47 249.33,100.06 248.06,100.06 247.43,99.43 247.43,96.51 v2(248.06,95.87)
PLAY_MUTE_LED_CNTR: length 104.9
  TOP w0.102: v3(310.93,149.34) 311.64,150.05 R124.1 311.9,149.85 Q125.2 ; U501.1 298.5,62.59 v2(298.69,62.77)
  L5 w0.102: v3(310.93,149.34) 311.7,149.34 314.89,146.14 314.89,133.76 319.69,128.97 319.69,125.33 318.19,123.83 318.19,116.95 317.48,116.24 317.48,110.73 315.72,108.97 315.72,108.3 309.53,102.12 309.53,88.25 308.64,87.36 308.64,82.56 309.1,82.1 309.1,80.2 307.37,78.47 307.37,73.91 307.64,73.65 307.64,70.73 304.45,67.55 304.45,66.91 303.18,65.64 303.18,64.82 303.16,64.8 303.16,64.72 302.61,64.18 299.1,64.18 298.69,63.76 v2(298.69,62.77)
PLT_DET: length 3.5
  TOP w0.102: R309.1 259.21,107.81 259.57,107.45 259.92,107.45 260.33,107.05 v1(260.56,107.05) 260.68,106.93 U300.102
PLT_ID1: length 25.8
  TOP w0.102: R4803.1 157.01,72.63 v2(156.6,72.22)
  BOTTOM w0.076: U4555.J1 172.4,78.86 171.91,78.37 171.23,78.37 170.82,77.96
  BOTTOM w0.102: R4760.1 154.59,73.65 v1(155.1,73.14) 155.19,73.05 155.77,73.05 v2(156.6,72.22) 157.41,71.41 159.85,71.41 161.09,72.65 161.09,73.95 162.24,75.09 165.55,75.09 166.36,75.09 168.43,77.16 169.9,77.16 170.7,77.96 170.82,77.96
PLT_ID2: length 28.2
  TOP w0.102: v2(155.25,74.58) 155.25,74 155.73,73.52 R4804.1
  BOTTOM w0.076: 169.7,77.77 170.59,78.66 170.69,78.66 170.97,78.94 171.5,78.94 172.45,79.89 172.57,80.02 172.91,80.02 173.03,79.9 174.51,79.9 U4555.K3
  BOTTOM w0.102: R4761.1 155.2,74.53 v2(155.25,74.58) 155.25,74.03 156.01,73.26 v1(157,73.26) 157.33,73.59 158.73,73.59 160.64,75.5 161.21,75.5 161.42,75.7 165.8,75.7 166.11,75.7 168.17,77.77 168.34,77.77 169.7,77.77
PLT_ID3: length 30.3
  TOP w0.102: v2(155.05,72.21) 155.05,72.03 156.22,70.85 v1(157.39,70.85) 157.51,70.85 158.23,71.57 R4805.1
  BOTTOM w0.076: 171.26,77.82 171.44,78.01 172.19,78.01 172.58,78.4 173.73,78.4 U4555.J2
  BOTTOM w0.102: R4762.1 154.72,71.87 155.05,72.2 ; 171.26,77.82 170.69,77.26 170.69,75.04 170.34,74.69 165.38,74.69 165.38,74.69 162.41,74.69 161.75,74.04 161.75,72.55 160.21,71.01 159.81,71.01 156.24,71.01 155.05,72.2 ; v2(155.05,72.21) 155.05,72.2
PLT_RST#: length 218
  TOP w0.102: U400.36 290.57,113.44 290.14,113.86 v2(289.68,113.86) ; v2(142.53,99.3) 142.15,99.68 141,99.68 140.86,99.54 Q302.1 ; v2(172.69,104.77) 172.66,104.74 172.66,103.18 v1(172.8,103.03) 173.13,102.7 173.13,101.11 172.63,100.6 172.63,96.47 173.76,95.34 173.76,88.92 174.31,88.37 175.43,88.37 175.73,88.67 176.21,88.67 176.21,88.67 176.37,88.67 176.37,88.67 176.7,88.67 176.73,88.67 v2(177.16,88.24)
  L6 w0.076: 173.68,87.99 173.96,87.99 173.99,88.02 175.47,88.02 175.6,87.9 176.82,87.9 v2(177.16,88.24)
  L6 w0.102: v2(289.68,113.86) 289.04,113.86 284.74,109.56 284.74,108.66 281.08,105 281.08,104.24 281.08,99.98 279.38,98.28 278.13,98.28 276.79,99.63 272.62,99.63 269.78,102.47 269.78,109.71 269.4,110.09 261.55,110.09 v2(261.3,110.35) ; v2(142.53,99.3) 142.97,98.86 142.97,96.55 143.57,95.94 146.06,95.94 147.41,94.59 v2(147.41,92.34) 149.08,94.01 153.85,94.01 154.66,93.19 157.7,93.19 158.48,92.41 158.48,90.19 159.21,89.46 160.29,89.46 160.88,90.05 162.96,90.05 164.26,88.76 167.58,88.76 168.02,88.31 169.18,88.31 169.77,88.9 170.4,88.9 170.45,88.85 171.77,88.85 172.16,88.45 172.16,88.39 172.56,87.99 173.68,87.99
  BOTTOM w0.076: v2(177.16,88.24) 177.16,88.49 U4555.AG7
  BOTTOM w0.102: v2(261.3,110.35) 260.79,110.86 255.42,110.86 254.93,110.37 243.96,110.37 243.85,110.26 243.55,110.26 240.9,110.26 240.77,110.39 238.75,110.39 238.54,110.59 213.93,110.59 213.86,110.59 213.48,110.22 213.48,110.22 210.87,110.22 210.87,110.22 205.9,110.22 205.9,110.22 175.68,110.22 173.34,107.88 173.34,106.74 172.88,106.28 172.88,104.96 v2(172.69,104.77) ; v2(147.41,92.34) 146.5,93.25 145.65,93.25 144.43,94.47 U4700.2
PM_EXTTS#1_R: length 84.9
  TOP w0.102: R4200.2 124.28,140.49 v3(124.49,140.7)
  L5 w0.102: v2(175.42,144.38) 174.66,145.15 166.4,145.15 165.19,143.94 163.42,143.94 162.08,142.61 125.54,142.61 124.49,141.55 v3(124.49,140.7)
  BOTTOM w0.102: v3(124.49,140.7) 124.5,140.71 CN4125.198 ; v2(175.42,144.38) 175.93,144.89 201,144.89 201.5,144.39 CN4100.198
PM_PWROK: length 196.5
  TOP w0.102: R321.1 281.24,110.09 279.82,108.68 279.82,108.39 279.73,108.25 278.85,107.37 278.84,107.37 278.8,107.33 U300.60 274.15,107.33 272.95,106.13 272.95,105.4 269.81,102.26 269.81,100.68 v2(269.06,99.93) ; v2(248.06,97.78) 248.57,97.27 248.57,94.85 247.94,94.22 v1(247.17,94.22) 246.98,94.22 244.46,91.7 243.06,91.7 242.32,90.97 242.32,89.95 242.02,89.65 242.02,88.09 241.29,87.37 241.29,87.36 241.17,87.23 240.4,87.23 C4937.1 239.67,87.52 CN4920.47
  L3 w0.102: v2(241.75,118.4) 242.28,118.4 247.04,113.64 247.04,102.93 248.19,101.78 248.19,99.76 247.81,99.38 247.81,98.03 v2(248.06,97.78)
  L5 w0.102: v2(160.58,91.65) 160.46,91.65 159.15,92.96 159.15,98.55 156.75,100.95 156.75,108.82 158.44,110.51 v2(162.21,110.51)
  L6 w0.102: v2(269.06,99.93) 268.15,99.93 267.21,98.99 257.17,98.99 255.85,100.32 251.24,100.32 248.7,97.78 v2(248.06,97.78)
  BOTTOM w0.102: v2(162.21,110.51) 169.13,117.42 208.89,117.42 210.5,117.42 211.48,118.41 211.89,118.41 211.89,118.4 v2(241.75,118.4) ; R4802.1 161.66,90.35 160.58,91.43 v2(160.58,91.65)
PM_SLP_A: length 8.9
  BOTTOM w0.102: v1(123.68,87.03) 123.68,87.87 123.48,88.07 Q7150.5
  BOTTOM w0.381: Q7152.3 120.68,91.93 121.49,91.13 R7154.2 ; Q7150.2 123.48,90.62 122.97,91.13 R7154.2 ; R7154.2 121.7,90.49 123.48,88.71 Q7150.5
PM_SLP_A#: length 221.1
  TOP w0.102: R2957.1 256.11,115.13 v1(255.3,115.94) 254.23,117.01 v2(253.27,117.01) ; CN4941.6 130.71,76.58 130.07,76.58 129.29,75.8 128.69,75.8 126.65,77.84 126.65,79.23 127.62,80.2 127.62,83.35 123.65,87.31 123.65,87.82 123.35,88.12 122.59,88.12 121.95,88.76 121.95,91.53 v2(120.12,93.36) ; v2(150.53,106.41) 150.53,105.01 152.84,102.7 152.84,102.19 156.28,98.76 156.28,95.72 156.28,95.71 v2(156.28,92.06) 156.92,91.43 157.64,91.43 157.98,91.76 R4718.2 ; U300.93 264.88,111.35 264.66,111.57 v2(264.66,112.07)
  L3 w0.102: v2(252.38,123.43) 253.27,122.54 v2(253.27,117.01) ; v2(120.12,93.36) 120.12,93.08 121.82,91.38 136.41,91.38 137.33,92.31 143.3,92.31 143.95,91.65 155.87,91.65 v2(156.28,92.06)
  L5 w0.102: v2(263.68,115.17) 263.68,114.87 264.66,113.89 v2(264.66,112.07)
  BOTTOM w0.102: Q7152.1 120.03,93.45 v2(120.12,93.36) ; v2(252.38,123.43) 251.85,123.96 241.16,123.96 239.95,122.75 208.59,122.75 207.34,121.5 207.14,121.3 166.4,121.3 157.39,112.28 154.13,112.28 151.04,109.19 151.04,106.79 150.65,106.41 v2(150.53,106.41) ; v2(253.27,117.01) 253.3,116.99 258.57,116.99 259.2,116.36 259.21,116.36 259.22,116.34 262.52,116.34 v2(263.68,115.17)
PR_AOUT_L_AB: length 6.7
  TOP w0.254: v1(306.23,67.63) 305.87,67.63 305.38,67.13 C560.1 304.71,66.59 304.71,65.19 304.17,64.65 304.17,64.4 303.84,64.07 303.26,64.07 302.8,63.61 U501.39
