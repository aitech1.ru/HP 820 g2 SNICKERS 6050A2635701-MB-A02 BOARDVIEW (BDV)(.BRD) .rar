# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Library data of the parts (continued)
L3000 L3001 = CHOKE_4PIN: part number: CHOKE_4PIN-WCM_2012_900T,6014B0264601,LS_200X120X120_4,1.35MM,CHOKE_4PIN,,,,CHOKE-90OHM-25%-330MA-0805-0.35HM-A-100M-TAP; signal model: L4_6014B0264601_WCM_2012_900T; room: Sheet38
L3051-L3053 = IDUT_SINGLE: part number: IDUT_SINGLE-HCI1005F_R12J_M,6014B0162501,LS_100X050X060_2,0.75MM,IDUT_SINGLE,,,,INDUCTOR,120NH,5%,100MHZ,150MA,0402INCH,; signal model: L2_6014B0162501_HCI1005F_R12J_M; room: Sheet37
L3065 L3067 = BEAD_SINGLE: part number: BEAD_SINGLE-BLM15BB470SN1D,6014A0020601,LS_100X050X060_2,0.75MM,BEAD_SINGLE,,,,BEAD,47OHM,1MM*0.5MM; signal model: L2_6014A0020601_BLM15BB470SN1D; room: Sheet36
L3066 = BEAD_SINGLE: part number: BEAD_SINGLE-BLM15BB470SN1D_DY,6014A0020601_DY,LS_100X050X060_2,0.75MM,BEAD_SINGLE,,,,BEAD,47OHM,1MM*0.5MM; signal model: L2_6014A0020601_DY_BLM15BB470SN1D_DY; room: Sheet36
L3068 = IDUT_SINGLE: part number: IDUT_SINGLE-SWF2520CF_4R7K_M,6014B0099601-002,STRIKE-6014B0099601-002,2.25MM,IDUT_SINGLE,,,,INDUCTOR,4.7UH,10%,7.96MHZ,600MA,1008INCH,SMD,TR; signal model: L2_6014B0099601-002_SWF2520CF_4R7K_M; room: Sheet36
L4850 L4851 L4854 L4865 = IDUT_SINGLE: part number: IDUT_SINGLE-2.2UH_20%,6014B0205301,LS_160X080X100_2,1.15MM,IDUT_SINGLE,,,,INDUCTOR,2.2UH,20%,7.96MHZ,560MA,0603MM,SMD,TR; signal model: L2_6014B0205301_2_2uH_20%; room: Sheet29
L6000 = CHOKE_2PIN: part number: CHOKE_2PIN-ETQP3W4R7WFN,6014B0166902,LS_700X660X300_2_555,3.15MM,CHOKE_2PIN,4.7UH,5.5A_35M_15%,7X6.6X3,INDUCTOR,4.7UH,20%,100KHZ,5.5A,7X6.6X3MM,SMD,TR; signal model: L2_6014B0166902_ETQP3W4R7WFN; room: Sheet5
L6035 = FILTER: part number: FILTER-NFE31PT222Z1E9L,60140EC0030T,EMIS_NFM60R,1.778MM,FILTER,FILTER EMI 6A SMD 1206INCH 3P TR; signal model: L4_60140EC0030T_NFE31PT222Z1E9L; room: Sheet16
L6100 L6150 = IDUT_SINGLE: part number: IDUT_SINGLE-PCMC063T-1R5MN,6014B0026101-006,OBERONC-6014B0026101-006,3.15MM,IDUT_SINGLE,,,,INDUCTOR,1.5UH,20%,100KHZ,9A,7.3X6.6X3.0MM,SMD,TR; signal model: L2_6014B0026101-006_PCMC063T-1R5MN; room: Sheet7
L6200 = CHOKE_4PIN_2PIN: part number: CHOKE_4PIN_2PIN-PAN_ETQP3W1R0WFN_4P,6014B0166901,LS_700X660X300_4,3.15MM,CHOKE_4PIN_2PIN,1.0UH,11.8A_6.9M_15%,7X6.6X3,INDUCTOR,1.0UH,20%,100KHZ,11.8A,7X6.6X3MM,SMD,TR; signal model: L4_6014B0166901_ETQP3W1R0WFN; room: Sheet9
L6300 = CHOKE_4PIN_2PIN: part number: CHOKE_4PIN_2PIN-PAN_ETQP3W1R0WFN_4P,6014B0166901,LS_700X660X300_4,3.15MM,CHOKE_4PIN_2PIN,1.0UH,11.8A_6.9M_15%,7X6.6X3,INDUCTOR,1.0UH,20%,100KHZ,11.8A,7X6.6X3MM,SMD,TR; signal model: L4_6014B0166901_ETQP3W1R0WFN; room: Sheet10
L6350 = IDUT_SINGLE: part number: IDUT_SINGLE-NRS5020T1R0NMGJ,6014B0186903,LS_500X500X200_2_340,2.15MM,IDUT_SINGLE,,,,INDUCTOR,1.0UH,30%,100KHZ,3.5A,4.9X4.9X2MM,SMD,TR; signal model: L2_6014B0186903_NRS5020T1R0NMGJ; room: Sheet11
L6450 = IDUT_SINGLE: part number: IDUT_SINGLE-NRS5020T1R0NMGJ,6014B0186903,LS_500X500X200_2_340,2.15MM,IDUT_SINGLE,,,,INDUCTOR,1.0UH,30%,100KHZ,3.5A,4.9X4.9X2MM,SMD,TR; signal model: L2_6014B0186903_NRS5020T1R0NMGJ; room: Sheet12
L6610 = IDUT_4PIN: part number: IDUT_4PIN-PCME063T-R24MS1R195,6014B0228601-001,COMET-6014B0228601-001,3.15MM,IDUT_4PIN,,,,INDUCTOR,0.24UH,+/- 20%,1MHZ,35A,6.6X7.05X3MM,SMD,TR; signal model: L4_6014B0228601-001_PCME063T-R24MS1R195; room: Sheet14
MIC600 MIC601 = SPK0415HM4H_B: part number: SPK0415HM4H_B-KNOWLES_SPK0415HM4H_B_8P,6039B0054101,MICP_KNOW_8_106,1.31MM,,MIC,-27DB,4.00X3.00,OMNI; room: Sheet64
PAD300 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet46
PAD310 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet46
PAD1411 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet51
PAD1700 PAD1950 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet40
PAD2990 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610_NSP,POWERPAD_2_0610_NSP,POWERPAD_2_0610_NSP,0.127MM,POWERPAD_2,POWERPAD_2_0610_NSP; room: Sheet15
PAD6010 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet5
PAD6100 PAD6110 PAD6150 PAD6160 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet7
PAD6200 PAD6210 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet9
PAD6240 PAD6241 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M,POWERPAD1X1M,POWERPAD1X1M,0.559MM,POWERPAD_2,POWERPAD1X1M; room: Sheet9
PAD6242 = POWERPAD_2: part number: POWERPAD_2-POWERPAD1X1M_NSP,POWERPAD1X1M_NSP,POWERPAD1X1M_NSP,0.127MM,POWERPAD_2,POWERPAD1X1M_NSP; room: Sheet9
PAD6300 PAD6310 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet10
PAD6350 PAD6360 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet11
PAD6450 PAD6460 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet12
PAD6610 = POWERPAD_2: part number: POWERPAD_2-POWERPAD_2_0610,POWERPAD_2_0610,POWERPAD_2_0610,0.559MM,POWERPAD_2,POWERPAD_2_0610; room: Sheet14
Q110 Q115 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet57
Q112 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet53
Q113 = NMOS: part number: NMOS-L2N7002WT1G_DY,6015B0104301_DY,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet57
Q114 = PMOS_A: part number: PMOS_A-PM513BA_DY,6015B0145801_DY,TSOT23_292X130X120_3_095,1.35MM,,TRANSISTOR-FET,PEMOS,20V,3A,SOT23,3P,TR; room: Sheet57
Q125 = NMOS_DUAL_C: part number: NMOS_DUAL_C-L2N7002DW1T1G,6015B0098401,TSSC88_200X125X110_6_065-2,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet57
Q300 = PMOS_A: part number: PMOS_A-PM513BA,6015B0145801,TSOT23_292X130X120_3_095,1.35MM,,TRANSISTOR-FET,PEMOS,20V,3A,SOT23,3P,TR; room: Sheet47
Q301 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet47
Q302 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet46
Q320 = NMOS_DUAL_C: part number: NMOS_DUAL_C-L2N7002DW1T1G,6015B0098401,TSSC88_200X125X110_6_065-2,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet47
Q485 = LBSS84LT1G: part number: LBSS84LT1G-LES_LBSS84LT1G_SOT23_3P,6015B0054501,TSSOT23_292X130X111_3_095,1.26MM,,SOT23,0.13A,TRANSISTOR-FET,PEMOS,50V,130MA,SOT23,3P,TR; room: Sheet49
Q486 = NPN_BIAS_R: part number: NPN_BIAS_R-PDTC144EU,6015B0030601,TSOT323_200X125X110_3_065,1.25MM,NPN_BIAS_R,TRANSISTOR,NPN,50V,100MA,SOT323,3P,TR; room: Sheet49
Q487 = NPN_D: part number: NPN_D-LMBT3904LT1G,6015B0048201,TSSOT23_292X130X111_3_096,1.26MM,NPN_D,SOT23,0.2A,TRANSISTOR,NPN,40V,200MA,SOT23,3P,TR; room: Sheet49
Q501 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet54
Q528 = NMOS_DUAL_C: part number: NMOS_DUAL_C-L2N7002DW1T1G,6015B0098401,TSSC88_200X125X110_6_065-2,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet54
Q600 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet55
Q800 Q802 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet56
Q801 = NMOS_A: part number: NMOS_A-PM514BA,6015B0145601,TSOT23_292X130X120_3_095,1.35MM,,TRANSISTOR-FET,NEMOS,20V,3A,SOT23,3P,TR; room: Sheet56
Q1000-Q1002 = NMOS: part number: NMOS-L2N7002WT1G_DY,6015B0104301_DY,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet45
Q1003 = LBSS84LT1G: part number: LBSS84LT1G-LES_LBSS84LT1G_SOT23_3P,6015B0054501,TSSOT23_292X130X111_3_095,1.26MM,,SOT23,0.13A,TRANSISTOR-FET,PEMOS,50V,130MA,SOT23,3P,TR; room: Sheet45
Q1300 = FDC638APZ: part number: FDC638APZ-FDC638APZ,6015B0068901,TSOT_290X160X110_6_095,1.25MM,TRANSISTOR-FET,PEMOS,20V,4.5A,SSOT6,6P,TR; room: Sheet50
Q1301 Q1304 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet50
Q1302 = NMOS_DUAL_C: part number: NMOS_DUAL_C-L2N7002DW1T1G,6015B0098401,TSSC88_200X125X110_6_065-2,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet50
Q1400 = FDC638APZ: part number: FDC638APZ-FDC638APZ_DY,6015B0068901_DY,TSOT_290X160X110_6_095,1.25MM,TRANSISTOR-FET,PEMOS,20V,4.5A,SSOT6,6P,TR; room: Sheet51
Q1401 = NMOS: part number: NMOS-L2N7002WT1G_DY,6015B0104301_DY,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet51
Q1402 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet51
Q1950 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet40
Q2971 = FDC638APZ: part number: FDC638APZ-FDC638APZ,6015B0068901,TSOT_290X160X110_6_095,1.25MM,TRANSISTOR-FET,PEMOS,20V,4.5A,SSOT6,6P,TR; room: Sheet15
Q4100 = NMOS: part number: NMOS-BSS138LT1,6015B0082001,TSSOT23_292X130X111_3_095,1.26MM,NMOS,,,TRANSISTOR,NEMOS,50V,200MA,SOT23,3P,TR; room: Sheet32
Q4101 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet32
Q4102 = NPN_B: part number: NPN_B-MMBT4401,6015B0037801,TSOT23_290X130X110_3_096,1.25MM,NPN_B,TRANSISTOR NPN 40V 600MA SOT23 3P TR; room: Sheet32
Q4300 Q5314 = NMOS_DUAL_C: part number: NMOS_DUAL_C-L2N7002DW1T1G,6015B0098401,TSSC88_200X125X110_6_065-2,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet19
Q4501 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet21
Q4505 = NMOS_C: part number: NMOS_C-DIODES_DMG3414U_7,6015B0129301,TSSOT23_290X130X120_3_095,1.35MM,NMOS_C,TRANSISTOR-FET,NEMOS,20V,4.2A,SOT23,3P,TR; room: Sheet29
Q4700 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet23
Q4752 Q4753 Q4759 = NMOS_DUAL_C: part number: NMOS_DUAL_C-L2N7002DW1T1G,6015B0098401,TSSC88_200X125X110_6_065-2,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet22
Q4754 Q4755 = LBSS84LT1G: part number: LBSS84LT1G-LES_LBSS84LT1G_SOT23_3P,6015B0054501,TSSOT23_292X130X111_3_095,1.26MM,,SOT23,0.13A,TRANSISTOR-FET,PEMOS,50V,130MA,SOT23,3P,TR; room: Sheet27
Q4756 Q4831 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet27
Q4920 Q4921 Q4926 = NMOS_DUAL_C: part number: NMOS_DUAL_C-L2N7002DW1T1G,6015B0098401,TSSC88_200X125X110_6_065-2,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet20
Q4942 = NMOS_DUAL_C: part number: NMOS_DUAL_C-L2N7002DW1T1G,6015B0098401,TSSC88_200X125X110_6_065-2,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet29
Q5000 = NPN_D: part number: NPN_D-LMBT3904LT1G,6015B0048201,TSSOT23_292X130X111_3_096,1.26MM,NPN_D,SOT23,0.2A,TRANSISTOR,NPN,40V,200MA,SOT23,3P,TR; room: Sheet19
Q5301 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet34
Q5401 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet35
Q6000 = NMOS_4D3S: part number: NMOS_4D3S-FDMC8884,6015B0086301,MOSFET_300X300X112_8_065,1.25MM,NMOS_4D3S,TRANSISTOR-FET,NEMOS,30V,10A,POWER33,8P,TR; room: Sheet5
Q6001 = NMOS_4D3S_SCH: part number: NMOS_4D3S_SCH-FDMC7692S,6015B0105101,MOSFET_300X300X112_8_065,1.27MM,NMOS_4D3S_SCH,,,TRANSISTOR-FET,NEMOS,30V,12.5A,MLP,8P,TR; room: Sheet5
Q6009 = NMOS_DUAL_C: part number: NMOS_DUAL_C-L2N7002DW1T1G,6015B0098401,TSSC88_200X125X110_6_065-2,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet5
Q6010 Q6012 = PEMOS_SCH_2: part number: PEMOS_SCH_2-ALPHA_AON7403L_DFN_8P,6015B0093301,MOSFET_300X300X112_8_065,1.27MM,,TRANSISTOR-FET,PEMOS,30V,8A,DFN,8P,TR; room: Sheet5
Q6011 = NMOS_4D3S: part number: NMOS_4D3S-RQ3E080BNFU7TB,6015B0135301,MOSFET_300X300X112_8_065,1.27MM,NMOS_4D3S,TRANSISTOR-FET,NEMOS,30V,8A,HSMT8,8P,TR; room: Sheet5
Q6900 Q6903 = PNP_A: part number: PNP_A-PMBT3906,6015B0054301,TSOT23_290X130X110_3_095,1.25MM,PNP_A,,,TRANSISTOR PNP 40V 100MA SOT23 3P TR; room: Sheet6
Q6901 = NPN_D: part number: NPN_D-LMBT3904LT1G,6015B0048201,TSSOT23_292X130X111_3_096,1.26MM,NPN_D,SOT23,0.2A,TRANSISTOR,NPN,40V,200MA,SOT23,3P,TR; room: Sheet6
Q6902 = LBSS84LT1G: part number: LBSS84LT1G-LES_LBSS84LT1G_SOT23_3P,6015B0054501,TSSOT23_292X130X111_3_095,1.26MM,,SOT23,0.13A,TRANSISTOR-FET,PEMOS,50V,130MA,SOT23,3P,TR; room: Sheet6
Q6998 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet6
Q7002 Q7101 Q7152 Q7154 Q7155 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet15
Q7050 Q7100 Q7151 = NMOS_4D1S: part number: NMOS_4D1S-ALPHA_AO6424L_TSOP_6P,6015B0135001,TSOP_290X160X125_6_095,1.4MM,NMOS_4D1S,TSOP,5A,TRANSISTOR-FET,NEMOS,30,5A,TSOP-6L,6P,TR; room: Sheet15
Q7051 Q7056 Q7150 = NMOS_DUAL_C: part number: NMOS_DUAL_C-L2N7002DW1T1G,6015B0098401,TSSC88_200X125X110_6_065-2,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet15
Q7153 = NMOS_4D3S: part number: NMOS_4D3S-RQ3E150BNFU7TB,6015B0157801,MOSFET_300X300X112_8_065,1.27MM,NMOS_4D3S,TRANSISTOR-FET,NEMOS,30V,15A,HSMT8,8P,TR; room: Sheet15
Q7350 = NMOS_DUAL_C: part number: NMOS_DUAL_C-L2N7002DW1T1G,6015B0098401,TSSC88_200X125X110_6_065-2,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet17
Q7351 Q7353 = NMOS_4D3S: part number: NMOS_4D3S-RQ3E100BNFU7TB,6015B0134801,MOSFET_300X300X112_8_065,1.27MM,NMOS_4D3S,TRANSISTOR-FET,NEMOS,30V,10A,HSMT8,8P,TR; room: Sheet17
Q7352 Q7355 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet17
Q9031 = NMOS: part number: NMOS-L2N7002WT1G,6015B0104301,TSSOT323_200X125X100_3_065,1.15MM,NMOS,,,TRANSISTOR-FET,NEMOS,60V,115MA,SC-70,3P,TR; room: Sheet58
Q9032 = NMOS_DUAL_C: part number: NMOS_DUAL_C-L2N7002DW1T1G,6015B0098401,TSSC88_200X125X110_6_065-2,1.25MM,NMOS_DUAL_C,,TRANSISTOR-FET,NEMOS,60V,115MA,SOT363,6P,TR; room: Sheet58
R100 = RSC_0402: part number: RSC_0402-47_5%_2,60130B4700ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47-5%-1/16W-0402-TAP; signal model: R2_60130B4700ZT_47_5%_2; room: Sheet46
R101 R314 R317 R320 R326 R327 R332 R371 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet46
R103 R301 R398 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet46
R113 R118 = RSC_0402: part number: RSC_0402-47K_5%_2,60130B4730ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47K-5%-1/16W-0402-TAP; signal model: R2_60130B4730ZT_47K_5%_2; room: Sheet53
R115 R126 = RSC_0402: part number: RSC_0402-270_5%_2,6013A0076301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-270-5%-1/16W-0402-TAP; signal model: R2_6013A0076301_270_5%_2; room: Sheet57
R124 R130 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet57
R127 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet57
R135 = RSC_0402: part number: RSC_0402-47K_5%_2_DY,60130B4730ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47K-5%-1/16W-0402-TAP; signal model: R2_60130B4730ZT_DY_47K_5%_2_DY; room: Sheet57
R136 = RSC_0402: part number: RSC_0402-330K_5%_2_DY,60130B33400Z_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-330K-5%-1/16W-0402-TAP; signal model: R2_60130B33400Z_DY_330K_5%_2_DY; room: Sheet57
R300 R302 R315 R316 = RSC_0402: part number: RSC_0402-300_5%_2,6013A0003401,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-300-5%-1/16W-0402-TAP; signal model: R2_6013A0003401_300_5%_2; room: Sheet46
R303 R318 R340-R342 R356 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet46
R304 R305 = RSC_0402: part number: RSC_0402-100K_5%_2_DY,60130B1040ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_DY_100K_5%_2_DY; room: Sheet46
R306 R307 R310 R311 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet46
R309 R312 R313 R322 R324 R325 R329 R330 R363 R373 R385-R388 R391 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet46
R319 R335 R347 R352 R382 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet46
R321 = RSC_0402: part number: RSC_0402-20K_5%_2,6013A0050701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-5%-1/16W-0402-TAP; signal model: R2_6013A0050701_20K_5%_2; room: Sheet46
R323 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet47
R328 = RSC_0402: part number: RSC_0402-43_5%_2,6013A008960C,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-43-5%-1/16W-0402-TAP; signal model: R2_6013A008960C_43_5%_2; room: Sheet46
R331 R355 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet46
R333 R362 R365-R367 R390 R396 = RSC_0402: part number: RSC_0402-33_5%_2,60130B3300ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33-5%-1/16W-0402-TAP; signal model: R2_60130B3300ZT_33_5%_2; room: Sheet46
R334 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet47
R336-R339 = RSC_0402: part number: RSC_0402-15_5%_2_DY,6013B0027201_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,15,5%,1/16W,0402,TR,-55/+125PPM/DEGREEC; signal model: R2_6013B0027201_DY_15_5%_2_DY; room: Sheet46
R343 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.55MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet46
R344 R346 R368 R369 = RSC_0402: part number: RSC_0402-3.3K_5%_2,6013A0051001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-3.3K-5%-1/16W-0402-TAP; signal model: R2_6013A0051001_3_3K_5%_2; room: Sheet46
R345 R370 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet46
R351 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet47
R360 R361 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet46
R372 = RSC_SHORT: part number: RSC_SHORT-SHORT_0603_25,SHORT_0603_25,RSC_160X080X080_2_25_SHORT,0.95MM,RSC_SHORT,SHORT_0603_25; signal model: R2_short_0603_25_short_0603_25; room: Sheet46
R383 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet47
R392-R394 = RSC_0402: part number: RSC_0402-270_5%_2,6013A0076301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-270-5%-1/16W-0402-TAP; signal model: R2_6013A0076301_270_5%_2; room: Sheet47
R400 = RSC_0402: part number: RSC_0402-RSC_0402_DY,RSC_0402_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402_DY; signal model: R2_RSC_0402_DY_RSC_0402_DY; room: Sheet49
R401 = RSC_0402: part number: RSC_0402-3.01K_1%_2,6013A008810W,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-3.01K-1%-1/16-0402-TAP; signal model: R2_6013A008810W_3_01K_1%_2; room: Sheet49
R402 R403 = RSC_0402: part number: RSC_0402-470_5%_2,60130B4710ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-470-5%-1/16W-0402-TAP; signal model: R2_60130B4710ZT_470_5%_2; room: Sheet49
R404 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet49
R405 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet49
R407 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet49
R470-R473 = RSC_0402: part number: RSC_0402-75_1%_2,6013A0050301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-75-1%-1/16W-0402-TAP; signal model: R2_6013A0050301_75_1%_2; room: Sheet49
R485 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet49
R487 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet49
R488 = RSC_0402: part number: RSC_0402-20K_5%_2,6013A0050701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-5%-1/16W-0402-TAP; signal model: R2_6013A0050701_20K_5%_2; room: Sheet49
R489 = RSC_0402: part number: RSC_0402-2.2K_5%_2_DY,6013A0049601_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_DY_2_2K_5%_2_DY; room: Sheet49
R499 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.55MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet49
R501 R509 R511 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet54
R502 R528 = RSC_0402: part number: RSC_0402-20K_1%_2,6013A0015301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-1%-1/16W-0402-TAP; signal model: R2_6013A0015301_20K_1%_2; room: Sheet54
R503 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet54
R504 R505 = RSC_0402: part number: RSC_0402-6.2K_1%_2,6013A0057801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-6.2K,1%-1/16W-0402-TAP; signal model: R2_6013A0057801_6_2K_1%_2; room: Sheet54
R506 R507 = RSC_0402: part number: RSC_0402-3.48K_1%_2,6013A0088205,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-3.48K-1%-1/16W-0402-TAP; signal model: R2_6013A0088205_3_48K_1%_2; room: Sheet54
R510 = RSC_0402: part number: RSC_0402-20K_5%_2,6013A0050701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-5%-1/16W-0402-TAP; signal model: R2_6013A0050701_20K_5%_2; room: Sheet54
R513 = RSC_0402: part number: RSC_0402-47K_5%_2,60130B4730ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47K-5%-1/16W-0402-TAP; signal model: R2_60130B4730ZT_47K_5%_2; room: Sheet54
R514 R516 = RSC_0402: part number: RSC_0402-33_5%_2,60130B3300ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33-5%-1/16W-0402-TAP; signal model: R2_60130B3300ZT_33_5%_2; room: Sheet54
R515 = RSC_0402: part number: RSC_0402-39.2K_1%_2,6013A0092301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-39.2K-1%-1/16W-0402-TAP; signal model: R2_6013A0092301_39_2K_1%_2; room: Sheet54
R517 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet54
R520 R521 = RSC_0805: part number: RSC_0805-0_5%_5,60130BA0003T,RSC_200X125X115_2,1.3MM,RSC_0805,0805,RES-CHIP-0-5%-1/8W-0805-TAP; signal model: R2_60130BA0003T_0_5%_5; room: Sheet54
R529 R530 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet54
R531 = RSC_0402: part number: RSC_0402-5.1K_1%_2,6013A0082001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-5.1K-1%-1/16W-0402-TAP; signal model: R2_6013A0082001_5_1K_1%_2; room: Sheet54
R532-R537 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet54
R550 R551 R558 R559 R602 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet55
R552 R557 R571 R572 = RSC_0402: part number: RSC_0402-39K_1%_2,6013A0085601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-39K-1%-1/16W-0402-TAP; signal model: R2_6013A0085601_39K_1%_2; room: Sheet55
R553 R556 R561-R564 R612 R617 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet55
R560 R565 = RSC_0402: part number: RSC_0402-22K_5%_2_DY,60130B22300Y_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-22K-5%-1/16W-0402-TAP; signal model: R2_60130B22300Y_DY_22K_5%_2_DY; room: Sheet55
R566-R569 = RSC_0402: part number: RSC_0402-30_5%_2,6013B0094201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,30,5%,1/16W,0402,TAP; signal model: R2_6013B0094201_30_5%_2; room: Sheet55
R570 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet55
R603 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet55
R604 R605 = RSC_0402: part number: RSC_0402-22K_5%_2,60130B22300Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-22K-5%-1/16W-0402-TAP; signal model: R2_60130B22300Y_22K_5%_2; room: Sheet55
R618 R619 = RSC_0402: part number: RSC_0402-100K_5%_2_DY,60130B1040ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_DY_100K_5%_2_DY; room: Sheet55
R620 = RSC_0603: part number: RSC_0603-1K_5%_3,60130B10200Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-1K-5%-1/10W-0603-TAP; signal model: R2_60130B10200Z_1K_5%_3; room: Sheet55
R640 R641 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet64
R800 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.55MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet56
R801 = RSC_0402: part number: RSC_0402-6.2K_1%_2,6013A0057801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-6.2K,1%-1/16W-0402-TAP; signal model: R2_6013A0057801_6_2K_1%_2; room: Sheet56
R802 R808 R809 R811 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet56
R803 = RSC_0402: part number: RSC_0402-47K_5%_2,60130B4730ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47K-5%-1/16W-0402-TAP; signal model: R2_60130B4730ZT_47K_5%_2; room: Sheet56
R810 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet56
R1000 R1001 R1010 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet45
R1006 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet45
R1007 R1008 = RSC_0402: part number: RSC_0402-47K_5%_2_DY,60130B4730ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47K-5%-1/16W-0402-TAP; signal model: R2_60130B4730ZT_DY_47K_5%_2_DY; room: Sheet45
R1300 R1307 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet50
R1301 = RSC_0402: part number: RSC_0402-220K_5%_2,6013A0076001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-220K-5%-1/16W-0402-TAP; signal model: R2_6013A0076001_220K_5%_2; room: Sheet50
R1302 R1304 R1315 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet50
R1306 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet50
R1310 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet50
R1311 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet50
R1403 = RSC_0402: part number: RSC_0402-220K_5%_2_DY,6013A0076001_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-220K-5%-1/16W-0402-TAP; signal model: R2_6013A0076001_DY_220K_5%_2_DY; room: Sheet51
R1404 R1408 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet51
R1405 R1410 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet51
R1407 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet51
R1409 R1417 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet51
R1451 = RSC_0402: part number: RSC_0402-47K_5%_2_DY,60130B4730ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47K-5%-1/16W-0402-TAP; signal model: R2_60130B4730ZT_DY_47K_5%_2_DY; room: Sheet51
R1452 = RSC_0402: part number: RSC_0402-100K_5%_2_DY,60130B1040ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_DY_100K_5%_2_DY; room: Sheet51
R1952 R1953 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet40
R1955 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet40
R1956 = RSC_0603: part number: RSC_0603-RSC_0603_DY,RSC_0603_DY,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603_DY; signal model: R2_RSC_0603_DY_RSC_0603_DY; room: Sheet40
R2200 R2201 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet44
R2202 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.55MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet44
R2203 R2204 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet44
R2205 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet44
R2500 = RSC_0402: part number: RSC_0402-1M_5%_2_DY,60130B10500Y_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_DY_1M_5%_2_DY; room: Sheet41
R2511 = RSC_0402: part number: RSC_0402-20K_5%_2,6013A0050701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-5%-1/16W-0402-TAP; signal model: R2_6013A0050701_20K_5%_2; room: Sheet42
R2512 = RSC_0402: part number: RSC_0402-17.8K_1%_2,6013A008840H,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,17.8KOHM,1%,1/16W,0402,TAPMM; signal model: R2_6013A008840H_17_8K_1%_2; room: Sheet42
R2514 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet42
R2515 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet42
R2553 = RSC_0402: part number: RSC_0402-12K_1%_2,6013A0003501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-12K-1%-1/16W-0402-TAP; signal model: R2_6013A0003501_12K_1%_2; room: Sheet41
R2554 R2555 R2558-R2560 R2562-R2564 R2573-R2575 R2590 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet41
R2556 R2557 R2571 R2572 R2593 R2594 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet41
R2561 R2565 R2566 R2568-R2570 R2580 R2581 R2591 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet41
R2567 = RSC_0402: part number: RSC_0402-8.2K_5%_2,6013A0050801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-8.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0050801_8_2K_5%_2; room: Sheet41
R2576 = RSC_0402: part number: RSC_0402-8.2K_5%_2_DY,6013A0050801_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-8.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0050801_DY_8_2K_5%_2_DY; room: Sheet41
R2585 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet41
R2592 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet41
R2950 = RSC_0402: part number: RSC_0402-46.4K_1%_2,6013A0088601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-46.4K-1%-1/16-0402-TAP; signal model: R2_6013A0088601_46_4K_1%_2; room: Sheet18
R2951 = RSC_0402: part number: RSC_0402-35.7K_1%_2,6013B0156401,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,35.7K,1%,1/16W,0402,TR; signal model: R2_6013B0156401_35_7K_1%_2; room: Sheet18
R2952 = RSC_0402: part number: RSC_0402-1K_1%_2,60130B10019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_1K_1%_2; room: Sheet18
R2953 R2956 R7406 R7407 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet18
R2954 R2957 R7414-R7416 = RSC_0402: part number: RSC_0402-3.3K_5%_2,6013A0051001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-3.3K-5%-1/16W-0402-TAP; signal model: R2_6013A0051001_3_3K_5%_2; room: Sheet18
R2955 R7408 R7409 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet18
R2958 = RSC_0402: part number: RSC_0402-13K_1%_2,6013A0088404,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-13K-1%-1/16W-0402-TAP; signal model: R2_6013A0088404_13K_1%_2; room: Sheet18
R2959 = RSC_0402: part number: RSC_0402-41.2K_1%_2,6013A008850R,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-41.2K-1%-1/16-0402-TAP; signal model: R2_6013A008850R_41_2K_1%_2; room: Sheet18
R2960 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet18
R2970 = RSC_0402: part number: RSC_0402-330K_5%_2,60130B33400Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-330K-5%-1/16W-0402-TAP; signal model: R2_60130B33400Z_330K_5%_2; room: Sheet15
R2971 = RSC_0402: part number: RSC_0402-47K_5%_2,60130B4730ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47K-5%-1/16W-0402-TAP; signal model: R2_60130B4730ZT_47K_5%_2; room: Sheet15
R2972 R7050 = RSC_0402: part number: RSC_0402-47_5%_2,60130B4700ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47-5%-1/16W-0402-TAP; signal model: R2_60130B4700ZT_47_5%_2; room: Sheet15
R3001 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet38
R3003 R3008 R3021 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet38
R3009 = RSC_0402: part number: RSC_0402-2K_5%_2,60130B2020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2K-5%-1/16W-0402-TAP; signal model: R2_60130B2020ZT_2K_5%_2; room: Sheet38
R3013 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet38
R3051-R3053 = RSC_0402: part number: RSC_0402-75_1%_2,6013A0050301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-75-1%-1/16W-0402-TAP; signal model: R2_6013A0050301_75_1%_2; room: Sheet37
R3059 R3060 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet37
R3061 R3076 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet36
R3062 R3064 R3077 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet36
R3063 R3075 R3081-R3083 R3092 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet36
R3065 = RES: part number: RES-12K_5%_DY,6013A0002901_DY,RSC_100X050X035_2,0.5MM,,RES-CHIP-12K-5%-1/16W-0402-TAP; room: Sheet36
R3066 R3069 = RSC_0402: part number: RSC_0402-33_5%_2,60130B3300ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33-5%-1/16W-0402-TAP; signal model: R2_60130B3300ZT_33_5%_2; room: Sheet37
R3067 R3074 R3078 R3093-R3095 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet36
R3068 = RSC_0402: part number: RSC_0402-1.2K_1%_2,6013A0067601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1.2K-1%-1/16W-0402-TAP; signal model: R2_6013A0067601_1_2K_1%_2; room: Sheet36
R3071 = RSC_0402: part number: RSC_0402-100K_5%_2_DY,60130B1040ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_DY_100K_5%_2_DY; room: Sheet36
R3301 R3303 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet37
R3302 = RSC_0402: part number: RSC_0402-5.1M_5%_2,6013B0106702,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,5.1M,5%,1/16W,0402,TR; signal model: R2_6013B0106702_5_1M_5%_2; room: Sheet37
R3304 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet37
R3305 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet37
R3501 R3507 R3510 R3516 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet48
R3502 R3503 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet48
R3511 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.55MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet48
R3600 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet52
R4100 R4101 R4114 R4116 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet32
R4103 R4115 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet32
R4104 R4107 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet32
R4105 R4112 R4503 = RSC_0402: part number: RSC_0402-2_1%_2,6013B0172801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,2,1%,1/16W,0402,TR; signal model: R2_6013B0172801_2_1%_2; room: Sheet25
R4106 R4108 R4109 R4122 = RSC_0402: part number: RSC_0402-1.8K_1%_2,6013A0067101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1.8K-1%-1/16W-0402-TAP; signal model: R2_6013A0067101_1_8K_1%_2; room: Sheet32
R4110 R4111 R4136 = RSC_0402: part number: RSC_0402-24.9_1%_2,6013A008740P,RSC_100X050X035_2,0.5MM,RSC_0402,0402,RES-CHIP-24.9-1%-1/16W-0402-TAP; signal model: R2_6013A008740P_24_9_1%_2; room: Sheet25
R4117-R4120 = RSC_0402: part number: RSC_0402-64.9_1%_2,6013A0077101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-64.9-1%-1/16W-0402-TAP; signal model: R2_6013A0077101_64_9_1%_2; room: Sheet32
R4121 = RSC_0402: part number: RSC_0402-330_5%_2,60130B3310ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-330-5%-1/16W-0402-TAP; signal model: R2_60130B3310ZT_330_5%_2; room: Sheet32
R4123 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet32
R4125 R4126 R4200 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet33
R4131 R4132 = RSC_0402: part number: RSC_0402-1.8K_1%_2,6013A0067101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1.8K-1%-1/16W-0402-TAP; signal model: R2_6013A0067101_1_8K_1%_2; room: Sheet33
R4134 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet33
R4301 R4303 R5043 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet19
R4302 = RSC_0402: part number: RSC_0402-22_5%_2,60130B2200ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-22-5%-1/16W-0402-TAP; signal model: R2_60130B2200ZT_22_5%_2; room: Sheet19
R4411 = RSC_0402: part number: RSC_0402-39K_1%_2,6013A0085601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-39K-1%-1/16W-0402-TAP; signal model: R2_6013A0085601_39K_1%_2; room: Sheet19
R4412 = RSC_0402: part number: RSC_0402-150_1%_2,60130B15009Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-150-1%-1/16W-0402-TAP; signal model: R2_60130B15009Y_150_1%_2; room: Sheet19
R4507 R4508 = RSC_0402: part number: RSC_0402-51_5%_2_DY,60130B5100ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-51-5%-1/16W-0402-TAP; signal model: R2_60130B5100ZT_DY_51_5%_2_DY; room: Sheet21
R4509 R4920 = RSC_0402: part number: RSC_0402-51_5%_2,60130B5100ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-51-5%-1/16W-0402-TAP; signal model: R2_60130B5100ZT_51_5%_2; room: Sheet21
R4515 = RSC_0402: part number: RSC_0402-56_5%_2,60130B5600ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-56-5%-1/16W-0402-TAP; signal model: R2_60130B5600ZT_56_5%_2; room: Sheet21
R4516 = RSC_0402: part number: RSC_0402-100K_5%_2_DY,60130B1040ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_DY_100K_5%_2_DY; room: Sheet21
R4517 = RSC_0402: part number: RSC_0402-62_5%_2,6013A008960G,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,62,5%,1/16W,0402,TR; signal model: R2_6013A008960G_62_5%_2; room: Sheet21
R4518 = RSC_0402: part number: RSC_0402-200_1%_2,6013A0023701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200-1%-1/16W-0402-TAP; signal model: R2_6013A0023701_200_1%_2; room: Sheet21
R4519 R4520 = RSC_0402: part number: RSC_0402-49.9_1%_2,6013A0076901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-49.9-1%-1/16W-0402-TAP; signal model: R2_6013A0076901_49_9_1%_2; room: Sheet28
R4521 = RSC_0402: part number: RSC_0402-100_1%_2,6013A0016701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100OHM-1%-1/16W-0402-TAP; signal model: R2_6013A0016701_100_1%_2; room: Sheet30
R4522 = RSC_0402: part number: RSC_0402-100_1%_2,6013A0016701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100OHM-1%-1/16W-0402-TAP; signal model: R2_6013A0016701_100_1%_2; room: Sheet31
R4523 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet28
R4524 = RSC_0402: part number: RSC_0402-75_1%_2,6013A0050301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-75-1%-1/16W-0402-TAP; signal model: R2_6013A0050301_75_1%_2; room: Sheet30
R4525 = RSC_0402: part number: RSC_0402-43_5%_2,6013A008960C,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-43-5%-1/16W-0402-TAP; signal model: R2_6013A008960C_43_5%_2; room: Sheet30
R4526 = RSC_0402: part number: RSC_0402-51_5%_2_DY,60130B5100ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-51-5%-1/16W-0402-TAP; signal model: R2_60130B5100ZT_DY_51_5%_2_DY; room: Sheet20
R4527 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet21
R4534 = RSC_0402: part number: RSC_0402-1K_1%_2_DY,60130B10019Z_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-1%-1/16W-0402-TAP; signal model: R2_60130B10019Z_DY_1K_1%_2_DY; room: Sheet28
R4535 R4701 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.55MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet29
R4540 = RSC_0402: part number: RSC_0402-100_1%_2,6013A0016701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100OHM-1%-1/16W-0402-TAP; signal model: R2_6013A0016701_100_1%_2; room: Sheet21
R4541 = RSC_0402: part number: RSC_0402-120_1%_2,6013B0077801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,120,1%,1/16W,0402,TR,200PPM/DEGREEC; signal model: R2_6013B0077801_120_1%_2; room: Sheet21
R4544 = RSC_0402: part number: RSC_0402-24.9_1%_2,6013A008740P,RSC_100X050X035_2,0.5MM,RSC_0402,0402,RES-CHIP-24.9-1%-1/16W-0402-TAP; signal model: R2_6013A008740P_24_9_1%_2; room: Sheet24
