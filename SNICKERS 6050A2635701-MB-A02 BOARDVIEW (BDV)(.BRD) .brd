# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DPB_PORT_DATA_AUX_DN: length 100.2
  L3 w0.102: v2(315.32,59.38) 315.32,59.24 315.53,59.04 315.75,59.04 315.88,59.17 315.88,60.39 315.54,60.73 315.54,75.23 311.93,78.84 306.74,78.84 306.43,78.53 302.74,78.53 301.29,77.09 300.99,77.09 300.75,76.85 v3(300.75,76.72)
  L6 w0.114: v2(315.32,59.38) 315.32,59.24 315.14,59.07 314.52,59.07 314.15,58.69 314.15,56.73 315.65,55.22 315.65,53.47 316.53,52.59 316.53,37.71 317.95,36.28 317.95,27.05 v3(317.66,26.76)
  BOTTOM w0.114: U5301.27 283.46,78.45 283.32,78.59 283.32,79.12 284.11,79.9 284.11,80.86 285.02,81.78 285.02,83.74 286.26,84.97 291.02,84.97 295.76,80.24 298.3,80.24 298.71,79.82 298.71,78.67 300.39,77 300.56,77 300.75,76.82 v3(300.75,76.72) ; v3(317.66,26.76) 317.66,26.78 318.34,26.1 R3301.2 318.55,25.89 319.18,26.53 319.18,26.78 319.28,26.87 319.65,26.87 319.73,26.95 CN3300.17
DPB_PORT_HPD: length 85.6
  TOP w0.102: v2(289.34,53.45) 289.34,54.47 287,56.8 287,59.6 285.86,60.74 284.36,60.74 284,61.1 284,62.42 v1(283.52,62.9) 282.43,63.99 282.43,64.58 282.86,65.01 282.86,69.33 283.62,70.09 284.13,70.09 284.44,70.39 v2(286.16,70.39)
  L5 w0.102: CN3300.18 322.36,25.14 322.36,24.62 321.85,24.12 320.33,24.12 319.56,24.88 319.56,34.83 315.93,38.46 315.93,51.96 314.06,53.83 306.23,53.83 305.95,54.11 302.71,54.11 302.04,53.45 v2(289.34,53.45)
  BOTTOM w0.102: U5301.48 286.04,70.52 v2(286.16,70.39)
DPC0_C_DN: length 3.6
  BOTTOM w0.114: U5401.7 263.77,72.12 263.69,72.03 262.62,72.03 262,71.41 261.26,71.41 C5402.2
DPC0_C_DP: length 3.6
  BOTTOM w0.114: U5401.6 263.78,71.72 263.69,71.81 262.72,71.81 262.09,71.18 261.26,71.18 C5401.2
DPC0_DN: length 67.1
  L3 w0.102: v2(205.14,72.42) 205.06,72.42 204.69,72.06 204.69,71.6 205.01,71.28 206.54,71.28 207.25,71.99 218.09,71.99 219.97,73.87 221.67,73.87 223.92,76.12 228.8,76.12 229.27,76.59 231.38,76.59 232.7,77.91 237.47,77.91 238.27,78.71 239.19,78.71 240.32,77.58 248.26,77.58 252.32,73.52 257.69,73.52 258.48,72.73 v2(258.61,72.73)
  BOTTOM w0.076: U4555.C51 204.46,75.19 204.74,74.91 204.84,74.76 204.88,74.61 204.88,74.42 204.87,74.39 204.82,74.27 204.82,74.16 204.87,74.03 204.99,73.9
  BOTTOM w0.114: 204.99,73.9 205.26,73.63 205.26,73.46 205.36,73.36 205.57,73.36 205.67,73.26 205.67,73.12 205.57,73.02 205.36,73.02 205.09,72.74 205.09,72.48 v2(205.14,72.42) ; v2(258.61,72.73) 258.63,72.7 258.63,72.34 259.63,71.34 259.95,71.34 260.08,71.47 C5402.1
DPC0_DOCK_DN: length 83.4
  L6 w0.114: v2(270.23,73.94) 270.18,73.89 270.18,73.67 270.24,73.61 270.52,73.61 270.68,73.77 272.42,73.77 272.42,73.77 272.52,73.77 273.58,74.83 274.84,74.83 275.67,75.66 280.48,75.66 282.07,77.25 286.38,77.25 287.9,78.77 289.87,78.77 291.33,80.24 294.73,80.24 295.87,81.37 295.87,97.91 297.27,99.32 297.27,102.5 297.09,102.69 297.09,104.42 298.67,106 301.11,106 304.57,109.47 304.6,109.47 304.61,109.47 305.07,109.47 306.84,111.24 313.54,111.24 315.6,113.29 315.6,113.85 316.01,114.26 316.8,114.26 317.02,114.49 v2(317.02,114.51)
  BOTTOM w0.114: v2(317.02,114.51) 317.02,114.49 317.18,114.33 317.18,114.34 318.21,114.34 318.8,114.93 320.33,114.93 320.6,115.2 CN3601.64 ; U5401.39 269.84,74.12 270.01,73.94 v2(270.23,73.94)
DPC0_DOCK_DP: length 83.2
  L6 w0.114: v3(317.02,113.83) 317.02,113.85 316.86,114.02 316.11,114.02 315.84,113.75 315.84,113.19 313.64,111 306.94,111 305.17,109.23 304.67,109.23 301.21,105.76 298.77,105.76 297.33,104.32 297.33,102.79 297.51,102.6 297.51,99.22 296.11,97.81 296.11,81.27 294.83,80 291.43,80 289.97,78.53 288,78.53 286.48,77.01 282.17,77.01 280.58,75.42 275.77,75.42 274.94,74.59 273.68,74.59 272.62,73.53 272.18,73.53 270.78,73.53 270.62,73.37 270.14,73.37 v2(269.98,73.2)
  BOTTOM w0.114: v2(269.98,73.2) 269.98,73.32 269.58,73.72 U5401.40 ; CN3601.63 318.89,114.7 318.3,114.11 317.28,114.11 317.02,113.85 v3(317.02,113.83)
DPC0_DP: length 67.2
  L3 w0.102: v2(258.14,72.24) 258.14,72.76 257.6,73.3 252.23,73.3 248.17,77.37 240.23,77.37 239.1,78.5 238.36,78.5 237.56,77.7 232.79,77.7 231.47,76.38 229.36,76.38 228.89,75.91 224.01,75.91 221.76,73.66 220.06,73.66 218.18,71.78 207.34,71.78 206.63,71.06 204.92,71.06 204.48,71.51 204.48,72.36 v3(204.4,72.44)
  BOTTOM w0.076: U4555.C50 203.86,75.51 204.13,75.24 204.13,75.06 204.3,74.89 204.48,74.89 204.69,74.69 204.71,74.58 204.71,74.45 204.69,74.39 204.68,74.38 204.66,74.3 204.66,74.08 204.75,73.89 204.75,73.82
  BOTTOM w0.114: v2(258.14,72.24) 258.41,72.24 259.54,71.11 259.83,71.11 C5401.1 ; v3(204.4,72.44) 205.03,73.07 205.03,73.54 204.94,73.63 204.75,73.82
DPC0_PORT_C_DN: length 5.9
  TOP w0.114: C3079.2 87.21,93.3 86.98,93.3 86.37,92.7 86.37,92.32 85.32,91.27 84.54,91.27 84.13,90.87 U3065.7
DPC0_PORT_C_DP: length 5.9
  TOP w0.114: C3078.2 87.49,92.81 87.23,93.08 87.07,93.08 86.6,92.61 86.6,92.22 85.42,91.04 84.63,91.04 84.36,90.77 84.36,90.39 84.44,90.31 84.56,90.31 84.64,90.23 U3065.6
DPC0_PORT_DN: length 226.1
  TOP w0.114: C3079.1 88.34,93.51 88.6,93.26 88.78,93.26 89.99,94.47 93.89,94.47 94.99,93.37 94.99,92.3 96.65,90.64 96.65,89.39 v2(96.83,89.2)
  L6 w0.114: v2(96.83,89.2) 96.65,89.39 96.65,89.6 96.8,89.75 97.64,89.75 98.01,89.38 101.81,89.38 103.18,88.01 107.15,88.01 115.78,79.39 124.03,79.39 124.94,78.47 128.48,78.47 130.49,76.46 130.49,75.75 136.08,70.15 139.12,70.15 143.23,66.04 146.66,66.04 148.71,63.98 160.74,63.98 163.07,61.65 163.67,61.65 170.68,54.64 173.49,54.64 175.79,52.35 228.44,52.35 229.18,53.09 230.85,53.09 232.77,55.01 239.03,55.01 239.79,54.25 247.52,54.25 249.19,52.58 260.73,52.58 261.32,51.99 266.45,51.99 267.83,53.38 267.83,54.63 272.96,59.75 272.96,62.72 274.12,63.89 274.12,67.36 271.49,69.99 270.94,69.99 v2(270.72,70.21)
  BOTTOM w0.114: v2(270.72,70.21) 270.68,70.24 269.75,70.24 269.63,70.12 U5401.49
DPC0_PORT_DP: length 226.3
  TOP w0.114: C3078.1 88.34,92.72 88.64,93.02 88.86,93.02 90.09,94.24 93.79,94.24 94.76,93.27 94.76,92.2 96.42,90.54 96.42,89.25 96.28,89.11 96.08,89.11 v2(95.99,89.2)
  L6 w0.114: v2(95.99,89.2) 96.24,89.2 96.41,89.38 96.41,89.7 96.7,89.99 97.74,89.99 98.11,89.62 101.91,89.62 103.28,88.25 107.25,88.25 115.88,79.63 124.13,79.63 125.04,78.71 128.58,78.71 130.73,76.56 130.73,75.85 136.18,70.39 139.22,70.39 143.33,66.28 146.76,66.28 148.81,64.22 160.84,64.22 163.17,61.89 163.77,61.89 170.78,54.88 173.59,54.88 175.89,52.59 228.34,52.59 229.08,53.33 230.75,53.33 232.67,55.25 239.13,55.25 239.89,54.49 247.62,54.49 249.29,52.82 260.83,52.82 261.42,52.23 266.35,52.23 267.59,53.48 267.59,54.73 272.71,59.85 272.71,62.82 273.88,63.99 273.88,67.26 271.39,69.75 270.98,69.75 v3(270.77,69.53)
  BOTTOM w0.114: U5401.50 269.52,69.72 269.84,70.04 270.29,70.04 270.77,69.56 v3(270.77,69.53)
DPC1_C_DN: length 2.9
  BOTTOM w0.114: C5404.2 261.79,73.43 262.56,73.43 262.75,73.24 263.7,73.24 263.78,73.32 U5401.10
DPC1_C_DP: length 2.9
  BOTTOM w0.114: U5401.9 263.75,72.92 263.66,73.01 262.65,73.01 262.47,73.2 261.76,73.2 C5403.2
DPC1_DN: length 69.4
  L3 w0.102: v4(205.82,72.44) 206.09,72.17 206.29,72.17 206.81,72.69 217.21,72.69 219.11,74.6 221.4,74.6 223.63,76.82 228.51,76.82 228.98,77.29 231.09,77.29 232.49,78.68 234.18,78.68 234.77,79.27 234.77,80.12 235.18,80.53 237.42,80.53 237.76,80.19 244.42,80.19 245.97,78.64 248.19,78.64 249.39,77.44 251.86,74.97 252.9,74.97 253.17,74.7 253.17,74.36 253.31,74.22 253.51,74.22 253.65,74.36 253.65,74.86 253.92,75.12 254.3,75.12 254.57,74.86 254.57,74.36 254.71,74.22 254.91,74.22 255.05,74.36 255.05,74.86 255.32,75.12 255.7,75.12 255.96,74.86 255.96,74.36 256.11,74.22 256.31,74.22 256.45,74.36 256.45,74.86 256.71,75.12 257.4,75.12 258.17,74.36 258.96,74.36 259.5,73.81 259.78,73.81 v2(259.89,73.93)
  BOTTOM w0.114: v4(205.82,72.44) 205.9,72.44 206.11,72.66 206.11,74.67 206.05,74.73 206.05,74.93 U4555.C53 ; C5404.1 260.59,73.46 260.47,73.34 260.18,73.34 259.89,73.63 v2(259.89,73.93)
DPC1_DOCK_DN: length 85.1
  L6 w0.114: v2(269.95,75.94) 270.14,75.76 271.25,75.76 273.08,77.59 274.69,77.59 275.87,76.41 280.19,76.41 281.76,77.98 286.07,77.98 287.71,79.62 289.42,79.62 290.82,81.02 294.08,81.02 295.1,82.04 295.1,96.9 294.23,97.78 294.23,102.87 295.88,104.52 296.15,104.52 298.56,106.93 300.94,106.93 303.54,109.53 303.54,110.75 304.15,111.36 305.21,111.36 305.85,112 312.91,112 314.6,113.69 314.6,113.98 316.34,115.72 316.81,115.72 v2(317,115.91)
  BOTTOM w0.114: v2(269.95,75.94) 269.95,75.76 269.51,75.32 U5401.36 ; CN3601.67 320.41,116.7 320.28,116.56 318.87,116.56 318.01,115.71 317.2,115.71 v2(317,115.91)
DPC1_DOCK_DP: length 85.1
  L6 w0.114: v2(270.04,75.26) 270.29,75.52 271.35,75.52 273.18,77.34 274.59,77.34 275.77,76.17 280.29,76.17 281.86,77.74 286.17,77.74 287.81,79.38 289.52,79.38 290.92,80.78 294.18,80.78 295.34,81.94 295.34,97 294.47,97.88 294.47,102.77 295.98,104.28 296.25,104.28 298.66,106.69 301.04,106.69 303.78,109.43 303.78,110.65 304.25,111.12 305.31,111.12 305.95,111.76 313.01,111.76 314.84,113.59 314.84,113.88 316.44,115.48 316.75,115.48 v3(317.02,115.2)
  BOTTOM w0.114: U5401.37 269.7,74.92 v2(270.04,75.26) ; CN3601.66 320.41,116.2 320.28,116.33 318.96,116.33 318.11,115.48 317.22,115.48 317.02,115.29 v3(317.02,115.2)
DPC1_DP: length 69.4
  L3 w0.102: v3(205.8,71.76) 206,71.95 206,71.95 206.38,71.95 206.9,72.47 217.29,72.47 219.2,74.38 221.49,74.38 223.72,76.6 228.6,76.6 229.07,77.07 231.18,77.07 232.58,78.47 234.27,78.47 234.99,79.18 234.99,80.03 235.27,80.31 237.33,80.31 237.67,79.97 244.33,79.97 245.88,78.42 248.1,78.42 249.3,77.22 249.3,77.22 249.99,76.53 251.77,74.76 252.81,74.76 252.95,74.61 252.95,74.27 253.22,74 253.6,74 253.87,74.27 253.87,74.77 254.01,74.91 254.21,74.91 254.35,74.77 254.35,74.27 254.62,74 255,74 255.27,74.27 255.27,74.77 255.41,74.91 255.61,74.91 255.75,74.77 255.75,74.27 256.02,74 256.4,74 256.66,74.27 256.66,74.77 256.8,74.91 257.31,74.91 258.08,74.14 258.87,74.14 259.42,73.6 v2(259.42,73.34)
  BOTTOM w0.114: v2(259.42,73.34) 259.54,73.46 259.74,73.46 260.09,73.11 260.36,73.11 C5403.1 ; v3(205.8,71.76) 206.34,72.3 206.34,74.84 U4555.B54
DPC1_PORT_C_DN: length 3.8
  TOP w0.114: U3065.10 82.63,89.99 82.64,89.99 82.64,92.13 82.98,92.47 83.45,92.47 C3081.2
DPC1_PORT_C_DP: length 3.7
  TOP w0.114: U3065.9 83.13,90.21 83.04,90.3 82.98,90.3 82.87,90.41 82.87,92.03 83.08,92.24 83.47,92.24 83.68,92.03 C3080.2
DPC1_PORT_DN: length 235.7
  TOP w0.114: v3(96.77,92.65) 96.77,92.6 96.57,92.41 96.18,92.41 95.77,92.81 95.77,93.67 94.07,95.38 89.78,95.38 88.71,94.31 86.96,94.31 85.29,92.64 84.58,92.64 C3081.1
  L6 w0.114: v2(271.23,72.56) 271.23,72.41 271.5,72.14 271.5,71.52 270.99,71 270.57,71 269.64,70.07 269.64,69.33 269.98,68.98 270.96,68.98 272.98,66.96 272.98,63.93 272.22,63.17 272.22,60.06 266.73,54.57 266.73,53.77 265.69,52.73 261.62,52.73 260.91,53.44 249.6,53.44 247.85,55.18 240.25,55.18 239.35,56.08 232.08,56.08 229.94,53.93 223.68,53.93 222.83,53.08 176.09,53.08 173.68,55.5 170.88,55.5 161.28,65.1 149.12,65.1 146.69,67.53 144.97,67.53 137.99,74.5 133.41,74.5 132.37,75.55 132.37,76.15 129.07,79.45 125.42,79.45 124.28,80.58 115.65,80.58 107.48,88.75 103.67,88.75 102.25,90.17 98.41,90.17 98.01,90.57 96.04,90.57 95.42,91.19 95.42,91.87 96.03,92.48 96.6,92.48 v3(96.77,92.65)
  BOTTOM w0.114: v2(271.23,72.56) 270.94,72.56 270.81,72.69 270.4,72.69 269.85,72.14 269.85,71.48 269.69,71.32 U5401.46
DPC1_PORT_DP: length 235.6
  TOP w0.114: v2(96.55,91.63) 96.65,91.63 96.78,91.76 96.78,91.98 96.59,92.18 96.09,92.18 95.55,92.72 95.55,93.58 93.97,95.15 89.87,95.15 88.81,94.08 87.05,94.08 85.39,92.42 85.02,92.42 84.53,91.93 C3080.1
  L6 w0.114: v2(96.55,91.63) 96.63,91.71 96.63,92.05 96.45,92.24 96.13,92.24 95.66,91.77 95.66,91.29 96.14,90.81 98.11,90.81 98.51,90.41 102.35,90.41 103.77,88.99 107.58,88.99 115.75,80.82 124.38,80.82 125.52,79.69 129.17,79.69 132.61,76.25 132.61,75.65 133.51,74.75 138.09,74.75 145.07,67.77 146.79,67.77 149.22,65.34 161.38,65.34 170.98,55.74 173.3,55.74 173.78,55.74 176.19,53.32 222.73,53.32 223.58,54.17 223.68,54.17 229.84,54.17 231.98,56.32 239.45,56.32 240.35,55.42 247.95,55.42 249.7,53.68 261.01,53.68 261.72,52.97 265.59,52.97 266.49,53.87 266.49,54.67 271.98,60.16 271.98,63.27 272.74,64.03 272.74,66.86 270.86,68.74 269.88,68.74 269.4,69.23 269.4,70.17 270.47,71.24 270.89,71.24 271.26,71.62 271.26,72.04 271.14,72.15 270.98,72.15 v2(270.82,72)
  BOTTOM w0.114: v2(270.82,72) 270.82,72.38 270.74,72.46 270.5,72.46 270.08,72.04 270.08,71.38 269.62,70.92 U5401.47
DPC_AUX_C_DN: length 2.2
  BOTTOM w0.114: U5401.25 266.41,78.43 266.36,78.48 266.36,78.71 266.36,78.71 266.36,79.24 266.36,79.25 266.36,79.4 266.33,79.43 266.33,80 266.41,80.08 C5499.2
DPC_AUX_C_DP: length 2.4
  BOTTOM w0.114: U5401.24 266.01,78.4 266.1,78.49 266.1,78.51 266.13,78.54 266.13,78.81 266.13,78.81 266.13,79.15 266.13,79.15 266.13,79.31 266.1,79.34 266.1,79.66 265.68,80.08 C5498.2
DPC_AUX_DN: length 145.6
  L6 w0.114: v2(174.38,71.6) 174.38,71.6 174.42,71.6 174.42,71.6 174.57,71.45 174.57,71.01 175.05,70.53 176.89,70.53 177.72,71.36 178.54,71.36 178.88,71.7 182.57,71.7 183.65,70.62 191.85,70.62 192.34,70.13 197.5,70.13 197.99,70.61 204.35,70.61 204.98,69.97 204.98,69.72 205.36,69.35 205.77,69.35 208.6,66.51 208.6,60.38 211.93,57.05 223.03,57.05 223.22,57.24 228.77,57.24 230.56,59.03 240.84,59.03 241.33,59.52 254.76,59.52 257.01,57.27 265.31,57.27 267.09,59.05 267.38,59.05 269.32,60.99 269.32,62.93 267.28,64.97 263.68,64.97 262.95,65.7 262.95,67.73 261.77,68.92 261.77,71.64 262.59,72.47 262.59,78.23 266.27,81.91 266.27,82.49 v2(266.42,82.63)
  BOTTOM w0.076: 175.82,72.5 175.84,72.52 176.04,72.73 176.2,72.73 176.92,73.44 176.92,74 177.45,74.53 U4555.B6
  BOTTOM w0.114: v2(266.42,82.63) 266.15,82.36 266.15,81.26 C5499.1 ; v2(174.38,71.6) 174.38,71.6 174.42,71.6 174.42,71.6 174.41,71.6 174.66,71.84 174.66,72.15 174.94,72.43 175.75,72.43 175.82,72.5
DPC_AUX_DP: length 145.6
  L6 w0.114: v2(265.65,82.63) 265.88,82.63 266.03,82.49 266.03,82.01 262.35,78.33 262.35,72.57 261.53,71.74 261.53,68.82 262.71,67.63 262.71,65.6 263.58,64.73 267.18,64.73 269.08,62.83 269.08,61.09 267.28,59.29 266.99,59.29 265.21,57.51 257.11,57.51 254.86,59.76 241.23,59.76 240.74,59.27 230.46,59.27 228.67,57.48 223.12,57.48 222.93,57.29 212.03,57.29 208.85,60.48 208.85,66.61 205.87,69.59 205.46,69.59 205.23,69.82 205.23,70.07 204.45,70.85 197.89,70.85 197.4,70.37 192.44,70.37 191.95,70.86 183.75,70.86 182.67,71.94 178.78,71.94 178.44,71.6 177.62,71.6 176.79,70.77 176.52,70.77 176.42,70.87 176.42,71.03 176.32,71.13 176.18,71.13 176.08,71.03 176.08,70.87 175.98,70.77 175.84,70.77 175.74,70.87 175.74,71.03 175.64,71.13 175.49,71.13 175.39,71.03 175.39,70.87 175.29,70.77 175.15,70.77 174.81,71.11 174.81,71.37 175.07,71.64 175.08,71.64 175.08,71.67 v3(175.04,71.67)
  BOTTOM w0.076: 175.96,72.36 175.97,72.36 175.97,72.39 176,72.42 176,72.45 176.11,72.56 176.27,72.56 177.08,73.37 177.08,73.68 177.28,73.88 U4555.A6
  BOTTOM w0.114: C5498.1 265.92,81.26 265.92,82.36 v2(265.65,82.63) ; v3(175.04,71.67) 175.08,71.67 175.08,71.64 175.07,71.64 174.89,71.82 174.89,72.06 175.03,72.2 175.26,72.2 175.38,72.08 175.38,71.94 175.48,71.84 175.63,71.84 175.7,71.92 175.7,72.1 175.8,72.2 175.84,72.2 175.85,72.21 175.85,72.25 175.96,72.36
DPC_DDCCLK: length 124.8
  L5 w0.114: v3(170.29,67.42) 171.04,66.67 177.88,66.67 179.19,67.98 181.04,67.98 183.25,65.77 184.44,65.77 187.36,62.85 190.77,62.85 191.24,62.38 197.51,62.38 198.34,62.38 199.59,61.13 212.87,61.13 213.68,61.94 220.3,61.94 221.12,62.76 227.13,62.76 228.16,62.76 228.34,62.94 242.78,62.94 242.78,62.93 243.42,62.93 243.42,62.94 246.12,62.94 246.13,62.94 246.25,62.94 248.06,64.76 254.57,64.76 257.36,67.55 258.84,67.55 258.97,67.69 260.61,69.33 260.61,70.42 262.46,72.27 262.46,74.15 263.88,75.56 263.88,75.86 263.88,77.88 264.83,78.83 v2(264.83,78.81)
  BOTTOM w0.076: U4555.D9 178.48,75.67 178.48,75.07 178.11,74.7 178.11,74.34 177.78,74.01 177.78,73.49 176.25,71.96 176.25,71.25 176.05,71.05 174.6,71.05 174.4,70.85
  BOTTOM w0.114: v2(264.83,78.81) 264.83,78.83 264.9,78.83 265.2,78.52 U5401.22 ; R4788.1 170.03,67.68 v3(170.29,67.42) 170.54,67.68 172.55,67.68 173.55,68.68 173.55,70 174.4,70.85
DPC_DDCDATA: length 125.2
  TOP w0.114: v3(175.42,66.03) 176.05,65.39 v2(176.05,64.88)
  L5 w0.114: v2(176.05,64.88) 178.02,62.92 183.59,62.92 183.83,63.16 183.83,65.18 183.96,65.31 184.15,65.31 184.29,65.18 184.29,63.16 184.42,63.03 184.61,63.03 184.74,63.16 184.74,64.42 184.88,64.55 185.07,64.55 185.2,64.42 185.2,63.16 185.33,63.03 185.52,63.03 185.66,63.16 185.66,63.55 185.79,63.69 185.98,63.69 186.11,63.55 186.11,63.16 186.25,63.03 186.66,63.03 187.2,62.48 190.61,62.48 191.09,62.01 191.39,62.01 197.66,62.01 197.66,62.01 198.19,62.01 199.44,60.76 219.72,60.76 221.3,62.35 228.33,62.35 228.55,62.57 242.63,62.57 243.57,62.57 243.57,62.57 250.22,62.57 250.98,63.33 253.7,63.33 257.55,67.18 258.99,67.18 259.34,67.54 260.14,68.33 261.07,68.33 261.65,68.91 261.65,70.04 264.45,72.84 264.45,77.56 v2(265.71,78.83)
  BOTTOM w0.076: 176.69,70.37 177.81,71.49 178.06,71.49 178.71,72.13 178.71,72.79 179.31,73.39 179.31,74.17 179.54,74.41 179.54,75.52 179.39,75.67 U4555.D11
  BOTTOM w0.114: 176.69,70.37 176.69,69.56 176.41,69.28 176.41,69.05 176.05,68.69 175.79,68.69 R4789.1 175.88,68.49 176.31,68.06 176.31,67.68 175.8,67.17 175.8,66.41 v3(175.42,66.03) ; v2(265.71,78.83) 265.72,78.83 265.68,78.83 265.61,78.75 U5401.23
DPC_DOCK_CA_DET: length 2.9
  BOTTOM w0.102: U5401.33 270.14,76.52 v1(270.24,76.62) 270.89,76.62 R5422.1 R5421.1
DPC_DOCK_CLK_AUX_DP: length 94.3
  L6 w0.114: CN3601.30 322.97,120.97 322.71,120.97 322.46,120.72 322.32,120.72 322.22,120.82 322.22,120.86 322.12,120.97 321.97,120.97 321.87,120.86 321.87,120.82 321.77,120.72 321.63,120.72 321.53,120.82 321.53,120.86 321.43,120.97 321.29,120.97 321.19,120.86 321.19,120.82 321.09,120.72 320.95,120.72 320.85,120.82 320.85,120.86 320.75,120.97 320.6,120.97 320.5,120.86 320.5,120.82 320.4,120.72 320.3,120.72 319.75,121.27 316.93,121.27 316.75,121.27 315.61,120.12 315.61,118.11 314.19,116.69 305.77,116.69 303.78,114.7 303.78,113.23 302.16,111.61 299.92,111.61 299.37,111.06 299.37,109.26 298.27,108.15 297.17,108.15 294.82,105.8 291.1,105.8 289.88,104.58 289.88,98.92 291.09,97.71 291.09,83.09 288.94,80.94 287.12,80.94 285.78,79.6 282.48,79.6 280.88,81.2 273.74,81.2 272.36,79.81 271.93,79.81 271.72,80.03 v2(271.72,80.04)
  BOTTOM w0.114: v2(271.72,80.04) 271.48,79.79 270.96,79.79 R5425.2 270.67,80.08 R5423.1 269.58,79.88 269.18,79.88 268.64,79.33 268.23,79.33 267.69,78.8 267.69,78.08 U5401.28
DPC_DOCK_DATA_AUX_DN: length 94.4
  L6 w0.076: 323.55,120.7 322.85,120.7
  L6 w0.114: 322.85,120.7 322.63,120.48 320.2,120.48 319.65,121.03 316.93,121.03 316.85,121.03 315.85,120.02 315.85,118.01 314.29,116.45 305.87,116.45 304.02,114.6 304.02,113.13 302.26,111.36 300.02,111.36 299.61,110.96 299.61,109.16 298.37,107.91 297.27,107.91 294.92,105.56 291.2,105.56 290.13,104.48 290.13,99.02 291.33,97.81 291.33,82.99 289.04,80.7 287.22,80.7 285.88,79.36 282.38,79.36 280.78,80.96 273.84,80.96 272.46,79.57 271.93,79.57 v2(271.71,79.35) ; CN3601.29 323.55,120.7 323.55,120.7
  BOTTOM w0.114: v2(271.71,79.35) 271.49,79.56 270.96,79.56 R5426.2 270.67,79.28 R5424.1 269.78,79.51 269.64,79.65 269.28,79.65 268.73,79.11 268.32,79.11 267.92,78.7 267.92,78.08 U5401.29
DPC_DOCK_HPD: length 92.9
  L6 w0.102: CN3601.24 321.66,118.2 319.32,120.54 317.13,120.54 316.34,119.75 316.34,117.54 312.45,113.65 305.34,113.65 303,111.31 303,109.71 300.71,107.42 297.71,107.42 294.99,104.69 294.43,104.69 293.74,104 293.74,101.49 292.51,100.26 291.37,100.26 291.09,99.98 291.09,98.87 291.98,97.98 291.98,82.95 289.23,80.2 287.53,80.2 285.8,78.47 280.47,78.47 279.25,79.69 273.54,79.69 272.12,78.27 271.33,78.27 271.18,78.42 270.1,78.42 269.48,77.8 269.48,75.1 v2(270,74.57)
  BOTTOM w0.102: U5401.38 269.94,74.52 v2(270,74.57)
DPC_HPD: length 116.3
  L5 w0.102: v2(263.3,70.52) 263.76,70.06 263.76,69.48 263.52,69.24 263.03,69.24 261.69,67.9 260.22,67.9 260.16,67.85 259.14,66.82 257.7,66.82 253.8,62.93 251.21,62.93 250.49,62.2 242.48,62.2 228.83,62.2 228.54,61.92 221.81,61.92 221.81,61.92 221.4,61.92 221.36,61.88 221.35,61.88 219.87,60.4 199.29,60.4 198.04,61.65 197.81,61.65 197.81,61.65 191.54,61.65 190.94,61.65 190.46,62.12 187.05,62.12 186.62,62.56 177.57,62.56 173.87,66.25 170.42,66.25 v4(169.73,66.94)
  BOTTOM w0.076: 174.74,70.77 176,70.77 176.41,71.18 176.41,71.89 178.07,73.55 U4555.A8
  BOTTOM w0.102: R4759.1 169.58,66.79 v4(169.73,66.94) 169.75,66.91 170.59,66.91 170.99,67.31 173.15,67.31 v1(173.26,67.42) 173.26,67.8 173.67,68.21 173.67,68.21 173.92,68.46 173.92,69.94 174.74,70.77 ; U5401.3 v2(263.3,70.52)
DPC_IN_CA_DET: length 4.9
  BOTTOM w0.102: U5401.4 263.48,70.92 263.47,70.92 263,70.92 262.29,70.22 261.91,70.22 261.58,69.89 261.58,68.62 TP5400.1
DPC_PORT_CA_DET: length 3.2
  BOTTOM w0.102: R5419.1 R5420.1 270.71,73.36 269.96,72.61 269.95,72.61 269.86,72.52 U5401.43
DPC_PORT_CLK_AUX_C1_DP: length 11.6
  TOP w0.114: v3(93.46,92.89) 93,93.35 90.53,93.35 88.93,91.75 87.34,91.75 86.13,90.54 U3065.3
  BOTTOM w0.114: C3075.2 94.6,93.36 93.93,93.36 v3(93.46,92.89)
DPC_PORT_CLK_AUX_DP: length 227.2
  L6 w0.114: v2(98.19,92.86) 98.19,93.06 98.41,93.28 98.89,93.28 99.06,93.11 99.06,92.51 98.97,92.42 98.58,92.42 98.38,92.21 98.38,91.95 99.04,91.29 103.16,91.29 104.48,89.96 108.8,89.96 111.14,87.62 111.73,87.62 117.44,81.9 129.38,81.9 134.89,76.39 137.72,76.39 145.19,68.92 147.67,68.92 150.04,66.56 162.52,66.56 162.73,66.34 165.2,63.87 166.73,63.87 167.88,62.72 170.69,62.72 175.91,57.51 195.81,57.51 198.17,55.15 222.89,55.15 223.32,55.59 229.29,55.59 231.32,57.62 241.61,57.62 242.42,56.8 248.37,56.8 250.56,54.61 261.3,54.61 262.08,53.83 265.21,53.83 265.6,54.23 265.6,55.01 271.11,60.52 271.11,63.82 271.52,64.22 271.52,66.15 271.11,66.56 270.01,66.56 269.91,66.46 267.11,66.46 264.8,68.77 264.8,76.72 265.5,77.42 266.31,77.42 267.16,78.27 267.16,79.04 v2(266.94,79.26)
  BOTTOM w0.114: C3075.1 96.25,93.11 97.94,93.11 v2(98.19,92.86) ; U5401.26 266.88,78.07 266.88,79.21 v2(266.94,79.26) 266.94,79.31 267.37,79.74 R5417.1
DPC_PORT_DATA_AUX_C1_DN: length 11.8
  TOP w0.114: v2(93.46,93.66) 93.21,93.66 93.15,93.72 90.38,93.72 88.78,92.12 87.19,92.12 85.64,90.56 U3065.4
  BOTTOM w0.114: v2(93.46,93.66) 93.53,93.73 95.1,93.73 C3076.2
DPC_PORT_DATA_AUX_DN: length 227.4
  L6 w0.114: v2(267.55,79.26) 267.55,78.02 266.45,76.92 265.92,76.92 265.28,76.29 265.28,69 267.33,66.95 271.24,66.95 271.89,66.3 271.89,64.07 271.48,63.66 271.48,60.36 265.97,54.85 265.97,54.07 265.36,53.46 261.93,53.46 261.71,53.68 261.16,54.23 250.2,54.23 248,56.42 242.25,56.42 241.42,57.25 231.48,57.25 229.45,55.22 223.52,55.22 223.07,54.77 198.03,54.77 195.66,57.14 175.75,57.14 170.68,62.22 167.77,62.22 166.63,63.36 165.03,63.36 162.2,66.19 149.88,66.19 147.52,68.55 145.04,68.55 137.57,76.02 134.73,76.02 129.24,81.52 117.3,81.52 111.59,87.23 111,87.23 108.64,89.6 104.32,89.6 103,90.92 98.89,90.92 97.67,92.14 97.67,93.36 98.04,93.73 v3(98.19,93.73)
  BOTTOM w0.114: C3076.1 96.24,93.48 97.94,93.48 v3(98.19,93.73) ; R5416.2 267.55,79.37 v2(267.55,79.26) 267.2,78.91 U5401.27
DPC_PORT_HPD: length 229.3
  TOP w0.102: U3065.13 81.38,87.91 80.21,89.08 80.21,89.39 R3071.2 80.68,89.39 v2(80.93,89.14)
  L5 w0.102: v2(80.93,89.14) 81.22,89.43 90.42,89.43 90.84,89.01 90.84,88.1 91.33,87.62 95.03,87.62 95.79,86.85 97.94,86.85 102.14,82.66 110.69,82.66 114.2,79.15 123.82,79.15 124.75,78.22 126.17,78.22 130.21,74.18 130.21,71.99 131.18,71.02 131.18,70.44 131.18,69.84 138.81,62.21 153.31,62.21 154.12,63.01 160.25,63.01 162.36,60.91 170.38,60.91 171.24,60.05 171.24,59.11 176.36,53.99 222.54,53.99 223.72,55.16 223.96,55.4 231.24,55.4 232.04,56.2 239.41,56.2 241.7,53.91 249.31,53.91 249.66,53.56 255.52,53.56 256.35,54.39 256.78,54.82 256.78,55.43 257.09,55.74 260.76,55.74 261.68,56.65 265.63,56.65 267.33,58.34 267.75,58.34 270.08,60.68 270.08,65.03 v2(270.41,65.35)
  BOTTOM w0.102: v2(270.41,65.35) 270.01,65.76 270.01,66.63 271.25,67.88 271.25,70.44 270.98,70.72 269.85,70.72 269.65,70.52 U5401.48
DPPC10: length 5.5
  BOTTOM w0.102: U5301.56 282.66,68.42 282.35,68.11 v1(282.35,67.8) 282.35,67.34 R5302.1 281.34,66.32 281.34,65.26 282.05,64.55 R5301.1
DPPC11: length 5.6
  BOTTOM w0.102: U5301.55 283.06,68.41 282.86,68.21 R5304.1 283.35,66.47 283.35,64.79 v1(283.31,64.76) 283.62,64.44 R5303.1
DPPC20: length 6.5
  BOTTOM w0.102: R5305.1 284.58,63.98 v1(284.58,64.76) 284.35,64.76 283.55,65.56 283.55,66.51 R5306.1 283.76,66.96 283.22,67.5 283.22,68.08 283.46,68.33 U5301.54
DPPC21: length 7.2
  BOTTOM w0.102: R5307.1 286.09,63.84 285.32,63.84 285.07,64.09 285.07,65.06 285.35,65.33 285.35,66.51 R5308.1 284.05,67.8 v1(283.72,67.8) 283.85,67.93 283.85,68.56 283.86,68.57 U5301.53
DPWROK: length 172.9
  TOP w0.102: R4936.2 157.89,108.03 v2(157.92,108.05) ; v2(300.26,132.32) 300.56,132.32 301.16,131.72 U7000.4 301.43,131.6 R7001.2
  L3 w0.102: v2(284.64,128.51) 284.64,129.51 279.39,134.76 274.5,134.76 v2(273.21,133.46)
  L5 w0.102: v2(284.64,128.51) 285.02,128.89 285.02,131.18 288.73,134.88 296.04,134.88 298.61,132.32 v2(300.26,132.32)
  BOTTOM w0.102: v2(273.21,133.46) 268.64,133.46 267.9,132.73 267.9,120.78 266.59,119.47 260.01,119.47 259.14,120.33 258.85,120.33 242.7,120.33 241.91,119.54 211.08,119.54 210.05,118.5 209.34,118.5 209.33,118.5 168.4,118.5 157.92,108.02 v2(157.92,108.05)
EDP_AUX_C_DN: length 3.5
  TOP w0.114: C3009.2 109.93,113.27 110.13,113.07 110.78,113.07 v4(111.02,113.31)
  BOTTOM w0.114: CN3000.26 112.47,113.25 112.33,113.11 111.22,113.11 v4(111.02,113.31)
EDP_AUX_C_DP: length 3.6
  TOP w0.114: v3(111.03,112.51) 110.7,112.84 110.13,112.84 109.93,112.63 C3010.2
  BOTTOM w0.114: CN3000.27 112.47,112.75 112.33,112.88 111.4,112.88 111.03,112.52 v3(111.03,112.51)
EDP_AUX_DN: length 146.9
  TOP w0.114: C3009.1 108.75,113.07 108.41,113.07 106.52,111.17 106.52,107.14 103.46,104.08 102.6,104.08 98.91,100.4 98.91,94.56 98.76,94.41 98.76,94.39 v2(98.74,94.39)
  L6 w0.114: v2(98.74,94.39) 98.81,94.32 98.81,94.32 98.95,94.19 98.95,93.96 99.27,93.63 100.82,93.63 101.06,93.88 102.2,93.88 102.85,93.23 106.91,93.23 107.84,94.16 107.94,94.16 109.96,94.16 111.68,92.44 111.68,91.02 116.72,85.98 124.7,85.98 125.82,84.86 134.61,84.86 138.48,81 140.46,81 142.21,79.24 143.08,79.24 144.42,77.9 145.45,77.9 150.17,73.18 150.17,71.68 152.25,69.6 163.2,69.6 165.32,67.49 169.55,67.49 169.93,67.87 170.56,67.87 171.88,66.55 177.45,66.55 178.76,67.86 184.66,67.86 184.93,68.13 191.05,68.13 191.52,68.6 199.14,68.6 199.65,69.11 199.65,69.4 v4(199.8,69.56)
  BOTTOM w0.114: v4(199.8,69.56) 199.6,69.76 199.6,70.05 199.77,70.22 200.61,70.22 201.09,70.71 201.09,72.54 200.7,72.93 200.7,73.8 200.79,73.88 U4555.A45
EDP_AUX_DP: length 146.8
  TOP w0.114: v3(99.42,94.44) 99.14,94.72 99.14,100.3 102.69,103.85 103.55,103.85 106.74,107.04 106.74,111.07 108.51,112.84 108.77,112.84 109.08,112.53 C3010.1
  L6 w0.114: v3(99.42,94.44) 99.2,94.22 99.2,94.05 99.37,93.88 100.72,93.88 100.96,94.12 102.3,94.12 102.95,93.47 106.81,93.47 107.74,94.4 108.04,94.4 108.04,94.4 110.06,94.4 111.92,92.54 111.92,91.12 116.82,86.22 124.8,86.22 125.92,85.1 134.71,85.1 138.58,81.24 140.56,81.24 142.31,79.48 143.18,79.48 144.52,78.14 145.55,78.14 150.41,73.28 150.41,71.78 152.35,69.84 163.3,69.84 165.42,67.73 169.45,67.73 169.83,68.11 170.66,68.11 171.98,66.79 177.35,66.79 178.66,68.1 184.56,68.1 184.83,68.38 190.95,68.38 191.42,68.84 199.04,68.84 199.4,69.21 199.4,69.4 199.25,69.56 v4(199.04,69.56)
  BOTTOM w0.114: U4555.B45 200.79,74.53 200.79,74.33 200.48,74.02 200.48,72.83 200.86,72.44 200.86,70.81 200.51,70.45 199.68,70.45 199.37,70.15 199.37,69.78 199.14,69.56 v4(199.04,69.56)
EDP_HPD#: length 106.8
  TOP w0.102: v3(107.35,115.05) 107.3,115.05 R3021.1
  L6 w0.102: v2(176.82,75.18) 176.83,75.18 176.83,75.18 175.71,75.18 174.82,74.3 172.77,74.3 171.51,73.04 168.92,73.04 168,73.95 158.15,73.95 157.87,73.67 155.35,73.67 154.54,74.48 154.54,76.46 151.64,79.37 151.64,81.5 150.85,82.29 149.84,82.29 148.44,83.69 148.44,84.88 146.63,86.69 145.55,86.69 144.74,87.49 144.74,89.09 142.49,91.35 127.46,91.35 125.47,93.34 125.47,94.36 124.34,95.49 122.79,95.49 120.66,97.62 120.66,99.05 119.01,100.7 112.36,100.7 108.31,104.74 108.31,114.08 v3(107.35,115.05)
  BOTTOM w0.102: v2(176.82,75.18) 176.91,75.26 U4555.D6 ; CN3000.20 112.98,116.25 108.55,116.25 v3(107.35,115.05)
EDP_TX0_C_DN: length 3.6
  TOP w0.114: C3012.2 109.94,110.73 110.27,111.06 110.7,111.06 v3(111.03,110.73)
  BOTTOM w0.114: v3(111.03,110.73) 111.4,111.1 112.02,111.1 112.26,111.34 112.89,111.34 CN3000.30
EDP_TX0_C_DP: length 3.6
  TOP w0.114: C3011.2 109.94,111.62 110.27,111.29 110.7,111.29 v4(111.03,111.62)
  BOTTOM w0.114: v4(111.03,111.62) 111.32,111.33 111.93,111.33 112.34,111.75 CN3000.29
EDP_TX0_DN: length 148.4
  TOP w0.114: v2(101.53,93.24) 101.66,93.24 101.81,93.08 101.81,92.87 101.69,92.76 101.24,92.76 100.22,93.78 100.22,100.17 103.18,103.13 103.85,103.13 107.52,106.79 107.52,110.01 108.58,111.07 108.75,111.07 109.08,110.75 C3012.1
  L6 w0.114: v2(201.07,69.56) 201.33,69.3 201.33,68.98 200.46,68.11 191.77,68.11 191.3,67.64 190.91,67.64 190.91,67.64 185.42,67.64 183.15,65.37 183.15,64.3 181.91,63.05 177.25,63.05 174.31,65.99 168.77,65.99 167.9,66.86 165.04,66.86 162.8,69.1 152.03,69.1 148.55,72.58 148.55,73.58 145.12,77.01 143.71,77.01 141.97,78.75 141.4,78.75 140.05,80.1 134.27,80.1 130.11,84.26 120.25,84.26 119.13,85.38 116.52,85.38 111.19,90.71 111.19,91.97 110.03,93.13 107.52,93.13 107.04,92.66 101.75,92.66 101.53,92.87 v2(101.53,93.24)
  BOTTOM w0.114: U4555.C45 200.79,74.99 201.12,74.65 201.12,72.88 201.36,72.65 201.36,69.84 v2(201.07,69.56)
EDP_TX0_DP: length 148.4
  TOP w0.114: v3(101.59,92.27) 101.33,92.53 101.15,92.53 99.99,93.68 99.99,100.26 103.09,103.36 103.76,103.36 107.29,106.89 107.29,110.11 108.49,111.3 108.76,111.3 C3011.1
  L6 w0.114: v4(201.74,69.56) 201.57,69.39 201.57,68.88 200.56,67.87 191.87,67.87 191.4,67.4 185.52,67.4 183.39,65.27 183.39,64.2 182.01,62.81 177.15,62.81 174.21,65.75 168.67,65.75 167.8,66.62 164.94,66.62 162.7,68.86 151.93,68.86 148.31,72.48 148.31,73.48 145.02,76.77 143.61,76.77 141.87,78.51 141.3,78.51 139.95,79.86 134.17,79.86 130.01,84.02 120.15,84.02 119.03,85.14 116.42,85.14 110.95,90.61 110.95,91.87 109.93,92.89 107.62,92.89 107.14,92.42 101.73,92.42 v3(101.59,92.27)
  BOTTOM w0.114: v4(201.74,69.56) 201.74,69.58 201.59,69.73 201.59,72.74 201.35,72.98 201.35,74.41 201.67,74.73 201.67,74.88 201.58,74.96 201.45,74.96 U4555.B46
EDP_TX1_C_DN: length 3.9
  TOP w0.114: C3014.2 110.26,109.28 110.7,109.28 v3(111.03,108.95)
  BOTTOM w0.114: CN3000.33 112.98,109.75 112.47,109.75 112.33,109.89 111.83,109.89 111.74,109.8 111.74,109.61 111.46,109.33 111.36,109.33 111.03,109 v3(111.03,108.95)
EDP_TX1_C_DP: length 3.9
  TOP w0.114: C3013.2 110.26,109.51 110.7,109.51 v2(111.03,109.84)
  BOTTOM w0.114: v2(111.03,109.84) 111.03,109.71 111.18,109.56 111.37,109.56 111.51,109.71 111.51,109.89 111.73,110.11 112.33,110.11 112.47,110.25 112.98,110.25 CN3000.32
EDP_TX1_DN: length 138.5
  TOP w0.114: v3(109.48,92.47) 109.36,92.35 109.11,92.35 108.92,92.54 108.92,94 111.29,96.37 111.29,100.53 108.24,103.58 108.24,109.24 108.42,109.42 108.74,109.42 109.08,109.08 C3014.1
  L6 w0.114: v3(109.48,92.47) 109.4,92.39 109.08,92.39 108.92,92.24 108.92,91.73 117.21,83.44 129.67,83.44 134.56,78.54 136.65,78.54 145.33,69.87 148.16,69.87 150.73,67.3 162.87,67.3 165.56,64.61 170.51,64.61 171.68,63.43 175.49,63.43 176.77,62.15 182.39,62.15 184.4,64.16 184.4,65.15 186.15,66.9 191.68,66.9 192.15,67.37 201.82,67.37 203.48,69.03 203.48,69.21 203.13,69.56 v4(203.11,69.56)
  BOTTOM w0.114: v4(203.11,69.56) 203.11,69.84 203.45,70.18 203.45,70.34 203.32,70.47 203.32,70.71 203.45,70.84 203.45,71.08 203.32,71.22 203.32,71.46 203.45,71.59 203.45,71.83 203.32,71.96 203.32,72.2 203.45,72.34 203.45,72.54 202.1,73.88 201.92,73.88 U4555.A47
EDP_TX1_DP: length 138.6
  TOP w0.114: v2(108.51,92.41) 108.51,92.43 108.53,92.45 108.58,92.45 108.69,92.56 108.69,94.09 111.06,96.46 111.06,100.43 108.01,103.49 108.01,109.34 108.32,109.65 108.88,109.65 C3013.1
  L6 w0.114: v4(203.74,69.56) 203.72,69.54 203.72,68.93 201.92,67.13 192.25,67.13 191.78,66.66 186.25,66.66 184.64,65.05 184.64,64.06 182.49,61.91 176.67,61.91 175.39,63.19 171.58,63.19 170.41,64.37 165.46,64.37 162.77,67.05 150.63,67.05 148.06,69.62 145.23,69.62 136.55,78.3 134.46,78.3 129.57,83.2 117.11,83.2 108.68,91.63 108.68,92.24 v2(108.51,92.41)
  BOTTOM w0.114: U4555.B47 201.92,74.53 201.92,74.4 203.68,72.64 203.68,69.62 v4(203.74,69.56)
EMCLK: length 5.4
  TOP w0.102: R312.1 279.31,113.42 v1(278.54,112.66) 277.37,111.49 275.82,111.49 275.68,111.36 U300.66
EMDAT: length 4.8
  TOP w0.102: U300.67 275.28,111.25 275.72,111.69 276.21,111.69 v1(277.15,112.63) 277.57,112.63 R313.1
EN_1V2A: length 107.8
  TOP w0.102: R7021.2 210.21,146.75 C7036.1 211.1,146.75 R7023.2 214.96,146.75 216.31,145.4 v3(216.31,144.38) ; v2(246.79,88.76) U6450.5
  L3 w0.102: v3(216.31,144.38) 217.41,143.29 243.08,143.29 243.72,142.66 254.74,142.66 255.56,141.84 255.56,134.78 246.72,125.94 246.72,115.76 248.47,114.01 248.47,104.79 248.19,104.51 v2(248.19,103.87)
  BOTTOM w0.102: v2(248.19,103.87) 248.19,100.82 247.05,99.68 247.05,89.01 v2(246.79,88.76)
EN_1V05A: length 6.1
  TOP w0.254: C7037.1 117.21,95.49 117.93,95.49 R7019.2 118.1,95.49 118.73,95.49 v2(119.16,95.92)
  BOTTOM w0.254: v2(119.16,95.92) 119.37,95.92 119.57,96.12 119.67,96.12 119.87,96.33 120.89,96.33 121.44,96.88 121.44,96.96 121.89,97.41 U6300.2
EN_1V5S: length 3
  TOP w0.254: R7020.2 C7035.1 97.87,143.96 v1(97.7,144.13) 98.08,144.13 98.33,144.38 U6350.5
EN_3V: length 14.1
  L3 w0.102: v4(213.14,151.12) 208.19,156.07 206.41,156.07 205.77,156.7 v3(204.89,156.7)
  BOTTOM w0.254: R7112.1 213.27,150.99 v4(213.14,151.12) ; U6100.13 204.48,156.22 204.89,156.63 v3(204.89,156.7) 204.89,157.2 204.46,157.64 R6110.1
EN_3VLDO: length 6.8
  TOP w0.102: R7117.2 208.82,155.05 v1(208.06,155.81) 208.05,155.83 204.74,155.83 204.2,156.37 v2(204.2,156.78)
  BOTTOM w0.254: U6100.12 204.08,156.66 v2(204.2,156.78)
EN_5V: length 34.2
  TOP w0.102: v2(240.24,148.58) 239.94,148.58 239.55,148.19 239.55,147.26 R6160.1
  L6 w0.102: v2(215.17,150.99) 218.73,147.43 231.3,147.43 232.95,145.78 239.43,145.78 240.57,146.92 240.57,148.24 v2(240.24,148.58)
  BOTTOM w0.203: U6150.13 239.85,148.42 240.01,148.58 v2(240.24,148.58)
  BOTTOM w0.254: R7113.1 214.28,150.61 214.66,150.99 v2(215.17,150.99)
EN_5V_3V: length 257.3
  TOP w0.102: v2(40.42,83.3) 40.42,85.81 41.43,86.83 43.57,86.83 45.4,88.66 U4411.3
  L3 w0.102: v2(212.12,151.12) 210.6,149.59 196.63,149.59 191.55,154.67 177.04,154.67 169.07,162.65 141.3,162.65 130.25,151.6 119.49,151.6 111.11,143.22 111.11,139.13 109.96,137.98 109.96,133.39 112.96,130.39 112.96,104.81 113.31,104.46 113.87,104.46 114.81,103.52 114.81,100.52 v2(112.88,98.59)
  L6 w0.102: v2(112.88,98.59) 112.1,98.59 109.95,100.74 101.83,100.74 95.91,94.82 92.78,94.82 91.11,93.15 91.11,92.75 91.11,92.33 88.04,89.27 82.58,89.27 80.32,87.01 50.42,87.01 49.8,86.38 49.76,86.38 48.57,85.19 42.31,85.19 v2(40.42,83.3)
  BOTTOM w0.254: R7113.2 214.07,149.34 213.48,149.34 R7112.2 213.1,149.38 212.97,149.38 212.65,149.7 212.65,150.12 212.38,150.4 R7110.1 v2(212.12,151.12)
EN_5VLDO: length 44
  TOP w0.102: v2(240.52,149.11) 242.7,149.11 242.98,148.83 242.98,147.77 R6151.2 241.02,145.81 237.24,145.81 235.87,147.18 v1(235.87,147.58) 233.46,150 v4(233.46,151.14) 221.88,151.14 218.22,154.8 212.38,154.8 212.12,155.05 R7116.2
  BOTTOM w0.203: U6150.12 239.82,148.82 240.11,149.11 v2(240.52,149.11)
  BOTTOM w0.381: R6150.1 233.19,151.47 233.46,151.2 v4(233.46,151.14) 234.05,151.73 R6167.1
EN_PVCORE: length 39.3
  TOP w0.254: v2(210.54,76.97) 210.54,76.84 211.08,76.29 211.08,75.8 210.9,75.63 210.9,72.2 v1(210.98,72.12) 210.98,71.32 v4(211.3,71)
  L6 w0.254: v3(219.82,72.45) 222.56,72.45 224.98,74.87 227.12,74.87 227.9,75.65 236.19,75.65 v2(236.5,75.35)
  BOTTOM w0.254: U4555.F60 210.21,77.36 210.54,77.03 v2(210.54,76.97) ; v3(219.82,72.45) 218.73,71.36 R4593.2 217.25,71.1 216.49,70.34 211.96,70.34 v4(211.3,71) ; R6643.2 235.87,77.84 236.5,77.21 v2(236.5,75.35)
EN_VRPVDDQ: length 48.2
  L5 w0.102: v2(179.36,148.07) 178.24,146.95 166.15,146.95 165.34,147.76 153.22,147.76 151.04,149.95 v2(151.04,152.26)
  BOTTOM w0.254: v2(151.04,152.26) 151.29,152.51 151.29,156.32 151.49,156.53 151.49,156.95 153.17,158.63 153.17,158.98 153.35,159.15 153.61,159.15 153.62,159.16 U6200.2 ; v2(179.36,148.07) 179.99,148.7 179.99,151.07 179.74,151.33 179.74,151.67 R7118.2 179.61,151.75 179.23,152.13 177.83,152.13 177.55,152.42 U6240.9
EN_VRPVTT: length 3.6
  BOTTOM w0.254: R7119.2 178.8,153.66 177.58,153.66 177.34,153.42 U6240.7
EXT_MIC_JACK: length 79.1
  TOP w0.254: v2(308.01,52.44) 307.33,52.44 R605.1 307.16,52.44 R604.1 R602.1
  L3 w0.254: v2(291.5,55.49) 290.3,54.3 290.3,51.8 290.81,51.29 306.86,51.29 v2(308.01,52.44)
  L6 w0.254: v2(308.01,52.44) 308.01,52.18 308.77,51.42 311.94,51.42 314.56,48.8 314.56,13.37 v2(318.8,9.13)
  BOTTOM w0.254: v2(291.5,55.49) 291.5,55.61 290.86,56.25 R620.1 ; v2(318.8,9.13) 319.82,9.13 v1(319.82,9.13) 319.83,9.13 L602.2
FET_A: length 12.6
  TOP w0.102: U300.123 260.62,98.53 260.42,98.33 257.21,98.33 v1(256.65,98.89) 256.29,99.25 256.29,101.23 255.24,102.28 255.24,102.96 R305.1 254.84,102.22 R332.1
FET_B: length 10.9
  TOP w0.102: v2(255.56,104) 255.68,104.13 R327.1 ; U300.116 261.36,101.33 v3(260.57,100.54) 259.08,100.54 R304.1
  L6 w0.102: v3(260.57,100.54) 260.23,100.54 257.92,102.86 256.95,102.86 255.81,104 v2(255.56,104)
FPR_LOCK#: length 167.4
  TOP w0.102: v4(165.13,83.02) 165.13,81.27 166.73,79.66 166.73,76.7 166.15,76.11 166.15,71.38 166.4,71.13 166.4,69.96 165.97,69.53 165.46,69.53 164.5,68.57 164.5,65.39 165.51,64.37 166.15,64.37 v1(168.31,62.22) 168.69,61.83 v2(168.69,60.13) ; v2(284.31,57.24) 284.31,57.34 283.15,58.5 CN2200.5
  L5 w0.102: v2(284.31,57.24) 284.31,56.54 279.96,52.19 268.81,52.19 268.51,52.49 261.27,52.49 260.97,52.19 241.5,52.19 238.56,55.13 232.72,55.13 231.9,54.31 226.49,54.31 224.64,52.46 175.5,52.46 168.69,59.27 v2(168.69,60.13)
  BOTTOM w0.076: 169.22,83.73 169.32,83.63 171.58,83.63 171.76,83.81 174.68,83.81 174.77,83.72 175.15,83.72 U4555.U4
  BOTTOM w0.102: v2(284.31,57.24) 283.95,56.88 R2200.1 ; 165.13,83.02 165.84,83.73 169.22,83.73 ; 165.13,83.02 v4(165.13,83.02) ; 165.13,83.02 R4706.2
FPR_OFF: length 177.8
  TOP w0.102: R2204.2 163.82,72.29 165.46,70.65 165.46,70.04 164.24,68.82 164.24,68.81 164.14,68.71 164.14,64.98 165.41,63.71 166.04,63.71 168.03,61.73 168.03,60.2 168.58,59.65 169.81,59.65 169.97,59.81 v2(169.97,60.12) 169.97,62.97 169.68,63.26 168.45,64.49 167.29,65.64 167.29,69.2 167.8,69.71 167.8,70.98 170.75,73.92 170.75,75.65 v1(169.96,76.44) 169.45,76.95 v2(169.45,78.6) ; CN2200.6 282.93,59.5 v2(284.72,57.72) ; v2(177.58,76.82) 177.58,77.2 176.56,78.22 176.35,78.22 176.18,78.39 R2205.2
  L3 w0.076: v2(177.58,76.82) 177.58,77.33 176.83,78.07 169.98,78.07 v2(169.45,78.6)
  L5 w0.102: v2(284.72,57.72) 284.21,57.72 283.83,57.34 283.83,56.56 281.35,54.09 278.8,54.09 278.04,53.33 269.27,53.33 268.79,52.84 261.12,52.84 260.98,52.7 241.5,52.7 238.71,55.49 232.58,55.49 232.53,55.44 232.53,55.44 231.75,54.67 224.77,54.67 222.92,52.82 176,52.82 169.97,58.85 v2(169.97,60.12)
FPR_OFF_GPIO11: length 31.8
  TOP w0.102: R2204.1 R2201.1 v1(165.51,73.39) 165.64,73.52 165.64,76.11 166.38,76.84 166.38,79.39 164.43,81.33 164.43,83.01 165.36,83.93 166.73,83.93 168.38,85.58 168.38,88.34 167.48,89.24 167.48,92.38 v2(167.54,92.44)
  BOTTOM w0.076: U4555.AN2 173.9,92.06 173.66,92.06 173.66,92.05 173.18,92.05 173.07,92.17 172.17,92.17 172.03,92.03
  BOTTOM w0.102: v2(167.54,92.44) 167.59,92.44 168.01,92.03 172.03,92.03
FPR_OFF_GPIO65: length 25.2
  TOP w0.102: v2(175.19,76.99) 175.74,77.54 R2205.1 ; R4745.1 154.56,75.09 155.43,75.09 155.94,74.58 v2(155.94,74.1)
  L6 w0.102: v2(175.19,76.99) 174.59,76.39 174.21,76.39 171.46,73.65 169.13,73.65 168.26,74.51 160.8,74.51 160.62,74.69 156.42,74.69 155.94,74.2 v2(155.94,74.1)
  BOTTOM w0.076: U4555.F4 175.49,77.29 v2(175.19,76.99)
GPIO3: length 20.7
  BOTTOM w0.076: U4555.J4 175.18,79.2 174.76,79.2 174.65,79.31 174,79.31 173.83,79.15 173.17,79.15 173.05,79.03 172.24,79.03 171.83,78.61 171.15,78.61 170.75,78.22
  BOTTOM w0.102: 170.75,78.22 170.69,78.15 170.63,78.15 169.84,77.36 168.34,77.36 166.27,75.3 165.64,75.3 161.7,75.3 v1(160.69,74.28) 160.33,73.92 160.33,72.53 159.67,71.87 R4906.1
GPIO4: length 10.4
  BOTTOM w0.102: R4859.1 167.34,72.25 v1(168.05,72.25) 168.43,72.25 168.77,72.59 168.77,73.07 169.27,73.57 171.52,73.57 172.43,74.49 172.43,76.06 173.31,76.94 173.81,76.94 173.81,76.98 U4555.F2
GPIO5: length 10.3
  BOTTOM w0.076: U4555.F3 174.58,77.65 173.19,77.65 173.1,77.56
  BOTTOM w0.102: R4735.1 167.67,73.52 v1(168.05,73.9) 168.38,74.23 171.2,74.23 171.76,74.79 171.76,76.22 173.1,77.56
GPIO10: length 12
  BOTTOM w0.076: U4555.AM2 174.19,91.6 174.06,91.47 173.86,91.47 173.7,91.31 173.21,91.31 173.14,91.31 172.98,91.15 172.35,91.15 172.04,91.45
  BOTTOM w0.102: 172.04,91.45 169.22,91.45 169.09,91.33 167.34,91.33 166.86,91.8 166.51,91.8 165.7,92.61 v1(164.67,92.61) 164.48,92.61 163.72,93.37 R4960.2
GPIO13: length 10.1
  BOTTOM w0.102: U4555.AT3 174.84,93.88 174.53,94.19 174.06,94.19 173.88,94.01 173.88,93.7 173.73,93.55 171.56,93.55 170.99,94.12 169.73,94.12 169.5,94.35 167.67,94.35 167.42,94.6 v1(167.42,95.24) 167.04,95.62 R4961.2
GPIO14: length 19.3
  L6 w0.102: v2(175.97,89.25) 175.78,89.44 173.96,89.44 173.28,90.12 171.59,90.12 170.35,91.35 164.56,91.35 163.55,92.36 160.2,92.36 159.62,91.78 v3(159.62,91.65)
  BOTTOM w0.076: v2(175.97,89.25) 175.84,89.39 U4555.AH4
  BOTTOM w0.102: v3(159.62,91.65) 159.5,91.53 R4741.2
GPIO24: length 19.2
  L6 w0.102: v2(175.99,86.4) 175.9,86.5 172.35,86.5 172.09,86.24 171.43,86.24 171.06,85.87 169.55,85.87 169.48,85.94 169.48,85.95 168.94,86.48 163.62,86.48 163.07,87.03 162.15,87.03 162.15,87.03 161.36,87.03 v4(160.92,87.48)
  BOTTOM w0.076: U4555.AD5 175.99,86.71 v2(175.99,86.4)
  BOTTOM w0.102: R4908.2 159.38,88.8 160.15,88.02 160.38,88.02 v1(160.43,87.97) 160.92,87.48 v4(160.92,87.48)
GPIO25: length 18.4
  L6 w0.102: v2(171.93,90.99) 170.61,92.31 170.21,92.31 169.58,92.95 165.92,92.95 164.83,94.04 159.94,94.04 v3(159.64,94.34)
  BOTTOM w0.076: v2(171.93,90.99) 172.1,90.82 172.89,90.82 173.21,91.14 173.83,91.14 174,91.31 174.68,91.31 174.72,91.27 175.19,91.27 175.44,91.51 175.49,91.56 U4555.AM4
  BOTTOM w0.102: R4909.2 159.62,94.32 v3(159.64,94.34)
GPIO34: length 10.6
  BOTTOM w0.076: U4555.V1 173.54,84.11 171.8,84.11 171.49,83.8 169.61,83.8 169.32,84.09 169.22,84.09
  BOTTOM w0.102: R4818.2 163.72,83.68 v1(164.5,83.68) 165.26,83.68 165.67,84.09 169.22,84.09
GPIO35: length 11.2
  BOTTOM w0.076: 170.84,83 171.46,83 171.81,83.35 U4555.U1
  BOTTOM w0.102: R4817.1 163.65,80.96 v1(164.24,80.96) 165.48,80.96 165.68,81.16 167.49,82.96 170.8,82.96 170.84,83
GPIO43: length 10.3
  BOTTOM w0.076: 174.47,96.74 174.47,96.18 174.53,96.12 174.53,95.72 174.53,95.72 174.53,95.65 174.86,95.33 U4555.AV3
  BOTTOM w0.102: R4778.1 v1(167.42,97.65) 167.8,98.03 169.45,98.03 170.53,96.95 174.27,96.95 174.47,96.74
GPIO44: length 13.4
  BOTTOM w0.076: U4555.AK4 175.19,89.77 174.72,89.77 174.67,89.81 173.89,89.81 173.73,89.64 171.25,89.64 170.71,89.1 169.77,89.1 169.23,89.64 169.22,89.64
  BOTTOM w0.102: 169.22,89.64 168.01,89.64 166.59,91.07 165.82,91.07 v1(165.51,91.37) R4911.2
GPIO47: length 22.5
  TOP w0.102: v4(159.52,83.29) 159.67,83.14 v1(159.67,82.61) 159.67,82.15 159.03,81.51 R4916.2
  L6 w0.076: v2(176.55,85.46) 176.16,85.07 174.92,85.07
  L6 w0.102: 174.92,85.07 173.97,85.07 173.42,84.52 171.86,84.52 171.32,83.99 169.37,83.99 168.76,84.59 168.68,84.59 168.62,84.59 168.62,84.59 168.16,84.59 165.83,84.59 165.48,84.25 163.32,84.25 162.49,85.07 160.58,85.07 160.58,85.07 159.52,84.01 v4(159.52,83.29)
  BOTTOM w0.076: v2(176.55,85.46) 176.55,85.67 U4555.AB6
GPIO51: length 124.8
  TOP w0.102: R4868.2 277.89,93.03 v3(278.24,93.38)
  L5 w0.102: v2(175.93,81.62) 176.3,81.99 177.97,81.99 178.34,81.62 178.34,80.25 179.05,79.54 184.97,79.54 186.09,78.41 186.09,77.76 186.93,76.92 203.18,76.92 204.16,75.94 205.28,75.94 205.95,75.27 206.62,75.27 207.76,74.13 222.84,74.13 223.81,75.09 226.98,75.09 228.44,76.55 249.45,76.55 250.74,77.84 257.21,77.84 258.1,76.95 258.65,76.95 v2(258.96,77.25)
  BOTTOM w0.102: v2(258.96,77.25) 259.9,77.25 R4782.1 260.59,76.91 263.28,79.59 263.28,81.49 265.36,83.58 266.96,83.58 268.13,82.41 271.94,82.41 274.73,85.2 274.73,86.22 275.24,86.73 275.24,92.68 276.53,93.97 277.65,93.97 v3(278.24,93.38) ; U4555.R5 176.17,82.13 175.93,81.88 v2(175.93,81.62)
GPIO64: length 22.9
  TOP w0.102: v3(155.1,75.8) 154.38,75.8 R4738.1
  L6 w0.102: v3(155.1,75.8) 155.94,74.97 160.86,74.97 161.12,74.71 168.54,74.71 169.27,73.98 171.52,73.98 172.73,75.18 v2(174.54,76.99)
  BOTTOM w0.076: v2(174.54,76.99) 174.54,76.87 U4555.E3
GPIO67: length 22.9
  TOP w0.102: R4749.1 157.85,74.79 v1(157.26,74.79) 157.13,74.79 156.72,74.38 v2(156.72,74.1)
  L6 w0.102: v2(175.29,76.12) 174.21,76.12 172.51,74.42 171.5,73.42 169.07,73.42 168.18,74.31 160.71,74.31 160.53,74.48 157.11,74.48 v2(156.72,74.1)
  BOTTOM w0.102: U4555.E4 175.49,76.31 v2(175.29,76.12)
GPIO68: length 7.5
  BOTTOM w0.102: U4555.C3 174.67,75.19 174.33,75.52 173.95,75.52 173.84,75.42 173.3,75.42 173.08,75.19 173.08,73.85 171.74,72.5 v1(170.52,72.5) 170.26,72.24 R4750.1
GPIO69: length 10.3
  BOTTOM w0.102: 169.27,72.78 v1(169.27,72.81) ; 169.27,72.78 169.66,73.17 171.39,73.17 172.63,74.41 172.63,75.98 173.39,76.75 174.05,76.75 U4555.E2 ; 169.27,72.78 169.27,72.68 168.15,71.56 167.54,71.56 R4752.1
GPIO83: length 25.1
  TOP w0.102: v2(155.23,79.26) 154.28,79.26 R4764.1
  L6 w0.102: v2(155.23,79.26) 155.45,79.26 155.94,78.77 159.43,78.77 159.79,78.42 162.16,78.42 162.77,79.03 169.61,79.03 170.21,78.42 172.15,78.42 173.71,79.99 174.56,79.99 175.73,81.16 176.12,81.16 v2(176.56,81.59)
  BOTTOM w0.076: v2(176.56,81.59) 176.56,81.86 176.82,82.13 U4555.R6
GPIO84: length 26.8
  TOP w0.102: v4(155.99,76.35) 155.23,77.12 v1(155.23,77.46) R4754.1
  L6 w0.102: v4(155.99,76.35) 156.1,76.46 157.89,76.46 158.68,75.68 166.3,75.68 167.55,76.92 170.11,76.92 170.83,76.2 172.09,76.2 173.34,77.44 173.34,77.82 174.37,78.86 176.21,78.86 176.92,79.57 v2(176.92,79.74)
  BOTTOM w0.076: v2(176.92,79.74) 176.92,80.13 176.82,80.22 U4555.L6
GPIO85: length 24.4
  L5 w0.076: v2(176.49,80.64) 176.16,80.3 175.58,80.3 175.33,80.55 172.45,80.55 171.87,79.98 169.69,79.98 169.5,80.17 169.22,80.17
  L5 w0.102: v3(155.9,81.04) 156.33,80.6 159.24,80.6 159.67,80.17 169.22,80.17
  BOTTOM w0.076: U4555.N6 176.82,81.17 176.49,80.84 v2(176.49,80.64)
  BOTTOM w0.102: v3(155.9,81.04) 155.36,80.5 154.77,80.5 154.26,79.99 R4806.1
GPIO86: length 26.3
  L5 w0.076: 169.22,79.76 169.41,79.76 169.53,79.65 171.82,79.65 172.29,79.18 173.9,79.18 174.2,79.49 175.32,79.49 175.79,79.96 176.59,79.96 176.75,80.12 177.64,80.12 v2(178.03,79.74)
  L5 w0.102: 169.22,79.76 158.35,79.76 158.16,79.57 157.16,79.57 157.15,79.59 156.48,79.59 v3(156.19,79.3)
  BOTTOM w0.102: R4809.1 154.51,77.84 155.23,77.84 155.74,78.35 155.74,78.84 v3(156.19,79.3) ; U4555.L8 178.12,80.22 178.03,80.12 v2(178.03,79.74)
GPIO87: length 25.8
  L5 w0.076: v2(177.18,81.58) 176.82,81.21 176.14,81.21 176.12,81.23 175.42,81.23 175.29,81.1 174.98,81.1 174.97,81.1 174.29,81.1 173.75,81.65 172.49,81.65 170.99,80.14 169.76,80.14 169.44,80.46 169.22,80.46
  L5 w0.102: v2(155.1,81.06) 155.68,81.65 160.46,81.65 161.1,81.01 161.46,81.01 161.59,81.14 161.95,81.14 162.63,80.46 169.22,80.46
  BOTTOM w0.102: R4810.1 154.79,80.76 v2(155.1,81.06) ; U4555.R7 177.47,82.13 177.18,81.84 v2(177.18,81.58)
GPIO88: length 24.3
  L5 w0.076: v2(176.37,79.57) 175.77,78.98 172.25,78.98 171.75,79.48 169.29,79.48 169.26,79.51 169.22,79.51
  L5 w0.102: v2(156.98,79.18) 158.22,79.18 158.56,79.51 169.22,79.51
  BOTTOM w0.076: v2(176.37,79.57) 176.37,80.03 176.17,80.22 U4555.L5
  BOTTOM w0.102: R4813.1 154.56,77.51 155.33,77.51 156.98,79.16 v2(156.98,79.18)
GPIO89: length 25
  L5 w0.076: v2(177.15,80.71) 176.72,80.28 176.68,80.28 176.54,80.14 175.51,80.14 175.28,80.36 172.54,80.36 171.99,79.81 169.6,79.81 169.45,79.97 169.22,79.97
  L5 w0.102: 169.22,79.97 158.43,79.97 158.26,79.97 158.07,79.78 157.25,79.78 157.23,79.79 156.53,79.79 156.22,80.1 v3(155.03,80.1)
  BOTTOM w0.076: v2(177.15,80.71) 177.15,80.85 177.47,81.17 U4555.N7
  BOTTOM w0.102: v3(155.03,80.1) 155.02,80.1 155.02,79.89 154.26,79.12 R4814.1
GPIO90: length 18.9
  BOTTOM w0.076: 170.74,78.47 170.75,78.47 171.06,78.78 171.57,78.78 171.98,79.19 172.95,79.19 173.07,79.32 173.76,79.32 174.06,79.61 U4555.K2
  BOTTOM w0.102: R4755.1 159.62,72.76 v1(159.75,72.88) 159.75,74.1 160.71,75.07 161.07,75.07 161.5,75.5 165.72,75.5 165.72,75.5 166.19,75.5 168.26,77.57 169.77,77.57 170.55,78.34 170.61,78.34 170.67,78.41 170.68,78.41 170.74,78.47
GPIO94: length 24.6
  BOTTOM w0.102: U4555.G1 173.54,78.11 172.72,78.11 172.44,77.83 171.57,77.83 170.95,77.21 170.95,74.94 170.49,74.48 165.3,74.48 165.3,74.48 162.57,74.48 162.08,74 162.08,72.5 160.37,70.79 155.28,70.79 v1(155.1,70.98) R4763.1
GPIO134: length 12.5
  TOP w0.102: U300.110 262.81,103.73 263.25,103.28 v2(263.25,102.86) ; v3(255.3,105.01) 254.84,104.55 R391.1
  L6 w0.102: v2(263.25,102.86) 261.35,104.76 260.74,104.76 259.65,103.67 256.65,103.67 v3(255.3,105.01)
GPS_XMIT_OFF#: length 117.4
  L5 w0.102: v2(252.18,79.23) 251.58,78.64 250.53,78.64 249.33,77.43 240.29,77.43 240.14,77.58 237.47,80.25 235.24,80.25 234.78,79.79 234.78,79.03 234.09,78.34 232.78,78.34 232.36,77.91 227.93,77.91 226.56,76.54 223.75,76.54 222.48,75.27 219.23,75.27 218.79,75.72 208.86,75.72 207.7,76.87 206.51,76.87 205.98,77.4 205.98,77.99 205.53,78.43 188.92,78.43 188.04,79.31 187.66,79.31 186.52,80.45 185.25,80.45 184.59,81.11 180.55,81.11 179.56,82.1 179.19,82.1 178.9,82.4 178.9,83.02 177.91,84.01 175.67,84.01 v2(175.17,84.51)
  L6 w0.102: v4(161.05,84.14) 161.28,83.9 162.66,83.9 162.88,83.69 165.72,83.69 166.06,84.03 168.39,84.03 169,83.42 171.3,83.42 171.84,83.96 174.62,83.96 v2(175.17,84.51)
  BOTTOM w0.076: v2(175.17,84.51) 175.17,84.38 175.49,84.06 U4555.V4
  BOTTOM w0.102: R4708.1 159.15,84.84 160.35,84.84 v1(160.52,84.66) v4(161.05,84.14) ; v2(252.18,79.23) 252.18,78.63 250.72,77.17 250.72,75.05 251.58,74.19 251.58,71.33 253.92,69 CN1400.26
