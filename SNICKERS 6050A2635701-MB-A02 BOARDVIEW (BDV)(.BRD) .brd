# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Library data of the parts (continued)
C1415 C1452 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009904,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009904_4_7uF_6_3V_3; room: Sheet51
C1700 = CSC0402: part number: CSC0402-68PF_50V_2,60100768020T,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP-680-J,50V-TAP(0402); signal model: C2_60100768020T_68pF_50V_2; room: Sheet40
C1701 C1956 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009904,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009904_4_7uF_6_3V_3; room: Sheet40
C1702-C1705 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet40
C2200 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet44
C2201 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009904,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009904_4_7uF_6_3V_3; room: Sheet44
C2250 C2255 C3009-C3014 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet38
C2251 C3003 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009904,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009904_4_7uF_6_3V_3; room: Sheet38
C2256 C3006 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet38
C2401 C2411 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040702,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_22uF_6_3V_5; room: Sheet42; signal model: C2_6010A0036403_0_1uF_16V_2
C2402 C2404-C2408 C2500 C2501 C2503 C2513 C2514 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet42
C2412 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet42; signal model: C2_6010A0036403_0_1uF_16V_2
C2413 = CSC0805: part number: CSC0805-22UF_6.3V_5_DY,6010A0040702_DY,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_DY_22uF_6_3V_5_DY; room: Sheet42
C2414 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet42
C2415 = CSC0603: part number: CSC0603-22UF_6.3V_3_DY,6010B0219001_DY,CSC_160X080X090_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,R6,0603,TR; signal model: C2_6010B0219001_DY_22UF_6.3V_3_DY; room: Sheet42
C2512 = CAP_TA_SP: part number: CAP_TA_SP-100UF_6.3V,6010B0154501,CST_320X160X180_2_245,1.95MM,CAP_TA_SP,,,CAPACITOR-TA-SP,100UF,6.3V,M,85C,AX1.6,SMD,TR,45MOHM; signal model: C2_6010B0154501_100uF_6_3V; room: Sheet42
C2550 C2566 = CSC0402: part number: CSC0402-15PF_50V_2,6010071502AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP,15PF,J-50V-NPO-0402-TAP; signal model: C2_6010071502AT_15pF_50V_2; room: Sheet41
C2551 C2552 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009904,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009904_4_7uF_6_3V_3; room: Sheet41
C2553-C2564 C2567-C2570 C2582-C2584 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet41
C2575 = CSC0402: part number: CSC0402-100PF_50V_2_DY,6010071012AT_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-101-J,50V-NPO-0402; signal model: C2_6010071012AT_DY_100pF_50V_2_DY; room: Sheet41
C2578 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet41
C2590 = CSC0402: part number: CSC0402-0.1UF_16V_2_DY,6010071041BT_DY,CSC_100X050X055_2,0.7MM,CSC0402,0402,,CAP-CHIP-104-Z,16V-TAP(0402); signal model: C2_6010071041BT_DY_0_1uF_16V_2_DY; room: Sheet41
C2950 C7402 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet18
C2951 = CSC0402: part number: CSC0402-0.068UF_10V_2,6010B0018301,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.068UF,10V,K,X5R,0402,TR; signal model: C2_6010B0018301_0_068uF_10V_2; room: Sheet18
C2952 C7401 C7403 = CSC0402: part number: CSC0402-3300PF_50V_2,6010A0025701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-332-K,50V-X7R-0402-TAP; signal model: C2_6010A0025701_3300pF_50V_2; room: Sheet18
C2970 C7035-C7037 C7152 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet15
C2971 C2990 C7050 C7100 C7153 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_10uF_6_3V_3; room: Sheet15
C2994 C2995 = CSC0805: part number: CSC0805-22UF_6.3V_5_DY,6010A0040702_DY,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_DY_22uF_6_3V_5_DY; room: Sheet15
C3015 = CSC0402: part number: CSC0402-680PF_50V_2_DY,6010A0025501_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-681-K,50V-X7R-0402-TAP; signal model: C2_6010A0025501_DY_680pF_50V_2_DY; room: Sheet38
C3051-C3056 = CSC0402: part number: CSC0402-12PF_50V_2,6010A0036103,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-12PF-50V-J-NPO-0402-TAP; signal model: C2_6010A0036103_12pF_50V_2; room: Sheet37
C3058 C3300-C3307 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet37
C3059 C3060 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet37
C3061 C3066 C3089 C3091 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet36
C3062 C3067 C3075-C3081 C3085 C3093 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet36
C3065 C3088 C3090 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet36
C3068 C3070 = CSC0402: part number: CSC0402-2.2UF_6.3V_2_DY,6010B0059301_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059301_DY_2_2uF_6_3V_2_DY; room: Sheet36
C3069 = CSC0402: part number: CSC0402-0.01UF_50V_2_DY,6010B0058401_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2_DY; room: Sheet36
C3071 C3072 = CSC0402: part number: CSC0402-15PF_50V_2,6010071502AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP,15PF,J-50V-NPO-0402-TAP; signal model: C2_6010071502AT_15pF_50V_2; room: Sheet36
C3073 C3094 = CSC0402: part number: CSC0402-1UF_6.3V_2_DY,6010B0006001_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_DY_1uF_6_3V_2_DY; room: Sheet36
C3074 C3087 = CSC0402: part number: CSC0402-0.1UF_16V_2_DY,6010A0036403_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_DY_0_1uF_16V_2_DY; room: Sheet36; signal model: C2_6010A0036403_0_1uF_16V_2
C3092 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009904,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009904_4_7uF_6_3V_3; room: Sheet36
C3308 C3311 C3357 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet37
C3310 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_10uF_6_3V_3; room: Sheet37
C3501 = CSC0402: part number: CSC0402-10PF_50V_2_DY,6010A0025401_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-10PF-D,50V-NPO-0402-TAP; signal model: C2_6010A0025401_DY_10pF_50V_2_DY; room: Sheet48
C3502-C3504 C3506 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet48
C3600 C3601 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet52
C3602 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet52
C4100-C4103 C4108 C4112 C4114 C4116 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet32
C4104 C4110 C4119 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet32
C4105 C4111 C4120 C4146 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059301,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059301_2_2uF_6_3V_2; room: Sheet32
C4106 = CAP_TA_SP: part number: CAP_TA_SP-330UF_2.5V,6010B0106701,CSTJB_350X280X200_2_300,2.15MM,CAP_TA_SP,,,CAPACITOR-TA-SP,330UF,2.5V,M,85C,BX1.9,SMD,TR,45MOHM; signal model: C2_6010B0106701_330uF_2_5V; room: Sheet32
C4107 C4109 C4113 C4115 C4117 C4118 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_10uF_6_3V_3; room: Sheet32
C4121 C4122 C4124 = CSC0402: part number: CSC0402-0.022UF_16V_2,6010A0000101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-223-K,16V-X7R-0402-TAP; signal model: C2_6010A0000101_0_022uF_16V_2; room: Sheet25
C4125-C4128 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet33
C4129 C4135 C4136 C4138 C4139 C4142 C4144 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet33
C4130 C4137 C4145 C4147 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059301,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059301_2_2uF_6_3V_2; room: Sheet33
C4131 = CAP_TA_SP: part number: CAP_TA_SP-330UF_2.5V_DY,6010B0106701_DY,CSTJB_350X280X200_2_300,2.15MM,CAP_TA_SP,,,CAPACITOR-TA-SP,330UF,2.5V,M,85C,BX1.9,SMD,TR,45MOHM; signal model: C2_6010B0106701_330uF_2_5V_DY; room: Sheet33
C4132-C4134 C4140 C4141 C4143 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_10uF_6_3V_3; room: Sheet33
C4200-C4207 C4209-C4214 C7654 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet61
C4411 C5009 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet19
C4514 = CSC0402: part number: CSC0402-47PF_50V_2,6010074702AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-470-J,50V-NPO-0402; signal model: C2_6010074702AT_47pF_50V_2; room: Sheet21
C4515 C4516 C4525-C4528 C4990 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_10uF_6_3V_3; room: Sheet30
C4521 C4522 C4529-C4540 C4542 C4544 C4545 C4547-C4549 C4559-C4561 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040702,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_22uF_6_3V_5; room: Sheet30
C4555 = CSC0603: part number: CSC0603-4.7UF_6.3V_3,6010B0009904,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009904_4_7uF_6_3V_3; room: Sheet30
C4590 = CSC0603: part number: CSC0603-10UF_6.3V_3_DY,6010B0044901_DY,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_DY_10uF_6_3V_3_DY; room: Sheet30
C4700 C4785 C4786 C4790 C4792 C4935 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040702,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_22uF_6_3V_5; room: Sheet29
C4701 C4710 C4714 C4716 C4718-C4721 C4723 C4724 C4728 C4730 C4746 C4758 C4761 C4762 C4789 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet29
C4709 C4712 C4717 C4753 C4763 C4765 C4943 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet29
C4729 = CSC0805: part number: CSC0805-22UF_6.3V_5_DY,6010A0040702_DY,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_DY_22uF_6_3V_5_DY; room: Sheet29
C4751 C4754 C4755 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_10uF_6_3V_3; room: Sheet29
C4760 = CSC0402: part number: CSC0402-1UF_6.3V_2_DY,6010B0006001_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_DY_1uF_6_3V_2_DY; room: Sheet29
C4764 C4766 C4768 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet27
C4767 C4788 = CSC0402: part number: CSC0402-18PF_50V_2,6010A0036105,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-18PF-50V-J-NPO-0402-TAP; signal model: C2_6010A0036105_18pF_50V_2; room: Sheet27
C4787 = CSC0603: part number: CSC0603-10UF_6.3V_3_DY,6010B0044901_DY,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_DY_10uF_6_3V_3_DY; room: Sheet29
C4818-C4821 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet27
C4822 C4823 C4831-C4834 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet26
C4826 C4828 = CSC0402: part number: CSC0402-15PF_50V_2,6010071502AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP,15PF,J-50V-NPO-0402-TAP; signal model: C2_6010071502AT_15pF_50V_2; room: Sheet28
C4920 = CSC0402: part number: CSC0402-0.15UF_10V_2,6010B0092101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.15UF,10V,K,X5R,0402,TR; signal model: C2_6010B0092101_0_15uF_10V_2; room: Sheet20
C4937 = CSC0402: part number: CSC0402-0.1UF_16V_2_DY,6010071041BT_DY,CSC_100X050X055_2,0.7MM,CSC0402,0402,,CAP-CHIP-104-Z,16V-TAP(0402); signal model: C2_6010071041BT_DY_0_1uF_16V_2_DY; room: Sheet20
C5010 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet19
C5301-C5309 C5311 C5313 C5398 C5399 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet34
C5310 C5312 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet34
C5314 = CSC0402: part number: CSC0402-2.2UF_6.3V_2_DY,6010B0059301_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059301_DY_2_2uF_6_3V_2_DY; room: Sheet34
C5401-C5404 C5409 C5411 C5413 C5498 C5499 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet35
C5410 C5412 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet35
C5414 = CSC0402: part number: CSC0402-2.2UF_6.3V_2_DY,6010B0059301_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059301_DY_2_2uF_6_3V_2_DY; room: Sheet35
C5450 = CSC0603: part number: CSC0603-22UF_6.3V_3,6010B0219001,CSC_160X080X090_2,1.05MM,CSC0603,0603,,CAPACITOR-CHIP,22UF,6.3V,R6,0603,TR; signal model: C2_6010B0219001_22UF_6_3V_3; room: Sheet34
C6000 C6001 C6010 C6011 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet5
C6002 = CSC0805: part number: CSC0805-CSC0805_DY,CSC0805_DY,CSC_200X125X130_2,1.45MM,CSC0805,0805,,CSC0805_OPEN; signal model: C2_CSC0805_DY_CSC0805_DY; room: Sheet5
C6015 = CSC0402: part number: CSC0402-0.047UF_16V_2,6010B0046101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.047UF,16V,K,X7R,0402,TAP; signal model: C2_6010B0046101_0_047uF_16V_2; room: Sheet5
C6016 C6018 C7500 C7501 C7503 = CSC0402: part number: CSC0402-100PF_50V_2,6010071012AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-101-J,50V-NPO-0402; signal model: C2_6010071012AT_100pF_50V_2; room: Sheet16
C6017 C6020 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet16
C6019 C6023 C6028 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet5
C6021 C6024 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet5
C6022 C6049 = CSC0402: part number: CSC0402-100PF_50V_2,6010071012AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-101-J,50V-NPO-0402; signal model: C2_6010071012AT_100pF_50V_2; room: Sheet5
C6025 = CSC0402: part number: CSC0402-1UF_10V_2,6010B0055001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,10V,K,X5R,0402,TR; signal model: C2_6010B0055001_1uF_10V_2; room: Sheet5
C6027 C6029 = CSC0603: part number: CSC0603-1UF_25V_3,6010B0067601,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,1UF,25V,K,X5R,0603,TR; signal model: C2_6010B0067601_1uF_25V_3; room: Sheet5
C6030 C7600 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet5
C6031 C6032 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet5
C6100 C6150 = CAP_AL_SP: part number: CAP_AL_SP-100UF_6.3V,6010B0228101,CS_730X430X210_2,2.25MM,CAP_AL_SP,,,CAPACITOR-AL-SP,100UF,6.3V,M,-40~+105C,DX1.9,SMD,TR,17MOHM; signal model: C2_6010B0228101_100uF_6_3V; room: Sheet7
C6101 C6151 C6152 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040702,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_22uF_6_3V_5; room: Sheet7
C6109 C6115 C6156-C6158 C6165 C6169 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet7
C6110 C6160 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet7
C6111 C6161 = CSC0805: part number: CSC0805-4.7UF_25V_5,6010B0048901,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP,4.7UF,25V,K,X5R,0805,TR; signal model: C2_6010B0048901_4_7uF_25V_5; room: Sheet7
C6120 C6121 = CSC0603: part number: CSC0603-2.2UF_10V_3,6010B0011501,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,2.2UF,10V,K,X5R,0603,TR; signal model: C2_6010B0011501_2_2uF_10V_3; room: Sheet7
C6122 C6172 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet7
C6159 = CSC0603: part number: CSC0603-0.22UF_25V_3,6010B0027101,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,0.22UF,25V,K,X5R,0603,TR; signal model: C2_6010B0027101_0_22uF_25V_3; room: Sheet7
C6166 = CSC0402: part number: CSC0402-220PF_50V_2_DY,6010B0076701_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP,220PF,50V,J,C0G,0402,TR; signal model: C2_6010B0076701_220pF_50V_2_DY; room: Sheet7
C6200-C6203 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040702,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_22uF_6_3V_5; room: Sheet9
C6204 = CSC0805: part number: CSC0805-22UF_6.3V_5_DY,6010A0040702_DY,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_DY_22uF_6_3V_5_DY; room: Sheet9
C6210 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet9
C6211 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet9
C6215 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet9
C6216 C6242 C6243 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet9
C6217 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet9
C6240 C6241 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_10uF_6_3V_3; room: Sheet9
C6300-C6303 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040702,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_22uF_6_3V_5; room: Sheet10
C6304 = CSC0805: part number: CSC0805-22UF_6.3V_5_DY,6010A0040702_DY,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_DY_22uF_6_3V_5_DY; room: Sheet10
C6310 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet10
C6311 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet10
C6315 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet10
C6316 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet10
C6317 = CSC0402: part number: CSC0402-0.01UF_50V_2,6010B0058401,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.01UF,50V,K,X7R,0402,TAP; signal model: C2_6010B0058401_0_01uF_50V_2; room: Sheet10
C6350 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040702,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_22uF_6_3V_5; room: Sheet11
C6352 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet11
C6360 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_10uF_6_3V_3; room: Sheet11
C6450 = CSC0805: part number: CSC0805-22UF_6.3V_5,6010A0040702,CSC_200X125X130_2,1.45MM,CSC0805,0805,X5R,CAP-CHIP-22UF-6.3V-M-X5R-0805-TAP; signal model: C2_6010A0040702_22uF_6_3V_5; room: Sheet12
C6452 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet12
C6460 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_10uF_6_3V_3; room: Sheet12
C6610 C6611 = CSC0805: part number: CSC0805-10UF_25V_5,6010B0150801,CSC_200X125X140_2,1.55MM,CSC0805,0805,X5R,CAP-CHIP,10UF,25V,K,X5R,0805,TR,1.25MM; signal model: C2_6010B0150801_10UF_25V_5; room: Sheet14
C6613 C6614 C6618 C7661 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet14
C6615 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet14
C6616 = CSC0402: part number: CSC0402-1UF_10V_2,6010B0055001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,10V,K,X5R,0402,TR; signal model: C2_6010B0055001_1uF_10V_2; room: Sheet14
C6617 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet14
C6639 = CSC0402: part number: CSC0402-0.0015UF_50V_2,60100715220Z,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-152-K,50V-X7R-0402-TAP; signal model: C2_60100715220Z_0_0015uF_50V_2; room: Sheet13
C6640 C6641 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet13
C6642 C6643 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet13
C6644 = CSC0603: part number: CSC0603-0.33UF_10V_3,6010073340CT,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP-334-K,10V-X5R-TAP(0603); signal model: C2_6010073340CT_0_33uF_10V_3; room: Sheet13
C6645 = CSC0402: part number: CSC0402-4700PF_50V_2,6010A0029301,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-472-K,50V-X7R-0402-TAP; signal model: C2_6010A0029301_4700pF_50V_2; room: Sheet13
C6646 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet13
C6699 = CAP_AL_SP: part number: CAP_AL_SP-15UF_25V,6010B0185101,CS_350X280X200_2,2.15MM,CAP_AL_SP,,,CAPACITOR-TA-SP,15UF,25V,M,105C,BX1.9,SM; signal model: C2_6010B0185101_15uF_25V; room: Sheet14
C6900 C6998 = CSC0402: part number: CSC0402-0.22UF_6.3V_2,6010A0050701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP-0.22UF-M-6.3V-X5R-0402-TAP; signal model: C2_6010A0050701_0_22uF_6_3V_2; room: Sheet8
C6902 = CSC0402: part number: CSC0402-3900PF_16V_2,6010A003630L,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP-3900PF-16V-K-X7R-0402-TAP; signal model: C2_6010A003630L_3900pF_16V_2; room: Sheet6
C6906 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet6
C6999 = CSC0402: part number: CSC0402-100PF_50V_2,6010071012AT,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-101-J,50V-NPO-0402; signal model: C2_6010071012AT_100pF_50V_2; room: Sheet8
C7001 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet17; signal model: C2_6010A0036403_0_1uF_16V_2
C7110 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet15
C7352 C7355 = CSC0603: part number: CSC0603-10UF_6.3V_3,6010B0044901,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,10UF,6.3V,M,X5R,0603,TR; signal model: C2_6010B0044901_10uF_6_3V_3; room: Sheet17
C7400 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet18
C7455 C7458 C7468 C7473 C7490 C7491 C7495 = CSC0402: part number: CSC0402-82PF_50V_2,6010A003610G,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-82PF-50V-J-NPO-0402-TAP; signal model: C2_6010A003610G_82pF_50V_2; room: Sheet62
C7456 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet62; signal model: C2_6010A0036403_0_1uF_16V_2
C7457 C7459 C7461 C7463 C7465 C7469 C7471 = CSC0402: part number: CSC0402-68PF_50V_2_DY,60100768020T_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP-680-J,50V-TAP(0402); signal model: C2_60100768020T_68pF_50V_2_DY; room: Sheet62
C7460 C7462 C7464 C7466 C7470 C7474 = CSC0402: part number: CSC0402-82PF_50V_2_DY,6010A003610G_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-82PF-50V-J-NPO-0402-TAP; signal model: C2_6010A003610G_DY_82pF_50V_2_DY; room: Sheet62
C7467 C7472 = CSC0402: part number: CSC0402-68PF_50V_2,60100768020T,CSC_100X050X040_2,0.55MM,CSC0402,0402,C0G,CAP-CHIP-680-J,50V-TAP(0402); signal model: C2_60100768020T_68pF_50V_2; room: Sheet62
C7475 C7476 C7478 C7488 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet62
C7485 C7486 = CSC0603: part number: CSC0603-4.7UF_6.3V_3_DY,6010B0009904_DY,CSC_160X080X080_2,0.95MM,CSC0603,0603,X5R,CAP-CHIP,4.7UF,6.3V,K,X5R,0603,TR; signal model: C2_6010B0009904_DY_4_7uF_6_3V_3_DY; room: Sheet62
C7487 = CSC0402: part number: CSC0402-2.2UF_6.3V_2,6010B0059301,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059301_2_2uF_6_3V_2; room: Sheet62
C7494 = CSC0402: part number: CSC0402-2.2UF_6.3V_2_DY,6010B0059301_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,2.2UF,6.3V,M,X5R,0402,TR; signal model: C2_6010B0059301_DY_2_2uF_6_3V_2_DY; room: Sheet62
C7502 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet16
C7520 C7521 C7578 C7579 C7597 C7598 C7604-C7606 C7627-C7629 C7631 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet61
C7581 C7583-C7589 C7591-C7593 C7596 C7607 C7608 C7612-C7614 C7617 C7622 C7623 = CSC0402: part number: CSC0402-0.1UF_16V_2_DY,6010A0036403_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_DY_0_1uF_16V_2_DY; room: Sheet61
C7582 C7594 C7599 C7625 = CSC0402: part number: CSC0402-82PF_50V_2,6010A003610G,CSC_100X050X040_2,0.55MM,CSC0402,0402,NPO,CAP-CHIP-82PF-50V-J-NPO-0402-TAP; signal model: C2_6010A003610G_82pF_50V_2; room: Sheet61
C7595 C7609 C7611 C7616 C7618 C7619 = CSC0402: part number: CSC0402-0.1UF_25V_2_DY,6010B0087101_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2_DY; room: Sheet61
C7601-C7603 C7621 C7641-C7643 C7650 = CSC0402: part number: CSC0402-0.1UF_25V_2,6010B0087101,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,0.1UF,25V,K,X5R,0402,TR; signal model: C2_6010B0087101_0_1uF_25V_2; room: Sheet61
C7610 C7615 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet7
C7620 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet9
C7630 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet10
C7632-C7640 = CSC0402: part number: CSC0402-0.22UF_6.3V_2,6010A0050701,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP-0.22UF-M-6.3V-X5R-0402-TAP; signal model: C2_6010A0050701_0_22uF_6_3V_2; room: Sheet61
C9000 C9002 C9005-C9007 C9010 C9015 C9036 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet58
C9001 C9003 C9004 C9009 C9011 C9035 = CSC0402: part number: CSC0402-1UF_6.3V_2,6010B0006001,CSC_100X050X040_2,0.55MM,CSC0402,0402,X5R,CAP-CHIP,1UF,6.3V,K,X5R,0402,TR; signal model: C2_6010B0006001_1uF_6_3V_2; room: Sheet58
C9021 = CSC0402: part number: CSC0402-1000PF_50V_2,6010071020AT,CSC_100X050X055_2,0.7MM,CSC0402,0402,X7R,CAPACITOR-CHIP,1000PF,50V,K,X7R,0402,TR; signal model: C2_6010071020AT_1000PF_50V_2; room: Sheet58
C9113 = CSC0402: part number: CSC0402-0.1UF_16V_2,6010A0036403,CSC_100X050X040_2,0.55MM,CSC0402,0402,X7R,CAP-CHIP,0.1UF,16V,K,X7R,0402,TAP; signal model: C2_6010A0036403_0_1uF_16V_2; room: Sheet57
C9114 = CSC0402: part number: CSC0402-CSC0402_DY,CSC0402_DY,CSC_100X050X040_2,0.55MM,CSC0402,0402,,CSC0402_OPEN; signal model: C2_CSC0402_DY_CSC0402_DY; room: Sheet57
CN200 = CN_40_2G: part number: CN_40_2G-ACES_51540_04041_001_40P,6012B0541801,FPC_ACES_40_050_R_180_1,1.95MM,,CONNECTOR,FPC,1.8MM,FL,1X40,0.5MM,90D,SMD,TR,HI TEMP PLASTIC,G/F; room: Sheet53
CN202 = 6712K_F08M_02L: part number: 6712K_F08M_02L-ENTERY_6712K_F08M_02L_8P,6012B0275004-003,SWBACK-6012B0275004-003,2.15MM,,CONNECTOR,FPC,2.0MM,FL,1X8,0.5MM,90D,SMD,TR,G/F; room: Sheet53
CN290 CN9100 = 50505_0064N_001: part number: 50505_0064N_001-ACES_50505_0064N_001_6P,6012B0317701-002,COMET-6012B0317701-002,1.65MM,,CONNECTOR,FPC,1.5MM,FL,1X6,1.0MM,90D,SMD,TR,MATT TIN; room: Sheet57
CN300 = CN_34_2G: part number: CN_34_2G-ACES_51510_0344N_001_34P,6012B0519501,FPC_ACES_34_080_R_200_1,2.15MM,,CONNECTOR,FPC,FL,1X34,0.8MM,90D,SMD,TR; room: Sheet47
CN301 = 6712K_F08M_02L: part number: 6712K_F08M_02L-ENTERY_6712K_F08M_02L_8P,6012B0275004-003,SWBACK-6012B0275004-003,2.15MM,,CONNECTOR,FPC,2.0MM,FL,1X8,0.5MM,90D,SMD,TR,G/F; room: Sheet47
CN365 = 91960_0084L: part number: 91960_0084L-ACES_91960_0084L_8P,6026B0150101-002,SWBACK-6026B0150101-002,5MM,SOCKET,SPI,8P,1.27MM,5.0MM,STR,SMD,TR; room: Sheet46
CN375 = 50238_02471_001: part number: 50238_02471_001-ACES_50238_02471_001_24P_DY,6012B0073604-003_DY,GALIEO16-6012B0073604-003,4.55MM,,CONNECTOR,W TO B,4.25MM,ML,2X12,1.0MM,5.6CC,STR,SMD,TR,G/F; room: Sheet46
CN600 = CN_10_2G: part number: CN_10_2G-ACES_50376_01001_001_10P,6012B0452401-001,SWBACK-6012B0452401-001,1.73MM,,CONNECTOR,W TO B,H=1.55MM,ML,1X10,0.6MM,90D,SMD,TR,G/F; room: Sheet64
CN640 = 50271_0040N_001: part number: 50271_0040N_001-ACES_50271_0040N_001_4P,6012B0194003,WTB_ACES_4_125_SMD_R_M_340_1,3.55MM,,CONNECTOR,W TO B,4.2MM,ML,1X4,1.25MM,STR,SMD,TR,MATT TIN; room: Sheet54
CN820 = A0131_0001: part number: A0131_0001-FULLINHOPE_A0131_0001_12P,6026B0256701,SD_FULLP_12_SMD_RV_455,4.70MM,,SOCKET,SD CARD,12P,2.5MM,GOLD FLASH,5.25MM,90D,SMD,STANDARD,TR; room: Sheet56
CN1300 = AS0BC26_S30BE_7H: part number: AS0BC26_S30BE_7H-FOXCONN_AS0BC26_S30BE_7H_75P,6026B0291001,MPCI_FOX_75_050_RV_300,3.35MM,,SOCKET,PCIEX KEY E NGFF,75P,0.5MM,GOLD,10U,3.0MM,30D,SMD,TR; room: Sheet50
CN1400 = APCI0018_P005A: part number: APCI0018_P005A-LOTES_APCI0018_P005A_75P,6026B0243101,MPCI_LOTES_75_050_RV_300,3.35MM,,SOCKET,PCIEX KEY B NGFF,75P,0.5MM,GOLD,10U,3.0MM,30D,DIP,STANDARD,TR; room: Sheet51
CN1451 = PMPAT3_08GLBS7N14N0: part number: PMPAT3_08GLBS7N14N0-TAI_PMPAT3_08GLBS7N14N0_9P,6026B0176401-001,SIM_TAIT_9_ST_150-001,1.65MM,,SOCKET,SIM CARD,9P,GOLD,10U,1.5MM,90D,SMD,TR; room: Sheet51
CN1700 = CN_22_2G_SATA_SP: part number: CN_22_2G_SATA_SP-ALLTOP_C11848_122A1_L_22P,6012B0520601-005,SWBACK-6012B0520601-005,4.90MM,,CONNECTOR,HDD,SATA H=1.8/3.65MM,FL,BLK,1X22,90D,SMD,TR,GOLD,15U; room: Sheet40
CN1951 = APCI0020_P001A01: part number: APCI0020_P001A01-LOTES_APCI0020_P001A01_75P,6026B0240301,MPCI_LOTES_75_050_ST_300,3.35MM,,SOCKET,PCIEX,75P,0.5MM,GOLD,30U,3.0MM,30D,DIP,SMD,TR; room: Sheet40
CN2200 = 50505_0064N_001: part number: 50505_0064N_001-ACES_50505_0064N_001_6P,6012B0317701-002,COMET-6012B0317701-002,1.65MM,,CONNECTOR,FPC,1.5MM,FL,1X6,1.0MM,90D,SMD,TR,MATT TIN; room: Sheet44
CN2400 CN2401 CN2500 = CN_09_4G: part number: CN_09_4G-SINGA_2UB4006_180101F_9P,6012B0504101,USB3_SIGAT_9_DIP_SS_S_240_526,5.41MM,,CONNECTOR,USB 3.0,2.4/5.6MM,FL,BLU,9P,1.5CC,90D,DIP,TR,G/F; room: Sheet42
CN3000 = CN_40_4G: part number: CN_40_4G-ACES_59003_04006_001_40P,6012B0522301-001,SWBACK-6012B0522301-001,2.75MM,,CONNECTOR,W TO B,2.6MM,FL,1X40,0.5MM,STR,SMD,TR,G/F; room: Sheet38
CN3050 = CN_15_2G: part number: CN_15_2G-SYN_070546HR015M22BZR_15P,6012B0334801-002,SWBACK-6012B0334801-002,2.85MM,,CONNECTOR,D SUB,H=-2.2/2.7MM,FL,BLK,15P,1.145MM,1.95CC,90D,DIP,TR,HI TEMP PLASTIC,G/F; room: Sheet37
CN3300 = CN_20_4G: part number: CN_20_4G-TAIWIN_DP004_206CRL_TW_20P,6012B0519601-001,SWBACK-6012B0519601-001,5.53MM,,CONNECTOR,DISPLAY PORT,6.43MM,FL,BLK,20P,1.0CC,90D,DIP,TR,GOLD,30U; room: Sheet37
CN3601 = QL1046L_D262AR_7H: part number: QL1046L_D262AR_7H-FOX_QL1046L_D262AR_7H_92P,6012B0449701,DOCK_FOX_94_050_DIP_440,4.05MM,,CONNECTOR,DOCKING,2.0/4.8MM,FL,92P,90D,DIP,TR,G/F; room: Sheet52
CN4100 = AS0A626_U4R6_7H: part number: AS0A626_U4R6_7H-FOX_AS0A626_U4R6_7H_HP_204P,6026B0221601,DDR3_FOX_204_RV_400_4,4.15MM,,SOCKET,DDR3 DIMM,204P,0.6MM,GOLD,10U,4.0MM,90D,SMD,REVERSE,TR; room: Sheet32
CN4125 = AS0A626_U4R6_7H: part number: AS0A626_U4R6_7H-FOX_AS0A626_U4R6_7H_HP_204P,6026B0221601,DDR3_FOX_204_RV_400_4,4.15MM,,SOCKET,DDR3 DIMM,204P,0.6MM,GOLD,10U,4.0MM,90D,SMD,REVERSE,TR; room: Sheet33
CN4300 = 50271_0040N_001: part number: 50271_0040N_001-ACES_50271_0040N_001_4P,6012B0194003,WTB_ACES_4_125_SMD_R_M_340_1,3.55MM,,CONNECTOR,W TO B,4.2MM,ML,1X4,1.25MM,STR,SMD,TR,MATT TIN; room: Sheet19
CN4750 = CN_02_2G: part number: CN_02_2G-ENTERY_3703K_Q02N_11L_2P,6012B0111314,WTB_ENTRY_2_100_SMD_R_M_295,3.1MM,,CONNECTOR,W TO B,2.95MM,ML,NTU,1X2,1.0MM,90D,SMD,TR,MATT TIN,100-160U; room: Sheet27
CN4920 = BSH_030_01_L_D_A_TR: part number: BSH_030_01_L_D_A_TR-SAMTEC_BSH_030_01_L_D_A_TR_60P,6012A0109001,BTB_SAM_60_050_F_325,3.3MM,CONN-FL-2X30-0.5MM-SMD-B TO B; room: Sheet20
CN4941 = 50501_0184N_001: part number: 50501_0184N_001-ACES_50501_0184N_001_18P_DY,6012B0354701_DY,FPC_ACES_18_050_R_200_1,2.25MM,,CONNECTOR,FPC,2.0MM,FL,0.5A,1X18,0.5MM,90D,SMD,TR,HI TEMP PLASTIC,MATT TIN; room: Sheet20
CN6050 = BP02083_B24B1_9H: part number: BP02083_B24B1_9H-FOX_BP02083_B24B1_9H_8P,6012B0335005-002,AEROSMIT-6012B0335005-002,2.5MM,,CONNECTOR,BATTERY,2.5MM,ML,1X8,2.0MM,90D,DIP,TR,GOLD,30U; room: Sheet16
CN9000 = CN_40_2G: part number: CN_40_2G-ACES_51540_04041_001_40P,6012B0541801,FPC_ACES_40_050_R_180_1,1.95MM,,CONNECTOR,FPC,1.8MM,FL,1X40,0.5MM,90D,SMD,TR,HI TEMP PLASTIC,G/F; room: Sheet58
CN9001 = 083AA24F08B: part number: 083AA24F08B-HAMB_083AA24F08B_10P,6026B0198201,SMART_CONCT_10_ST_S_255,2.45MM,,SOCKET,SMART CARD+SWITCH,10P,GOLD,2.2MM,STR,SMD,TR; room: Sheet58
CN9002 = CN_15_2G: part number: CN_15_2G-ACES_51548_01541_001_15P,6012B0587101,FPC_ACES_15_050_R_200,2.15MM,,CONNECTOR,FPC; room: Sheet58
CN9021 = 6712K_F08M_02L: part number: 6712K_F08M_02L-ENTERY_6712K_F08M_02L_8P,6012B0275004-003,SWBACK-6012B0275004-003,2.15MM,,CONNECTOR,FPC,2.0MM,FL,1X8,0.5MM,90D,SMD,TR,G/F; room: Sheet58
D100 = SCH_SINGLE_B: part number: SCH_SINGLE_B-DIODE-BAT54-TAP-PHP_DY,60110GA0367T_DY,DSSOT23_292X130X109_3_095,1.24MM,SCH_SINGLE_B,DIODE-BAT54-TAP-PHP; room: Sheet46
D110 D126 = 23_22B_Y2ST3D_C30_2A: part number: 23_22B_Y2ST3D_C30_2A-EVL_23_22B_Y2ST3D_C30_2T_4P,6011B0137801,LED_EVERL_V_D_320X125X110,1.25MM,,DIODE-LED,YEL/WHT,3212,45/112MCD,140D,50/25MA,SMD,3P,TR; room: Sheet57
D301 = DB3X313J0L: part number: DB3X313J0L-PANASONIC_DB3X313J0L_SOT_3P,6011B0148301,DSSOT23_290X150X140_3_095,1.55MM,,DIODE,SCH,30V,200MA,1.5NS,SMD,SOT-23,TR; room: Sheet47
D302-D304 = BAW56S: part number: BAW56S-BAW56S,6011B0039701,DSSOT363_200X125X110_6_065,1.25MM,DIODE,DUAL SWCH,75V,250MA,4NS,SMD,SOT363,TAP; room: Sheet47
D485 D486 = PESD5V0S1BB: part number: PESD5V0S1BB-PHP_PESD5V0S1BB_SOD523_2P,6011B0098001,DSSOD523_120X080X065_2-2,0.8MM,,DIODE,ESD,5V,130W,SMD,SOD523,TR; room: Sheet49
D500 D501 = DB3X313J0L: part number: DB3X313J0L-PANASONIC_DB3X313J0L_SOT_3P,6011B0148301,DSSOT23_290X150X140_3_095,1.55MM,,DIODE,SCH,30V,200MA,1.5NS,SMD,SOT-23,TR; room: Sheet54
D801 = DB3X313J0L: part number: DB3X313J0L-PANASONIC_DB3X313J0L_SOT_3P,6011B0148301,DSSOT23_290X150X140_3_095,1.55MM,,DIODE,SCH,30V,200MA,1.5NS,SMD,SOT-23,TR; room: Sheet56
D1300 = SCH_SINGLE_B: part number: SCH_SINGLE_B-BAT54_30V_0.2A,6011A0026801,TSOT23_290X130X110_3_096_P1,1.25MM,SCH_SINGLE_B,DIODE-SCH-30V-200MA-200MW-5NS-SMD-SOT23-TR; room: Sheet50
D1410 = SCH_SINGLE_B: part number: SCH_SINGLE_B-BAT54_30V_0.2A,6011A0026801,TSOT23_290X130X110_3_096_P1,1.25MM,SCH_SINGLE_B,DIODE-SCH-30V-200MA-200MW-5NS-SMD-SOT23-TR; room: Sheet51
D1451 = D_DUAL_SERIES_A: part number: D_DUAL_SERIES_A-DIODES_BAV99,6011B0023401,DSMI_3A,1.3MM,D_DUAL_SERIES_A,DIODE,SWCH,100V,300MA,350MW,SMD,SOT23,TR; room: Sheet51
D2201 = PESD5V2S2UT: part number: PESD5V2S2UT-PHP_PESD5V2S2UT_SOT23_3P_DY,6011B0062301_DY,DSOT23_290X130X110_3_095,1.25MM,DIODE,ESD,5.2V,15A,260W,SMD,SOT23,TR; room: Sheet44
D2551 = DB3X313J0L: part number: DB3X313J0L-PANASONIC_DB3X313J0L_SOT_3P_DY,6011B0148301_DY,DSSOT23_290X150X140_3_095,1.55MM,,DIODE,SCH,30V,200MA,1.5NS,SMD,SOT-23,TR; room: Sheet41
D2951 D7400 = DB3X313J0L: part number: DB3X313J0L-PANASONIC_DB3X313J0L_SOT_3P,6011B0148301,DSSOT23_290X150X140_3_095,1.55MM,,DIODE,SCH,30V,200MA,1.5NS,SMD,SOT-23,TR; room: Sheet18
D3000 = SCH_SINGLE_B: part number: SCH_SINGLE_B-BAT54_30V_0.2A,6011A0026801,TSOT23_290X130X110_3_096_P1,1.25MM,SCH_SINGLE_B,DIODE-SCH-30V-200MA-200MW-5NS-SMD-SOT23-TR; room: Sheet38
D4200-D4205 = VARISTOR: part number: VARISTOR-SFI0402_050E3R0PP_LF_DY,6011B0161301_DY,DS_100X050X060_2_S2,0.75MM,VARISTOR,DIODE,VARISTOR,60V,1A,SMD,TR; room: Sheet61
D4750 = SCH_DUAL_2IN_1OUT_A: part number: SCH_DUAL_2IN_1OUT_A-BAT54C,60110GA0628T,DSSOT23_290X130X105_3_095,1.2MM,SCH_DUAL_2IN_1OUT_A,SOT23,200MA,DIODE-BAT54C-TAP-PHP; room: Sheet27
D6015 = SM24: part number: SM24-PANJTT_PJSOT24C_SOT23_3P,6011B0148901,DSOT23_292X130X110_3_095,1.25MM,,DIODE,TVS,24V,12A,500W,SMD,SOT23,TR; room: Sheet16
D6016 D6017 = SCH_DUAL_2IN_1OUT_A: part number: SCH_DUAL_2IN_1OUT_A-BAT54C,60110GA0628T,DSSOT23_290X130X105_3_095,1.2MM,SCH_DUAL_2IN_1OUT_A,SOT23,200MA,DIODE-BAT54C-TAP-PHP; room: Sheet5
D6018 = DIODE_SCH: part number: DIODE_SCH-1SS355VMTE_17,6011B0129301-005,TOOTSIE-6011B0129301-005,0.9MM,DIODE_SCH,DIODE,SWCH,80V,225MA,SMD,SC-76,TR; room: Sheet5
D6019 = SCH_SINGLE: part number: SCH_SINGLE-B0530W_7,6011B0063001,DSSOD123_270X155X135_2,1.5MM,SCH_SINGLE,DIODE-SCH-30V-0.5A-SMD-TR; room: Sheet5
D6150 D6151 = D_DUAL_SERIES_A: part number: D_DUAL_SERIES_A-DIODES_BAV99,6011B0023401,DSMI_3A,1.3MM,D_DUAL_SERIES_A,DIODE,SWCH,100V,300MA,350MW,SMD,SOT23,TR; room: Sheet7
D6901 = ZN_SINGLE: part number: ZN_SINGLE-BZT52-B4V7S_DY,6011B0148401_DY,DSOD323_185X125X095_2_231,1.1MM,ZN_SINGLE,DIODE-ZNR,4.7V,5MA,200MW,SOD-323,TR; room: Sheet6
D7504-D7506 = PESD5V0S1BB: part number: PESD5V0S1BB-PHP_PESD5V0S1BB_SOD523_2P_DY,6011B0098001_DY,DSSOD523_120X080X065_2-2,0.8MM,,DIODE,ESD,5V,130W,SMD,SOD523,TR; room: Sheet16
D7600-D7605 = VARISTOR: part number: VARISTOR-SFI0402_050E3R0PP_LF,6011B0161301,DS_100X050X060_2_S2,0.75MM,VARISTOR,DIODE,VARISTOR,60V,1A,SMD,TR; room: Sheet61
D7606-D7610 D7612-D7621 = SFI0603_240E2R5PP_LF: part number: SFI0603_240E2R5PP_LF-SFI_SFI0603_240E2R5PP_LF_2P,6011B0096201,DS_160X080X090_2,1.05MM,,DIODE,ESD,24V,SMD,0603,TR; room: Sheet61
D7611 = SFI0603_240E2R5PP_LF: part number: SFI0603_240E2R5PP_LF-SFI_SFI0603_240E2R5PP_LF_2P,6011B0096201,DS_160X080X090_2,1.05MM,,DIODE,ESD,24V,SMD,0603,TR; room: Sheet62
D9030 D9032 D9033 = 12_22_Y2ST3D_C30_2C: part number: 12_22_Y2ST3D_C30_2C-EVL_12_22_Y2ST3D_C30_2C_3P,6011B0137701,LED_EVERL_R_D_300X200X100_2,1.15MM,,DIODE,LED WHITE/YELLOW,3P; room: Sheet58
D9031 = LED_SINGLE_3PIN_B: part number: LED_SINGLE_3PIN_B-EVL_12_21_T3D_CP1Q2B12Y_2C_2P,6011B0115101-001,ST133ID-6011B0115101-001,1.35MM,LED_SINGLE_3PIN_B,LED-WHITE 3.0X1.0,,DIODE-LED,WHITE,3010,112MCD,130D,25MA,SMD,2P,TR; room: Sheet58
D9100 = LED_SINGLE: part number: LED_SINGLE-19_217_W1D_AP1Q2QY_3T,6011B0028601,LED_EVERLI_V_S_160X080X040,0.55MM,LED_SINGLE,,,DIODE-LED,WHITE,1608,112MCD,130D,25MA,SMD,2P,TR; room: Sheet57
FIX1-FIX8 = FIX_MASK: part number: FIX_MASK-FIX_MASK,FIX_MASK,FIX_MASK,0.127MM,FIX_MASK,FIX_MASK; room: Sheet60
FIX600-FIX602 = FIX_MASK: part number: FIX_MASK-FIX_MASK,FIX_MASK,FIX_MASK,0.127MM,FIX_MASK,FIX_MASK; room: Sheet64
FIX9000-FIX9007 = FIX_MASK: part number: FIX_MASK-FIX_MASK,FIX_MASK,FIX_MASK,0.127MM,FIX_MASK,FIX_MASK; room: Sheet58
FIX9100-FIX9102 = FIX_MASK: part number: FIX_MASK-FIX_MASK,FIX_MASK,FIX_MASK,0.127MM,FIX_MASK,FIX_MASK; room: Sheet57
JACK485 = JM3611_SP51AB11_7H: part number: JM3611_SP51AB11_7H-FOX_JM3611_SP51AB11_7H_12P,6026B0256501,RJ45_FOX_12_DIP_RS_Y_510,5.25MM,,JACK+LED,GRN+YEL,RJ45,HIGH TEMP,12P,GOLD FLASH,DIP,TR; room: Sheet49
JACK600 = 2SJ3005_001211: part number: 2SJ3005_001211-SINGA_2SJ3005_023111F_7P,6026B0256901,AUDIO_SIGAT_7_R_265_540,5.25MM,,JACK,AUDIO,BLK,7P,GOLD FLASH,DIP,TR; room: Sheet55
JACK6000 = 2DC3092_000111F: part number: 2DC3092_000111F-SINGA_2DC3092_000111F_9P,6026B0256601,DC_SIGAT_3_R_145_358,3.5MM,,JACK,POWER,THERMOPLASTIC,3P,GOLD,DIP,TR; room: Sheet16
L400 = IDUT_SINGLE: part number: IDUT_SINGLE-SWF2520CF_4R7K_M,6014B0099601-002,STRIKE-6014B0099601-002,2.25MM,IDUT_SINGLE,,,,INDUCTOR,4.7UH,10%,7.96MHZ,600MA,1008INCH,SMD,TR; signal model: L2_6014B0099601-002_SWF2520CF_4R7K_M; room: Sheet49
L502 = BEAD_SINGLE: part number: BEAD_SINGLE-BLM18PG600SN1D,60140EA0314T,EMIS_BLM11,1.02MM,BEAD_SINGLE,,,,BEAD,60OHM,25%,500MA,0.1OHM,0603INCH,100MHZ,C,TR; signal model: L2_60140EA0314T_BLM18PG600SN1D; room: Sheet54
L550 L551 L602 = BEAD_SINGLE: part number: BEAD_SINGLE-BLM18PG600SN1D,60140EA0314T,EMIS_BLM11,1.02MM,BEAD_SINGLE,,,,BEAD,60OHM,25%,500MA,0.1OHM,0603INCH,100MHZ,C,TR; signal model: L2_60140EA0314T_BLM18PG600SN1D; room: Sheet55
L603 = BEAD_SINGLE: part number: BEAD_SINGLE-BLM15AG121SN1D_500MA,6014B0098001,LS_100X050X055_2,0.7MM,BEAD_SINGLE,,,,BEAD,120OHM,25%,500MA,0.25OHM,0402INCH,100MHZ,C,TR; signal model: L2_6014B0098001_BLM15AG121SN1D_500mA; room: Sheet64
L1400 = CHOKE_4PIN: part number: CHOKE_4PIN-WCM_2012_900T,6014B0264601,LS_200X120X120_4,1.35MM,CHOKE_4PIN,,,,CHOKE-90OHM-25%-330MA-0805-0.35HM-A-100M-TAP; signal model: L4_6014B0264601_WCM_2012_900T; room: Sheet51; signal model: L4_6014A0013901_WCM_2012_900T
L2400 L2404 L2500 = CHOKE_4PIN: part number: CHOKE_4PIN-WCM_2012_900T,6014B0264601,LS_200X120X120_4,1.35MM,CHOKE_4PIN,,,,CHOKE-90OHM-25%-330MA-0805-0.35HM-A-100M-TAP; signal model: L4_6014B0264601_WCM_2012_900T; room: Sheet42
L2550 = IDUT_SINGLE: part number: IDUT_SINGLE-SWF2520CF_4R7K_M,6014B0099601-002,STRIKE-6014B0099601-002,2.25MM,IDUT_SINGLE,,,,INDUCTOR,4.7UH,10%,7.96MHZ,600MA,1008INCH,SMD,TR; signal model: L2_6014B0099601-002_SWF2520CF_4R7K_M; room: Sheet41
