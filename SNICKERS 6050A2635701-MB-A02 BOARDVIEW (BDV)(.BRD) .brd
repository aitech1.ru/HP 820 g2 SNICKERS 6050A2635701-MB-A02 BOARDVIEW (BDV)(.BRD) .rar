# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DGND_CHASSIS1: length 3
  TOP w0.381: R7629.1 318.29,78.47 v2(318.68,78.85) ; C7629.1 318.17,77.58 v2(318.42,77.33)
  vias: v1(319.31,77.96) v2(320.33,77.58) v2(322.23,76.31) v2(326.04,78.85) v2(328.07,78.85) v2(328.2,76.44)
DGND_CHASSIS2: length 2.6
  TOP w0.381: R7627.1 318.17,58.41 v4(318.29,58.28) 317.99,58.28 317.28,58.99 C7627.1
  vias: v1(319.06,59.17) v4(318.55,60.9) v4(320.58,59.55) v4(322.23,60.95) v4(322.23,58.02)
DGND_CHASSIS3: length 4.5
  TOP w0.381: 318.3,43.8 317.45,43.8 C7631.1 316.56,44.18 316.14,44.61 R7631.1
  vias: v1(328.33,36.56) v4(319.69,42.4) v4(321.22,42.4) v4(322.23,42.66) v4(328.17,42.71)
DGND_PBN: length 13.1
  TOP w0.381: 277.93,30.85 CN9100.1 ; CN9100.1 279.57,30.85 ; CN9100.1 278.75,30.37
  TOP w0.508: v4(282,29.22) 281.9,29.12 CN9100.G2 ; CN9100.G1 282,38.35 v4(282,37.35)
  BOTTOM w0.381: 260.93,27.08 SW9100.1 ; SW9100.1 262.42,27.08 ; SW9100.1 v4(261.68,28.08) ; v1(267.24,30.21) v4(267.24,29.32) ; 281.62,31.3 U9100.3 ; U9100.3 282.58,31.3 ; U9100.3 282.1,31.87 ; U9100.3 282.1,30.73 ; 279.49,31.87 C9113.2
  BOTTOM w0.508: SW9100.G1 260.72,27.88 ; SW9100.G1 v4(260,28.74) ; SW9100.G1 259.28,27.88 ; SW9100.G1 260,27.32
  vias: v4(253.78,24.12) v4(256.32,24.75) v4(260,23.1) v4(260.13,19.42) v4(263.3,32.12) v4(264.19,37.07) v4(264.7,33.13) v4(266.48,36.18) v4(267.11,26.4) v4(268.26,33.39) v4(268.76,31.1) v4(269.78,35.8) v4(274.61,35.8) v4(276.77,36.94) v4(279.99,31.13) v4(280.19,37.07) v4(281.08,35.42) v4(281.72,30.01) v4(285.02,34.66) v4(285.02,28.81) v4(285.15,32.37) v4(285.4,30.47)
DGND_SM: length 59.2
  TOP w0.305: v2(78.52,106.28) 78.26,106.28 78,106.55 CN9000.14 ; v2(78.52,106.92) 78.5,106.94 CN9000.15
  TOP w0.356: CN9002.7 v2(81.15,158.74) ; CN9000.6 74,106.59 v2(73.44,106.03) ; 91,107.14 CN9000.40 ; CN9000.40 91,108.41 ; CN9000.40 91.35,107.77 ; CN9021.5 v2(71.26,148.85) ; 90.5,108.41 CN9000.39 90.5,107.14 ; CN9002.1 v2(77.39,160.15) ; 89.5,107.14 CN9000.37 89.5,108.41 ; 90,107.14 CN9000.38 90,108.41 ; CN9002.14 v2(84.65,158.9) ; CN9000.3 v2(72.5,106.87)
  TOP w0.381: R9037.2 v2(76.61,123.94) ; Q9031.2 73.96,139.83 v2(74.2,140.07) ; Q9031.2 73.37,140.36 ; Q9031.2 72.75,139.83 ; Q9031.2 73.37,139.3 ; C9007.2 v2(80.8,115.56) ; C9000.2 80.55,110.22 v2(80.68,110.35) ; C9002.2 80.55,112.38 v2(80.68,112.51) ; v2(73.06,123.3) 73.07,123.29 Q9032.4 ; C9004.2 80.09,108.99 v2(79.79,108.7) ; C9036.2 73.82,157.08 v2(74.07,156.83) ; C9010.2 v2(74.96,120.55) ; C9021.2 v2(72.8,143.5) ; v2(80.68,114.29) 80.55,114.16 C9005.2 ; C9035.2 v2(87.41,146.67) ; C9009.2 80.68,116.44 v2(80.8,116.32) ; v2(80.68,113.14) 80.55,113.27 C9003.2 ; CN9021.G2 v2(71.66,145.5) ; R9044.2 v2(89.06,143.88) ; Q9032.4 74.18,123.29 ; Q9032.4 73.75,122.91 ; C9006.2 66.07,112.38 v2(65.69,112.76) ; C9015.2 v2(72.55,136.64) ; C9001.2 v2(80.68,111.11) ; CN9021.G1 v2(71.47,152.7) ; v1(89.57,113.14) v2(89.57,112.38) ; C9011.2 v2(72.42,121.27) ; U9000.12 v2(76.36,111.49) ; R9012.2 v2(71.53,121.27)
  TOP w0.508: 72.85,144.22 CN9021.G2 72.85,146.78 ; CN9021.G1 72.85,153.98 ; CN9021.G1 73.72,152.7 ; CN9021.G1 72.85,151.42 ; 86.22,157.1 CN9002.G2 ; CN9002.G2 87.48,155.82 ; CN9002.G2 v2(87.48,158.79) ; 74.57,157.1 CN9002.G1 ; CN9002.G1 75.82,158.38 ; CN9002.G1 v2(77.62,157.1) ; CN9000.G1 70.37,104.6 ; CN9000.G1 69.8,105.78 ; CN9000.G1 69.8,103.42 ; 92.13,104.6 CN9000.G2 92.7,105.78
  BOTTOM w0.254: 54.42,120.07 CN9001.10
  BOTTOM w0.381: CN9001.5 36.05,135.52 v4(36.05,136.56)
  BOTTOM w0.635: v4(52.72,120.07) 54.42,120.07
  vias: v2(68.23,143.62) v2(69.8,102.9) v2(70.64,154.8) v2(71.79,160.39) v2(71.79,116.06) v2(71.79,111.92) v2(74.07,112.13) v2(75.22,141.84) v2(75.85,152.13) v2(75.81,105.91) v2(76.61,147.05) v2(76.99,114.67) v2(77.63,105.78) v2(78.65,157.72) v2(78.9,149.34) v2(80.8,145.91) v2(80.8,141.08) v2(84.87,141.08) v2(85.27,109.59) v2(85.38,148.32) v2(86.14,104.76) v2(89.57,138.92) v2(89.57,121.65) v2(89.57,106.92) v2(89.69,131.43) v2(89.95,108.7) v2(90.46,106.92) v2(90.61,144.26) v2(91.09,108.7) v2(91.85,125.33) v2(91.98,118.86) v2(92.36,109.33) v2(92.7,106.33) v4(2.26,150.86) v4(2.39,145.4) v4(2.39,139.05) v4(2.39,132.7) v4(2.39,126.35) v4(2.39,120) v4(2.39,113.65) v4(2.39,107.3) v4(7.47,154.29) v4(7.47,149.21) v4(7.47,142.86) v4(7.47,136.51) v4(7.47,130.16) v4(7.47,123.81) v4(7.47,117.46) v4(7.47,111.11) v4(9.31,105.26) v4(11.85,102.72) v4(12.55,154.29) v4(15.09,159.12) v4(15.09,151.75) v4(16.85,160.7) v4(16.85,99.4) v4(16.93,105.26) v4(18.45,155.31) v4(22.01,102.72) v4(22.26,151.88) v4(24.67,156.07) v4(27.09,105.26) v4(27.79,151.75) v4(28.61,156.2) v4(31.53,156.07) v4(31.53,148.7) v4(31.66,143.55) v4(31.68,136.26) v4(31.68,129.45) v4(31.66,121.75) v4(31.93,117) v4(32.17,102.72) v4(32.87,113.65) v4(32.87,107.3) v4(32.93,152.51) v4(34.17,158.76) v4(35.34,158.1) v4(35.41,109.84) v4(35.41,103.49) v4(36.02,134.02) v4(36.05,131.46) v4(36.05,128.89) v4(36.23,125.16) v4(36.48,154.54) v4(36.61,157.47) v4(36.68,149.21) v4(36.68,144.13) v4(37.25,105.26) v4(37.5,152.89) v4(37.95,139.05) v4(39.22,123.81) v4(39.22,120) v4(40.93,156.83) v4(41.76,142.86) v4(42.33,153.52) v4(42.33,102.72) v4(43.03,139.05) v4(43.03,117.46) v4(45.5,157.08) v4(45.57,123.81) v4(45.57,120) v4(46.64,160.51) v4(49.38,142.86) v4(49.38,120) v4(49.38,117.46) v4(50.65,139.05) v4(50.65,123.81) v4(51.92,156.83) v4(52.49,102.72) v4(53.19,160.64) v4(53.12,152.26) v4(53.37,124.27) v4(54.31,121.3) v4(54.46,118.55) v4(54.74,116.34) v4(55.73,142.86) v4(57,139.05) v4(57.57,105.26) v4(58.27,154.29) v4(59.11,116.32) v4(59.21,147.05) v4(59.54,144.13) v4(59.54,102.22) v4(60.81,160.64) v4(60.81,107.3) v4(62.08,154.29) v4(62.69,131.46) v4(62.82,136.66) v4(62.82,134.02) v4(62.97,128.94) v4(63.35,149.21) v4(63.35,139.05) v4(64.42,116.32) v4(67.16,160.64)
DGND_SYS1: length 22.4
  BOTTOM w0.254: MIC601.7 v4(248.24,47.55)
  BOTTOM w0.305: v4(192.93,47.74) 192.72,47.53 192.72,45.55 MIC600.7
  BOTTOM w0.381: v4(194.41,47.48) 194.46,47.48 194.54,47.41 MIC600.8 ; MIC600.5 196.27,45.5 196.48,45.71 v4(197.14,45.71) ; v4(245.12,43.67) 245.68,44.22 MIC601.8 ; C653.2 240.22,47.14 v4(240.7,46.67) ; v4(238.21,44.33) 238.2,44.34 CN600.8 ; 243.05,46.15 C652.2 ; CN600.3 241.2,44.44 v4(241.23,44.41) ; MIC601.5 244.68,45.27 244.48,45.07 244.25,45.07 ; C650.2 198.91,43.8 v4(199.04,43.67) ; 246.46,47.29 MIC601.6 ; R640.1 v4(199.3,42.91) ; v4(199.42,44.31) 199.11,44.31 C651.2 ; MIC600.6 195.47,44.22 195.89,43.8 v4(196.25,43.8) ; 235.94,46.91 C604.2
  BOTTOM w0.508: 242.82,43.87 CN600.G1 ; CN600.G1 243.35,44.57 ; CN600.G1 243.88,43.87 ; CN600.G1 243.35,43.18 ; 236.05,43.18 CN600.G2 ; CN600.G2 236.05,44.57 ; CN600.G2 235.52,43.87 ; CN600.G2 236.58,43.87
  vias: v4(201.05,43.67) v4(204.61,43.67) v4(207.15,44.94) v4(207.15,42.4) v4(209.69,43.67) v4(212.23,44.94) v4(212.23,42.4) v4(214.77,43.67) v4(217.31,44.94) v4(217.31,42.4) v4(219.85,43.67) v4(222.39,44.94) v4(222.39,42.4) v4(224.93,43.67) v4(225.44,47.61) v4(227.47,44.94) v4(227.47,42.4) v4(229.65,47.36) v4(230.01,43.67) v4(235.17,43.75) v4(235.24,47.36) v4(243.19,45.83) v4(244.11,43.42) v4(244.74,46.97)
DGND_VGA: length 0.8
  TOP w0.102: v4(34.02,78.88) 34.09,78.88 v1(34.58,79.36)
  vias: v4(33.53,77.86) v4(33.53,76.59)
P0V675M_VREF: length 79.7
  TOP w0.254: v2(253.78,140.96) 253.52,141.21 R4107.1 ; R4134.1 189.38,145.15 v2(190.17,144.36)
  TOP w0.381: R4104.1 206.36,144.55 v2(206.16,144.34)
  L3 w0.254: v2(190.17,144.36) 189.72,144.36 185.63,148.45 184.18,148.45 v3(182.91,149.72) ; v2(253.78,140.96) 252.51,142.23 243.49,142.23 242.86,142.86 207.4,142.86 206.16,144.1 v2(206.16,144.34)
  L6 w0.254: v2(190.17,144.36) 191.46,145.65 194.8,145.65 195.31,146.16 204.34,146.16 v2(206.16,144.34)
P0V675M_VREF_H: length 29.4
  TOP w0.381: R4503.2 226.94,102.1 C4124.1 226.89,102.14 226.52,102.14 223.84,99.46 223.84,96.67 v1(222.92,95.74) 218.6,91.43 214.91,91.43 214.57,91.08 211.77,91.08 210.6,89.9 208.76,89.9 208.38,89.52 206.03,89.52
  BOTTOM w0.381: v2(203.74,93.05) 203.43,92.75 U4555.AP49
P0V675S: length 128.4
  TOP w0.254: 121.62,141.76 v2(121.7,141.84)
  TOP w0.381: 171.48,142.35 C4212.1 170.77,143.24 ; 122.38,138.03 122.25,137.91 C4125.1 C4126.1 122.25,135.92 v2(121.95,135.62) ; 169.07,143.24 C4213.1 168.35,143.96 ; v5(170.59,149.72) 169.7,149.72 168.69,148.7 167.5,148.7 R7153.2 ; 199.3,138.16 199.55,137.91 C4103.1 C4100.1 199.8,136.68 v2(199.8,135.99) ; 122.38,140.07 C4128.1 C4127.1 121.62,141.76 ; 199.3,139.18 C4102.1 C4101.1 200.01,140.49 199.7,140.8 v2(199.7,141.21) ; 170.77,145.33 C4214.1 D4205.1 170.77,147.56
  TOP w0.635: 122.38,138.03 122.38,140.49 124.45,142.56 134.86,142.56 v1(136.81,144.51) 141.03,148.73 149.71,148.73 150.73,147.71 163.71,147.71 166.86,144.56 167.75,144.56 168.35,143.96 ; 171.48,142.35 178.85,142.35 186.09,149.59 194.85,149.59 198.28,146.16 198.28,141.08 199.3,140.07 199.3,138.16 ; 169.07,143.24 170.77,143.24 170.82,143.3 170.82,145.27 170.77,145.33 ; v5(170.59,149.72) 170.77,149.55 170.77,147.56
  BOTTOM w0.381: C7487.2 v5(170.59,149.72)
  BOTTOM w0.457: v2(121.7,141.84) 122.36,141.84 122.7,142.18 CN4125.204 ; CN4125.203 123,134.96 122.33,135.62 v2(121.95,135.62) ; v2(199.8,135.99) 199.8,135.57 200,135.37 CN4100.203 ; CN4100.204 v2(199.7,141.21)
P0V675S_DIMM0_VREF_CA: length 165.9
  TOP w0.381: v2(221.52,144.32) 221.59,144.32 222.33,143.58 C4111.1 C4110.1 223.22,141.08 v2(223.93,141.08) ; R4104.2 207.54,145.02 v2(208.22,144.34) 208.22,144.34 C4207.1 D4202.1 209.97,144.34 R4122.2 210.85,144.34 R4106.1 C4206.1 ; v2(228.13,104.88) 227.79,104.55 R4503.1
  L3 w0.381: v2(223.93,141.08) 223.93,141.46 224.62,142.15 237.85,142.15 238.41,141.59 238.41,140.83 238.92,140.32 239.81,140.32 240.32,139.81 240.32,115.68 229.52,104.88 v2(228.13,104.88)
  L6 w0.381: v3(142.23,145.31) 142.23,147.65 143.16,148.58 151.64,148.58 152.79,147.43 165.26,147.43 166.02,146.67 179.86,146.67 180.12,146.92 187.1,146.92 187.36,146.67 204.51,146.67 205.78,145.4 207.15,145.4 v2(208.22,144.34) 208.97,145.1 220.74,145.1 v2(221.52,144.32)
  BOTTOM w0.381: v3(142.23,145.31) D4203.1 C4209.1 C4137.1 C4138.1 146.1,145.72 CN4125.126 ; v2(223.93,141.08) 223.3,141.08 223.1,141.29 CN4100.126
P0V675S_DIMM0_VREF_DQ: length 18.3
  TOP w0.381: v3(263.68,135.49) 263.68,136.3 C4119.1 C4120.1 263.6,137.61 262.8,138.42 262.8,140.83 262.29,141.34 260.76,141.34 259.45,142.65 R4109.2 257.97,142.65 C4202.1 D4200.1 257.08,142.65 256.19,142.65 C4201.1 R4108.1 C4200.1 253.53,142.65 R4107.2 252.64,142.65 R4105.1
  BOTTOM w0.381: CN4100.1 263,135.19 263.3,135.49 v3(263.68,135.49)
P0V675S_DIMM1_VREF_DQ: length 23.8
  TOP w0.381: 186.26,142.74 186.26,142.52 185.71,141.97 184.03,141.97 183.42,141.36 183.42,136.51 184.39,135.54 C4145.1 C4144.1 186.69,136.78 v3(186.69,137.22) ; 186.26,142.74 C4205.1 ; 186.26,142.74 186.26,143.62 D4201.1 C4203.1 R4132.1 C4204.1 R4131.2 187.82,146.92 R4112.1 187.82,145.15 R4134.2
  BOTTOM w0.381: v3(186.69,137.22) 186,136.54 CN4125.1
P1V2_CR: length 6.3
  TOP w0.254: R800.1 286.54,72.07 287.23,72.07 287.61,71.69 C806.1 289.08,71.49 v1(289.54,71.94) 289.74,72.15 290.35,72.15 290.57,72.36 U800.10
P1V2_PHY_CR: length 21.4
  TOP w0.254: 290.52,70.76 U800.14 ; v2(281.87,65.34) 281.87,69.61 282.86,70.6 283.88,70.6 284.77,71.49 R800.2
  TOP w0.381: 290.52,70.76 289.21,69.45 288.62,69.45 C800.1 287.73,68.23 287.05,67.55 C801.1 286.76,67.26 285.53,66.03 v3(285.53,64.93)
  L5 w0.254: v3(285.53,64.93) 285.35,64.76 282.45,64.76 v2(281.87,65.34)
P1V2A: length 57.1
  TOP w0.254: C2564.1 266.52,59.3 267.11,59.3 267.37,59.56 U2550.57 ; U2550.13 275.21,54.77 v2(275.64,54.34) 275.62,54.33
  TOP w0.356: v2(267.66,62.55) 267.67,62.56 U2550.51 ; 276.51,61.28 276.51,62.72 276.84,63.06 U2550.31 ; 276.51,61.28 276.79,61.55 U2550.28 ; 276.51,61.28 v2(276.51,60.69) 276.51,58.28 v2(276.38,58.15) 276.48,58.05 U2550.21 ; U2550.8 272.71,55.91 272.53,56.09 271.45,56.09 271.21,55.84 U2550.5 271.21,54.6 ; 275.62,54.33 275.62,54.13 C2559.1
  TOP w0.381: v2(266.84,59.83) 266.55,59.83 C2564.1 ; 271.21,54.6 271.21,53.65 C2561.1 C2560.1 272.12,54.29 v2(272.07,54.34) ; v2(267.66,62.55) 267.66,62.64 267.19,63.1 C2563.1
  TOP w0.762: v5(262.36,69.38) 262.69,69.05 263.71,69.05 264.34,69.68 264.34,71.13 262.19,73.29 262.19,74.94 262.8,75.55 263.33,75.55 263.33,75.55 263.43,75.55 264.07,76.19 264.07,81.77 262.8,83.04 261.03,83.04 259.38,84.69 v1(259.37,84.69)
  L5 w0.508: v2(267.66,62.55) 267.93,62.55
  L5 w0.762: v2(266.84,59.83) 267.19,59.83 268.46,61.1 268.46,62.01 267.93,62.55
  BOTTOM w0.254: 276.43,58.2 v2(276.38,58.15)
  BOTTOM w0.381: v2(276.38,58.15) 275.79,57.56 C2562.1 ; C2557.1 277.02,59.68 ; C2558.1 276.43,58.2
  BOTTOM w0.508: 267.66,62.85 v2(267.66,62.55)
  BOTTOM w0.762: 266.13,62.38 266.13,63.01 266.39,63.27 267.44,63.27 267.66,63.05 267.66,62.85 ; 262.36,65.59 v5(262.36,69.38)
P1V05_LAN_M_PHY: length 30
  TOP w0.203: U400.46 289.59,108.95
  TOP w0.254: U400.22 v2(296.39,111.75) ; 289.59,108.95 288.7,108.95 288.41,108.66 C401.1 288.49,108.44 v2(289.08,108.44) 289.16,108.52 289.87,108.52 U400.47 ; U400.8 293.35,107.45 293.35,106.32 v2(293.33,106.31) ; v2(294.67,106.56) 294.57,106.67 U400.11 ; U400.16 296.34,109.35 v2(296.39,109.4)
  TOP w0.279: U400.37 290.58,112.55 290.75,112.38 ; U400.40 290.59,111.35 290.75,111.51 ; U400.43 290.41,110.15 v2(290.64,110.37)
  TOP w0.305: C403.1 297,111.75 296.39,111.75 v2(296.39,111.75)
  TOP w0.381: v2(290.64,110.37) 290.75,110.48 290.75,112.38 ; v2(294.67,106.56) 294.72,106.56 v1(295.18,106.11) 295.8,106.11 C409.1
  L5 w0.381: v2(289.08,108.44) 289.21,108.57 290.87,108.57 293.13,106.31 v2(293.33,106.31) 294.42,106.31 v2(294.67,106.56) 295.82,107.71 295.82,109 296.22,109.4 v2(296.39,109.4)
  L6 w0.381: v2(289.08,108.44) 289.21,108.57 289.22,108.57 290.64,110 v2(290.64,110.37)
  BOTTOM w0.381: v2(296.39,109.4) 295.81,109.98 295.81,111.17 v2(296.39,111.75)
P1V05_NIC: length 1.2
  TOP w0.254: U400.7 292.97,106.63 292.85,106.51 292.85,106.49 292.71,106.35
  vias: v1(292.13,105.65)
P1V5_VDD: length 24.8
  TOP w0.254: v2(83.7,90.56) 83.64,90.5 U3065.8
  TOP w0.356: C3085.1 90.54,86.91 U3065.36
  TOP w0.381: v2(90.26,87.78) 90.62,87.42 C3085.1
  TOP w0.508: L3068.2 90.64,88.16 v2(90.26,87.78)
  BOTTOM w0.381: 91.52,87.62 R3081.2 90.84,87.78 v2(90.26,87.78) 90.26,85.9 89.94,85.58 89.94,85.56 89.67,85.29 88.46,85.29 87.92,85.84 v1(87.92,87.87) 87.92,88.63 87.17,89.37 85.27,89.37 84.95,89.69 C3062.1 C3061.1 83.47,90.33 v2(83.7,90.56) ; C3092.1 93.46,88.18 R3077.2
  BOTTOM w0.457: C3092.1 92.91,87.62 91.52,87.62
P1V05A: length 163.2
  TOP w0.254: v2(179.53,85.53) 178.88,85.53 R4877.2 ; v2(182.1,80.66) 182.1,80.48 181.62,80 R4850.1 ; v2(182.66,85.58) 182.66,85.02 182.03,84.39 R4875.1 ; R4886.1 R4891.1 211.44,88.37 212.17,87.65 R4807.1 ; R4855.2 171.82,82.86 v4(172.09,82.58) 172.12,82.56 172.12,78.22 172.37,77.96 172.37,72.48 171.48,71.59 v2(171.48,70.67)
  TOP w0.381: R4807.1 212.38,86.6 212.98,86
  TOP w0.508: 212.98,86 214.66,86 215.96,84.69 216.95,84.69 218.6,83.04 218.6,81.62 217.13,80.15 216.21,80.15 215.55,79.49 215.55,76.69 214.41,75.55 214.41,73.65 212.26,71.5 212.26,69.39 212,69.12 v2(212,69.07)
  L3 w0.254: v2(179.53,85.53) 179.53,85.28 179.72,85.09 182.16,85.09 v2(182.66,85.58) 182.66,83.93 182.85,83.74 182.85,81.4 v2(182.1,80.66) 182.1,80.3 181.85,80.05 181.26,80.05 180.89,80.41 180.89,81.66 179.55,83 179.16,83 178.29,82.14 174.36,82.14 174.29,82.07 172.54,82.07 172.09,82.52 v4(172.09,82.58)
  L3 w0.508: v2(165.89,70.47) 165.89,71.05 165.08,71.87 160.69,71.87 159.59,70.77 v2(159.59,70.34) v2(158.76,70.34)
  L5 w0.508: v2(212,69.07) 212,68.75 211.71,68.47 205.74,68.47 204.75,69.46 204.75,69.92 204.25,70.42 198,70.42 197.9,70.32 190.99,70.32 190.66,69.98 183.9,69.98 182.25,71.64 182.02,71.87 179.54,71.87 178.81,71.87 178.47,71.53 178.05,71.53 177.44,70.92 174.92,70.92 174.67,70.67 v2(171.48,70.67) 171.3,70.67 171.3,70.67 168.3,70.67 167.94,71.03 166.45,71.03 v2(165.89,70.47)
  L5 w1.016: v2(158.76,70.34) 157.77,70.34 157.64,70.22 149.44,70.22 144.61,75.04 143.16,75.04 142.27,75.93 140.62,75.93 138.87,77.68 138.87,79.72 133.69,84.9 133.69,87.67 v2(132.81,88.55) v2(131.73,88.55)
  vias: v1(130.72,82.79)
P1V05A_MODPHY: length 20.8
  TOP w0.381: C4761.1 178.93,80.33 v2(179.3,80.7) ; v2(179.8,81.17) 179.95,81.32 C4765.2
  TOP w0.508: v2(174.53,67.8) v1(174.53,68.46)
  TOP w0.762: 175.32,73.54 174.56,73.54 173.79,74.31 173.79,78.78 174.38,79.36 174.53,79.36
  BOTTOM w0.508: L4865.1 161.96,64.88 161.54,64.47 L4854.1 161.07,66.98 160.86,67.18 Q4505.S
  BOTTOM w0.762: 168.11,65.26 164.88,65.26 164.32,65.82 162.82,65.82 162.5,65.5 L4865.1
  vias: v2(175.17,67.8)
P1V05A_SATA3PLL: length 32.6
  BOTTOM w0.203: 179.53,73.23 179.53,74.02 180.04,74.53 U4555.B11
  BOTTOM w0.254: U4555.A12 180.65,73.88 180.65,71.81 179.61,70.77 179.61,70.32 179.21,69.92 R4852.2 178.47,69.92 178.47,69.91 ; 178.98,71.74 178.98,72.67 179.53,73.23
  BOTTOM w0.508: L4865.2 164.07,64.51 167.91,64.51 168.8,63.62 C4790.1 168.8,62.99 170.16,61.63 172.68,61.63 173.52,62.48 C4792.1 174.24,63.45 v1(174.78,63.99) 174.91,64.12 174.91,64.63 176.44,66.15 176.44,66.89 178.47,68.92 178.47,71.23 178.98,71.74
P1V05A_USB3PLL: length 58.3
  BOTTOM w0.254: 185.33,72.6 184.89,73.04 184.89,73.28 184.64,73.53 184.64,73.99 184.41,74.22 U4555.B18
  BOTTOM w0.381: R4812.1 185.82,67.88 ; 185.82,67.26 186,67.09 R4811.1
  BOTTOM w0.508: 185.33,72.6 185.33,71.54 183.29,69.5 183.29,68.82 183.98,68.13 185.57,68.13 185.82,67.88 185.82,66.81 185.76,66.75 v1(185.76,63.54) 185.76,62.16 187.1,60.82 187.1,55.87 186.34,55.1 180.63,55.1 178.09,57.64 178.09,59.93 177.2,60.82 169.41,60.82 167.84,62.39 167.84,62.69 C4786.1 167.04,63.47 167.04,62.34 166.53,61.83 162.85,61.83 162.33,62.35 C4785.1 162.11,63.27 L4854.2
P1V05M: length 199.1
  TOP w0.254: C4758.2 181.9,87.52 v2(181.83,87.59) ; R2958.1 245.14,108.45 245.73,107.86 v2(245.73,107.58) ; C4729.1 173.67,108.02 175.32,106.37 v3(176.22,106.37) 176.22,104.76 175.23,103.77 175.23,98.48 175.89,97.82 175.89,96.42 176.75,95.55 176.75,94.8 177.17,94.38 177.46,94.38 177.69,94.14 177.69,93.12 178.19,92.62 178.37,92.62 178.56,92.43 178.58,92.43 178.62,92.39 178.69,92.39 179.26,91.82 179.26,90.25 180.2,89.31 180.2,89.31 180.67,88.84 C4716.1 180.67,87.63 180.02,86.98 v2(179.99,86.98)
  L5 w0.508: v2(128.04,92.5) 128.68,91.86 132.52,91.86 135.03,89.35 135.77,88.6 135.77,88.14 135.77,87.85 135.77,87.55 135.77,86.35 136.81,85.3 v2(137.67,85.3)
  L6 w0.254: v2(177.84,88.33) 179.26,86.9 179.91,86.9 v2(179.99,86.98) 179.99,86.8 178.68,85.49 178.68,80.99 177.9,80.21 176.72,80.21 176.59,80.08 176.2,80.08 175.38,79.25
  L6 w0.381: v2(128.04,92.5) 128.68,91.86 142.68,91.86 145.47,89.06 147.43,89.06 149.66,86.83 149.66,83.16 150.04,82.79 151.06,82.79 151.07,82.78 151.09,82.78 152.17,81.7 152.17,79.75 154.69,77.23 156.3,77.23 156.68,76.85 158.31,76.85 159.06,76.1 166.04,76.1 167.26,77.32 170.44,77.32 171.22,76.53 171.96,76.53 173.01,77.58 173.01,77.96 174.3,79.25 175.38,79.25
  BOTTOM w0.203: v2(179.99,86.98) 180.81,87.8 U4555.AG13 ; v2(181.83,87.59) 181.63,87.79 U4555.AG14
  BOTTOM w0.254: v2(245.73,107.58) 243.55,107.58 243.03,107.06 238.17,107.06 237.59,107.64 183.33,107.64 177.48,107.64 v3(176.22,106.37) ; U4555.AG8 178.12,88.8 177.84,88.51 v2(177.84,88.33) 177.85,88.32 U4555.AF9 U4555.AE9 ; v2(179.99,86.98) 180.75,86.22 181.52,86.22 181.83,86.54 v2(181.83,87.59)
  BOTTOM w0.381: R7150.1 126.39,92.23 126.87,92.71 126.87,92.72 127.19,93.04 127.2,93.04 127.21,93.05 127.82,93.05 128.05,92.82 128.05,92.52 v2(128.04,92.5)
P1V5S: length 297.8
  TOP w0.254: C5309.1 279.98,70.9 v2(279.56,71.32)
  TOP w0.381: v2(285.02,78.9) 283.72,78.9 283.01,79.61 276.64,79.61 v5(275.62,78.6) 275.96,78.26 275.96,78.24 276.28,77.92 276.3,77.92 276.38,77.84 277.15,77.84 277.95,77.03 v2(277.95,76.82) ; C4763.1 182.23,78.96 v2(182.33,78.86) ; v2(270.26,77.89) 269.7,77.33 265.82,77.33 265.09,76.6 265.09,75.76 263.71,74.38 v2(263.3,74.38)
  L3 w0.762: v5(275.62,78.6) 273.23,80.99 270.52,80.99 270.36,81.14 266.48,81.14 265.61,80.27 261.42,80.27 260.64,79.49 253.14,79.49 252.51,80.12 250.35,80.12 249.46,81.01 249.46,82.28 248.95,82.79 237.9,82.79 237.17,82.05 235.4,82.05 235.25,81.9 235.24,81.9 234.98,81.65 234.22,81.65 230.79,78.22 228.76,78.22 228.38,77.84 v3(226.73,77.84)
  L5 w0.381: v2(278.14,69.6) 278.15,69.6 277.96,69.78 277.96,72.02 276.97,73.01 275.52,73.01 274.2,71.69 273.72,71.69 271,68.97 269.86,68.97 269.07,68.18 v2(269.07,67.85) ; v2(285.02,78.9) 285.02,69.43 v2(285.25,69.2) ; v2(263.3,74.38) 263.51,74.38 263.86,74.03 263.86,72.96 261.11,70.21 v2(261.11,69.23)
  L6 w0.381: v2(285.25,69.2) 278.54,69.2 278.16,69.58 278.16,69.6 v2(278.14,69.6) ; v5(275.62,78.6) 273.2,78.6 272.31,77.71 270.44,77.71 v2(270.26,77.89)
  L6 w0.762: 208.95,74.92 210.08,73.78 215.54,73.78 217.01,75.25 222.62,75.25 223.58,76.21 225.86,76.21 226.73,77.07 v3(226.73,77.84) ; 177.96,75.55 177.55,75.14 177.55,74.88 177.13,74.46 177.12,74.46 176.44,73.77 173.01,73.77 171.48,72.25 169.58,72.25 169.4,72.07 166.61,72.07 165.84,72.83 158.81,72.83 158.68,72.96 154.77,72.96 153.79,73.94 153.79,76.1 148.77,81.11 148.77,81.75 143.72,86.8 143.72,88.5 142.05,90.18 137.27,90.18 136.79,90.66 126.42,90.66 122.03,95.06 121.49,95.06 119.82,96.73 119.82,98.54 118.42,99.93 111.97,99.93 105.93,105.97 104.8,105.97 v5(104.3,106.48)
  BOTTOM w0.254: U5301.17 279.5,76.12 279.37,76.25 ; v2(261.11,69.23) 260.94,69.4 C5409.1 261.57,70.6 262.16,70.6 262.88,71.32 U5401.5 ; C5414.1 263.09,75.7 263.51,76.12 U5401.17 ; 285.86,66.96 C5311.1 ; U5401.30 268.41,77.97 268.64,77.73 269.63,77.73 270.12,77.24 ; 278.57,71.21 278.67,71.32 v2(279.56,71.32) U5301.5 ; 285.02,68.29 284.66,68.64 U5301.51 ; U5401.51 268.6,68.85 269.71,68.85 C5411.1 269.73,68.52 v2(269.07,67.85) ; U5301.30 284.77,77.99 ; C5450.1 274.48,79.23 275.11,78.6 v5(275.62,78.6)
  BOTTOM w0.381: v2(278.14,69.6) 278.15,69.6 278.15,70.79 278.57,71.21 ; C5414.1 263.09,74.58 v2(263.3,74.38) ; 270.12,77.24 270.9,77.24 C5412.1 271.03,77.6 270.75,77.88 270.34,77.88 270.34,77.89 v2(270.26,77.89) ; C5311.1 286.16,67.21 286.16,68.29 v2(285.25,69.2) ; v2(277.95,76.82) C5314.1 278.16,77.46 v1(278.92,76.69) 279.37,76.25 ; 285.86,66.96 285.02,67.8 285.02,68.29 ; v2(182.33,78.86) 182.08,79.11 U4555.J15 ; 284.77,77.99 285.43,77.99 285.91,78.47 C5312.1 285.24,78.68 v2(285.02,78.9)
  BOTTOM w1.016: 98.58,133.97 104.98,127.57 104.98,109.13 104.3,108.44 v5(104.3,106.48)
P1V05S: length 176.1
  TOP w0.254: R4569.1 221.28,74.55 219.77,76.06 v2(219.77,76.19) ; v2(185.53,88.51) 185.73,88.71 C4701.1 187.22,88.71 C4751.1 ; C4760.1 180.16,78.6 v2(180.34,78.78) ; v2(187.47,80.61) 187.47,80.63 187.87,81.03 C4719.1 189.22,81.22 R4858.1 ; v2(185.6,80.88) 185.94,81.22 C4720.1 ; v2(182.34,78.16) 182.42,78.16 183.04,78.78 v2(183.2,78.78) 184.01,79.59 C4718.1 ; v2(184.44,68.82) 184.44,69.82 184.73,70.11 184.73,71.95 183.75,72.94 183.75,72.95 183.74,72.96 183.74,73.37 183.74,73.37 183.74,76.91 184.15,77.33 v2(184.15,78.1) ; v2(185.6,82.53) 185.01,81.95 C4721.1 ; C7591.1 179.95,83.3 v2(180.12,83.48) ; R7426.1 245.02,101.2 v2(245.4,101.59)
  TOP w0.381: D7621.2 188.08,72.88 L4850.1 187.19,71.2 186.21,70.22 186.21,68.82 185.71,68.31 184.94,68.31 v2(184.44,68.82)
  TOP w0.762: v5(139.86,88.12) 139.86,87.62 140.62,86.85 140.62,80 142.91,77.71 142.91,72.6 144.2,71.31 145.83,69.68 152.08,69.68 155.48,66.28 158.6,66.28 159.42,67.09 v5(159.42,67.9)
  L3 w0.381: v5(138.34,89.01) 138.11,89.23 128.27,89.23 v3(127.67,88.63)
  L5 w0.254: v2(187.94,80.27) 188.2,80.01 205.6,80.01 206.94,78.67 208.23,78.67 208.7,78.2 208.7,77.47 208.91,77.26 209.36,77.26 209.58,77.48 212.33,77.48 212.67,77.14 218.82,77.14 v2(219.77,76.19) ; v2(222.65,85.53) 222.65,88.62 229.27,95.24 235.21,95.24 240.8,100.82 241.21,100.82 242.37,101.99 244.99,101.99 v2(245.4,101.59)
  L6 w0.254: v2(190.52,69.03) 189.89,69.66 184.78,69.66 184.44,69.31 v2(184.44,68.82)
  BOTTOM w0.254: v2(177.91,87.36) 177.91,87.63 178.12,87.84 U4555.AE8 ; U4555.J17 182.88,79.11 v2(183.2,78.78) ; v2(222.65,85.53) 219.77,82.66 v2(219.77,76.19) ; U4555.H11 180.02,78.46 v2(180.34,78.78) 180.02,79.11 U4555.J11 ; v2(190.52,69.03) 190.28,69.27 R4892.2 ; U4555.AG16 182.44,88.68 182.81,89.05 v2(182.85,89.05) 182.88,89.05 183.25,88.68 U4555.AG17 ; U4555.P9 178.57,81.62 U4555.N8 178.12,81.17 177.78,80.82 v2(177.78,80.75) ; U4555.H15 181.85,78.45 182.14,78.16 v2(182.34,78.16)
  BOTTOM w0.381: U4555.T21 185.22,82.91 v2(185.6,82.53) 185.22,82.16 185.22,82.13 185.22,82.12 U4555.R21 ; R7152.1 127.41,88.38 v3(127.67,88.63) ; v2(185.53,88.51) 185.81,88.22 U4555.AF22
  BOTTOM w0.762: L4851.1 159.67,65.81 159.42,66.06 v5(159.42,67.9)
  vias: v5(139.35,89.01) v5(140.37,89.01) v5(140.88,88.12)
P1V05S_APLLOPI: length 7.3
  TOP w0.254: R4858.2 189.44,82.3 C4787.1 189.27,83.61 C4789.1 187.88,84.45 v1(187.57,84.77) 187.37,84.97 v2(185.6,84.97)
  BOTTOM w0.381: U4555.AA21 185.22,85.34 v2(185.6,84.97) 185.22,84.6 185.22,84.56 185.22,84.56 U4555.W21
P1V05S_AXCK_DCB: length 9.4
  TOP w0.254: v2(184.15,78.78) 184.67,78.26 184.67,77.42 184.74,77.35 184.74,76.26 185.37,75.63 C4723.1
  TOP w0.381: C4723.1 185.96,74.32 C4754.1 186,73.27 v1(185.88,73.16) 186,73.05 L4850.2
  BOTTOM w0.254: U4555.J18 184.08,78.78 v2(184.15,78.78) 184.23,78.86 U4555.K19
P1V05S_SSCF100: length 44.8
  TOP w0.254: v2(175.8,67.8) 175.8,66.74 176.56,65.97 v3(176.56,59.8)
  L6 w0.254: v2(175.8,67.8) 177.48,67.8 178.68,69 183.73,69 183.93,69.2 v2(183.93,69.2)
  BOTTOM w0.254: v2(183.93,69.2) 185.5,70.77 C4724.1 186.34,71.28 186.34,72.4 185.06,73.68 185.06,73.88 U4555.A20
  BOTTOM w0.508: v3(176.56,59.8) 176.18,59.42 167.8,59.42 166.4,60.82 160.59,60.82 158.4,63 C4755.1 L4851.2
P1V05S_VCCP: length 139.1
  TOP w0.254: 223.77,76.53 R4590.2 ; R4823.1 239.76,89.85 v2(240.14,89.47) ; v2(221.57,80.05) 222.28,79.34 223.32,79.34 223.77,78.88 R4920.2 ; v2(211.16,81.45) 211.17,81.45 211.7,80.93 R4821.1 R4524.1 ; R4923.1 239.84,86.53 239,86.53 v2(238.99,86.54) 238.98,86.53 CN4920.43 ; v2(233.19,86.42) 233.09,86.52 233.09,86.53 CN4920.44 ; U300.79 v2(270.48,109.12)
  TOP w0.381: R4507.2 223.78,76.46 223.77,76.46 223.77,76.53 223.87,76.63 223.87,77.73 R4508.2 R4920.2 224.07,78.74 224.65,79.32 R4517.2 ; R4507.2 224.55,75.47 C4555.1 ; R4507.2 R4569.2 R4732.2 224.55,73.66 225.08,73.14 225.08,72.38 224.51,71.81 R4568.2
  TOP w0.635: C4590.1 v4(187.75,85.71)
  L3 w0.254: v2(270.48,109.12) 270.48,108.12 267.98,105.62 267.98,102.77 265.84,100.63 265.84,99.25 263.68,97.09 263.68,92.82 260.51,89.65 256.56,89.65 255.67,90.54 248.7,90.54 247.99,89.83 240.5,89.83 v2(240.14,89.47)
  L5 w0.254: v2(221.57,80.05) 221.57,81.75 226.4,86.57 233.04,86.57 v2(233.19,86.42) 233.38,86.6 238.87,86.6 238.9,86.63 v2(238.99,86.54)
  L6 w0.254: v2(240.14,89.47) 240.14,87.68 v2(238.99,86.54) ; v2(221.57,80.05) 221.32,80.3 215.61,80.3 215.1,80.81 212.5,80.81 211.86,81.45 v2(211.16,81.45) 211.16,81.63 210.89,81.9 209.25,81.9 208.67,81.32 206.92,81.32 205.87,80.27 191.02,80.27 188.55,82.74 188.55,84.9 v4(187.75,85.71)
  BOTTOM w0.254: R7012.1 232.52,86.22 233,86.22 v2(233.19,86.42)
  BOTTOM w0.381: U4555.AC22 U4555.AE22 186.55,87.81 U4555.AE23 186.65,87.78 186.88,87.56 v2(187.16,87.56) 187.16,87.49 187.75,86.9 v4(187.75,85.71)
P1V8S_SM: length 1.4
  TOP w0.381: C9009.1 78.52,116.44 ; 78.52,115.56 C9007.1
  vias: v1(79.41,117.33)
P1V35: length 194.4
  TOP w0.254: v2(156.8,113.5) 160.66,113.5 ; C4115.1 229.87,143.78 v2(229.27,144.38) ; v2(234.5,144.38) 234.47,144.36 v1(234.47,143.62) ; v2(227.3,144.31) 227.45,144.16 C4118.1
  TOP w0.381: C4112.1 234.73,134.35 ; C4114.1 231,144.36 v2(231.01,144.36) ; C4135.1 161.58,134.1 ; C7605.1 144.94,133.46 ; C7636.1 184.48,145.95 v2(184.69,146.16) 184.69,146.54 185.07,146.92 C4204.2 R4132.2 C4203.2 ; C4201.2 R4108.2 C4200.2 254.41,141.21 ; C7633.1 232.58,131.09 v2(233.04,131.56) ; C4146.1 229.65,131.81 ; 240.52,140.24 C7598.1 240.52,141.43 v2(240.44,141.51) ; 224.76,131.09 C7632.1 ; 167.11,143.24 C4213.2 ; C4206.2 212.63,145.78 ; C7639.1 162.47,134.22 ; 148.41,145.84 C7638.1 ; C4139.1 152.94,133.46 ; 199.5,125.9 C7604.1 ; v2(202.47,145.53) 202.98,145.02 C7635.1 ; C4210.2 202.51,130.71 ; C4212.2 166.66,142.35 ; C7640.1 149.13,134.48 ; Q4100.3 v2(173.39,144.38) 173.39,143.83 C7637.1 ; C4142.1 162.21,143.62 ; R4106.2 211.74,145.78 ; C7634.1 213.52,145.78 ; 237.55,143.22 C4116.1 ; C4108.1 231.68,131.56 ; C4136.1 152.31,143.24 ; C4147.1 148.11,134.48
  TOP w0.508: v2(223.66,144.29) 223.33,144.62 C4117.1 ; v2(214.54,146.04) D7616.2 ; 254.41,141.21 254.79,140.83 v2(254.79,139.81) ; v2(193.31,88.78) 193.33,88.77 C4525.1 D7615.2 C4526.1 195.87,88.9 v2(195.91,88.94)
  L3 w0.508: v2(240.44,141.51) 240.44,141.21 241.33,140.32 241.33,135.75 241.97,135.11 253.02,135.11 253.78,135.88 253.78,138.8 v2(254.79,139.81)
  BOTTOM w0.178: U4555.AY40 197.54,96.52 197.54,97.34 v2(197.11,97.77) ; U4555.AN33 193.26,92.1 193.52,92.37 v2(193.7,92.37) ; U4555.AY35 194.38,96.52 194.46,96.59 194.46,97.52 194.21,97.77 v2(193.96,97.77)
  BOTTOM w0.254: v2(202.87,97.95) 203.03,97.95 203.43,97.55 203.43,97.07 203.84,96.67 203.84,96.52 U4555.AY50 ; U4555.AR48 202.54,93.56 202.55,93.56 202.69,93.71 v2(202.79,93.71) ; U4555.AP43 199.43,92.75 199.6,92.75 v2(199.93,93.08) ; v2(199.92,97.35) 200.01,97.35 200.69,96.68 200.69,96.52 U4555.AY44 ; v2(156.8,113.5) 156.8,113.5 153.69,113.5 149.59,109.4 149.59,100.63 149.59,97.31 150.08,96.83 150.08,93.52 149.38,92.82 R4553.1 ; v2(173.39,144.38) 173.39,145.4
  BOTTOM w0.381: CN4100.111 227.6,131.81 v2(226.87,131.08) ; v2(195.91,88.94) 195.91,88.94 U4555.AJ37 ; CN4100.112 v2(227.3,144.31) ; CN4125.100 153.9,144.48 v2(153.91,144.49) ; CN4100.87 234.8,131.91 v2(234.49,131.6) ; v2(162.13,132.76) 161.6,132.76 161.4,132.95 CN4125.75 ; CN4125.123 147,132.84 147.19,132.65 v2(148.45,132.65) 148.8,133 CN4125.117 ; v2(157.51,144.45) 157.5,144.44 CN4125.88 ; CN4125.93 156,132.95 156.19,132.76 v2(156.6,132.76) ; CN4100.117 225.8,132.4 225.42,132.02 v2(224.66,132.02) 224.13,132.02 224,132.15 CN4100.123 ; v2(152.66,132.7) 152.4,132.96 CN4125.105 ; v2(154,132.69) 154.2,132.89 CN4125.99 ; CN4125.82 v2(159.3,144.5) ; v2(160.3,132.74) 159.8,132.74 159.6,132.94 CN4125.81 ; v2(189.64,88.76) 189.17,88.76 U4555.AH26 ; CN4100.118 225.5,144.24 225.43,144.31 ; U4555.AJ31 v2(192.01,88.94) ; CN4100.81 236.6,132.02 v2(236.9,131.72) 237.61,131.72 238.4,132.52 CN4100.75 ; v2(231.01,144.36) 230.9,144.25 CN4100.100 ; v2(233.04,131.56) 233,131.6 CN4100.93 ; CN4100.106 229.1,144.22 v2(229.27,144.38) ; CN4125.118 148.5,144.51 v2(148.75,144.77) ; CN4100.94 v2(232.7,144.38) ; CN4125.112 150.3,144.28 v2(150.44,144.42) ; CN4125.111 150.6,132.72 v2(150.63,132.69) ; 218.3,145.32 C7597.1 ; CN4100.82 v2(236.3,144.38) ; CN4100.76 238.1,143.91 237.62,144.38 v2(237.27,144.38) ; U4555.AJ33 v2(193.31,88.78) ; CN4100.88 v2(234.5,144.38) ; CN4125.106 v2(152.1,144.44) ; CN4100.105 229.4,132.61 229.71,132.29 v2(230.45,132.29) 230.99,132.29 231.2,132.51 CN4100.99 ; C7606.1 163.23,148.65 ; CN4125.76 161.1,144.45 v2(161.07,144.49) ; CN4100.124 223.7,144.26 v2(223.66,144.29) ; CN4125.94 v2(155.7,144.51) ; CN4125.124 146.7,141.25 v2(146.55,141.1) ; v2(157.18,132.11) 157.8,132.73 CN4125.87
  BOTTOM w0.457: v2(192.16,104.67) 193.89,104.67 C4516.1
  BOTTOM w0.508: C4516.1 C4515.1 198.27,104.34 199.47,103.14 C4990.1 C4528.1 201.33,102.32 v2(201.63,102.01) 201.63,102.05 202.01,102.43 v2(202.11,102.53) 202.52,102.53 202.85,102.86 C4527.1
  vias: v5(158.15,146.54) v5(158.78,145.53) v5(159.42,146.54) v5(160.05,145.53) v5(160.69,146.54) v5(161.32,145.53) v5(161.96,146.54) v5(162.59,145.53) v5(163.23,146.54) v5(163.99,145.53)
P3V3_CR: length 56.8
  TOP w0.254: R808.1 295.86,78.77 295.31,78.22 295.1,78.22 294.8,77.92 294.8,74.79 295,74.58 v2(295.18,74.58) ; 290.18,71.69 290.4,71.69 290.67,71.96 U800.11
  TOP w0.381: v2(282.89,64.25) 283.37,64.73 283.37,68.69 283.97,69.29 C804.1 284.62,69.78 287.64,69.78 288.11,70.26 C805.1 289.03,70.55 290.18,71.69
  L5 w0.254: v2(282.89,64.25) 282.1,64.25 281.39,64.96 281.39,66.08 282.33,67.02 285.2,67.02 291.95,73.77 294.19,73.77 295,74.58 v2(295.18,74.58)
  L5 w0.508: v2(282.89,64.25) 283.88,64.25 284.89,63.23 286.42,63.23 v2(288.83,60.82)
  BOTTOM w0.254: v2(295.18,74.58) 295.18,75.04 v1(294.16,76.06) 290.69,76.06 R809.1 290.26,76.65 291.12,77.5 R810.1 291.13,77.61 Q802.1
  BOTTOM w0.508: Q801.3 288.26,61.39 v2(288.83,60.82)
P3V3_RTC: length 201.2
  TOP w0.254: v2(277.78,115.17) 277.78,113.78 277.48,113.48 C311.1 C312.1 276.26,112.38 275.88,112 275.52,112 274.88,111.36 U300.68
  L5 w0.254: v2(266.22,122.03) 268.54,119.72 268.54,119.7 269.55,118.68 273.44,118.68 275.62,116.49 275.62,114.94 276.15,114.41 277.53,114.41 277.78,114.67 v2(277.78,115.17)
  L6 w0.254: v2(148.24,104.51) 149.26,105.52 v2(155.48,105.52) 156.37,105.52 158.4,103.49 164.62,103.49 166.91,101.2 168.56,101.2 169.58,100.19 v3(171.33,100.19) 171.33,99.88 175.23,95.99 177.48,95.99 177.76,95.71 177.76,93.01 178.09,92.68 178.32,92.68 178.56,92.43 178.6,92.43 179.22,91.82 179.22,89.48 178.66,88.92 v2(178.66,88.9)
  BOTTOM w0.254: U4555.AG10 179.19,88.68 178.96,88.9 178.65,88.9 178.65,88.9 v2(178.66,88.9) ; R4833.1 144.05,100.57 143.48,101.14 D4750.3 ; R4833.1 R4831.1 R4845.1 ; R4833.1 144.51,100.65 145.87,102.01 R4834.1 C4766.1 C4709.1 C4710.1 146.67,103.95 147.23,104.51 v2(148.24,104.51) ; v2(155.48,105.52) 155.48,107.33 157.49,109.33 158.54,109.33 168.14,118.93 208.73,118.93 209.76,119.97 241.73,119.97 242.52,120.76 258.67,120.76 259.32,120.76 260.19,119.9 266.41,119.9 266.86,120.35 266.86,121.4 v2(266.22,122.03) ; v3(171.33,100.19) 171.58,100.44 R4742.1 R4842.1
P3V3_TPM: length 13.3
  TOP w0.381: v3(124.62,144.39) 125.62,145.4 126.4,145.4 127.54,146.54 C3503.1 127.62,146.92 128.35,146.92 R3511.1 128.51,146.92 129.24,146.92 R3516.1 R3510.1
  BOTTOM w0.254: U3500.5 125.1,146.19 125.41,146.5 R3503.1
  BOTTOM w0.305: U3500.5 125.1,144.83 124.82,144.55 124.77,144.55 v3(124.62,144.39)
P3V3A: length 534.9
  TOP w0.254: C4753.1 158.83,80.71 158.53,81.01 158.38,81.01 157.96,81.42 R4916.1 157.92,81.51 v2(157.44,81.04) ; R4918.1 154.67,94.35 v2(155.01,94.01) ; R4116.1 131.48,147.86 130.92,147.31 130.37,147.86 R3510.2 ; R4725.1 157.9,84.12 v4(157.36,84.12) ; R2954.1 v2(253.02,111.87) ; v2(308.77,109.46) 308.77,108.95 309.15,108.57 310.67,108.57 311.18,109.08 311.18,111.49 310.93,111.75 310.93,112.63 311.56,113.27 312.41,113.27 R1306.1 312.79,113.15 313.09,113.45 313.09,114.79 312.83,115.05 v2(312.33,115.05) ; C4746.2 v2(181.01,84.57) ; v2(275.95,68.01) 275.95,67.88 275.41,67.34 R2559.2 ; R2562.2 266.73,70.01 R2560.1 ; R2562.2 268.51,70.01 R2561.1 ; R2562.2 267.62,70.34 268.13,70.85 R2563.2 268.13,71.19 267.79,71.19 267.49,71.49 267.49,72.38 267.79,72.67 269.4,72.67 R2564.1 270.03,72.25 270.92,73.14 272.32,73.14 273.51,71.94 273.51,70.67 273.67,70.52 v2(273.67,70.36) 273.31,70.01 R2556.2 ; v2(221.14,89.39) 220.89,89.14 220.89,83.68 222.16,82.41 223.93,82.41 224.57,81.77 226.47,81.77 v2(226.98,82.28) ; v2(259.54,62.67) 259.54,63.03 260.36,63.85 261.55,63.85 261.82,63.57 261.82,63.31 R2568.1 262.46,63.31 263.26,62.51 R2569.1 262.88,62.09 260.79,62.09 260.59,61.88 260.59,60.64 261,60.23 R4839.2 ; v2(146.77,85.71) 147.4,85.08 147.4,83.47 145.96,82.03 145.96,81.44 146.26,81.14 v2(146.46,81.14) 146.46,71.71 v2(146.08,71.33) ; v2(163.23,77.02) 163.1,76.9 163.1,73.39 ; R4914.1 157.71,87.87 v4(157.36,88.22) 157.36,88.42 157.71,88.77 R4915.1 ; R4931.1 242.52,87.66 v2(242.22,87.36) ; v2(165.03,70.39) 164.95,70.39 v1(163.74,71.61) 163.1,72.25 163.1,73.39 ; R2201.2 163.1,73.39 ; v2(125.84,80.85) 125.84,78.04 129.8,74.08 CN4941.1 ; R1315.2 313.64,124.19 R1307.1 313.64,123.98 313.21,123.56 311.82,123.56 v2(311.56,123.3) ; v2(280.07,123.05) 280.11,123 C7587.1 ; v2(149.08,86.23) 149.08,90.21 v2(149.04,90.25) 149.26,90.48 149.26,94.19 149.61,94.55 v2(149.59,94.55) ; R4917.1 157.97,93.96 157.22,93.2 v4(157.22,92.02) 156.71,92.52 156.71,95.89 156.71,95.89 v4(156.71,96.35) 156.71,98.94 153.45,102.2 153.45,103.06 151.12,105.39 R4861.1
  TOP w0.356: CN200.26 112.05,89.32 111.97,89.24 111.55,89.24 CN200.25
  TOP w0.381: v5(107.73,86.35) 110.62,89.24 111.55,89.24 ; v4(187.81,87.69) 187.93,87.56 ; C7586.1 v5(229.28,96) ; 130.92,147.31 v2(130.92,146.16)
  TOP w0.508: v2(281.26,59.52) 281.26,59.98 281.97,60.69 281.97,61.07 ; 281.97,61.07 282.48,60.56 282.78,60.56 285.4,57.95 v2(285.4,57.9) ; 281.97,61.07 L2550.1
  TOP w0.635: 187.93,87.56 188.14,87.36 C4700.1
  L3 w0.254: v2(157.44,81.04) 160.26,78.22 162.03,78.22 v2(163.23,77.02) ; v2(161.97,95.67) 161.97,95.78 160.23,97.52 159.04,97.52 157.87,96.35 v4(156.71,96.35) ; v4(114.35,106.28) 114.33,106.28 114.97,106.92 114.97,140.7 120.43,146.16 v2(130.92,146.16) ; v2(185.6,87.4) 186.87,86.13 187.25,86.13 187.81,86.69 v4(187.81,87.69)
  L5 w0.254: v2(242.22,87.36) 244,89.14 244,92.14 240.57,95.57 v2(240.57,96.86) ; v4(161.98,93.15) 162.37,93.54 162.37,95.27 v2(161.97,95.67) ; v2(281.26,59.52) 281.26,59.57 280.83,60.01 278.72,60.01 278.26,60.46 278.26,62.11 276.69,63.69 274.91,63.69 274.33,64.27 274.33,66.6 274.95,67.22 275.45,67.22 275.95,67.72 v2(275.95,68.01) ; v2(181.01,84.57) 181.26,84.83 181.26,85.96 180.5,86.73 180.5,88.17 179.61,89.06 v2(179.61,89.06) ; v2(149.59,94.55) 149.76,94.38 154.63,94.38 v2(155.01,94.01) 155.01,94.26 156.71,95.96 v4(156.71,96.35) ; v2(311.56,123.3) 311.44,123.18 311.44,117.85 311.87,117.41 311.87,115.42 312.25,115.05 v2(312.33,115.05) ; v2(149.08,86.23) 148.55,85.71 v2(146.77,85.71)
  L6 w0.254: v2(234.82,82.51) 234.33,82.03 233.03,82.03 230.64,84.41 228.29,84.41 226.98,83.1 v2(226.98,82.28) ; v4(187.81,87.69) 187.81,88.44 187.23,89.01 185.2,89.01 184.33,88.15 178.7,88.15 178.21,88.63 178.2,88.63 178.03,88.8 177.64,88.8 177.6,88.76 175.67,88.76 175.42,88.51 174.06,88.51 173.26,89.3 170.64,89.3 170.57,89.38 169.59,89.38 169.04,89.93 169.04,90.13 168.51,90.66 163.76,90.66 162.74,91.68 v4(161.7,91.68)
  L6 w0.508: v5(229.28,96) 225.85,92.57 224.31,92.57 v2(221.14,89.39) 219.78,88.03 212.09,88.03 211.87,88.25 210.7,88.25 209.02,86.57 206.95,86.57 206.03,87.5 188,87.5 v4(187.81,87.69)
  BOTTOM w0.254: R4797.1 148.45,89.7 149,90.25 v2(149.04,90.25) ; 156.5,88.22 156.5,91.29 v4(157.22,92.02) 157.62,92.42 R4737.2 158.02,92.42 R4741.1 ; 156.5,88.22 v4(157.36,88.22) 157.94,88.8 R4908.1 R4733.1 ; 156.5,88.22 156.09,87.82 156.09,87.17 155.71,86.78 155.68,86.78 ; R4856.2 143.62,84.7 143.62,85.31 ; v2(293.78,98.79) 294.42,98.16 295,98.16 295.76,98.92 297.09,98.92 298.08,99.91 298.08,101.55 298.36,101.82 300.68,101.82 301.02,102.17 301.02,104.51 301.78,105.27 305.76,105.27 308.77,108.28 v2(308.77,109.46) ; v2(179.61,89.06) 179.7,89.06 180,89.36 U4555.AH11 ; 165.72,96.76 R4840.2 ; 165.72,96.76 165.72,97.39 165.72,97.39 R4778.2 165.72,97.9 165.72,97.9 R4746.1 ; 165.72,96.76 165.72,96.25 ; R4827.1 143.62,85.31 ; 143.62,85.31 143.63,85.3 144.86,85.3 145.09,85.08 Q4753.5 146.26,85.08 146.77,85.58 ; v2(157.44,81.04) 157.56,81.15 157.56,82.04 157.56,82.04 157.56,82.5 157.56,82.51 157.56,83.92 v4(157.36,84.12) 157.29,84.06 156.01,84.06 155.93,84.14 155.33,84.14 ; R369.2 146.08,80.42 R331.1 146.08,80.76 v2(146.46,81.14) ; R4904.1 165.13,71.31 165.13,70.6 165.08,70.54 165.08,70.44 v2(165.03,70.39) 164.37,69.73 R4900.1 ; 155.68,86.78 154.45,86.78 R4884.1 ; 155.68,86.78 155.68,85.63 155.3,85.25 155.3,84.16 155.33,84.14 ; v4(161.98,93.15) 162,93.15 162.22,93.37 162.58,93.37 ; 162.58,93.37 R4960.1 ; 162.58,93.37 162.58,92.45 R4734.1 R4911.1 162.01,91.37 v4(161.7,91.68) ; C7588.1 245.58,56.87 v2(245.58,57.52) ; 146.77,85.58 v2(146.77,85.71) ; 146.77,85.58 146.77,85.55 147.25,85.08 Q4753.2 148.07,85.08 R4830.1 148.45,85.61 v2(149.08,86.23) ; R4720.1 R4961.1 ; R4961.1 165.72,96.25 ; R4961.1 162.02,95.62 v2(161.97,95.67) ; v2(259.54,62.67) 259.62,62.67 260.13,63.18 260.13,65.14 259.82,65.45 259.82,66.73 260.3,67.21 R2581.1 260.17,67.42 258.63,67.42 R2590.1 257.84,67.65 256.67,67.65 256.15,67.13 256.15,58.91 256.45,58.61 C2590.1 258.22,57.22 258.22,56.37 257.72,55.87 257.72,52.56 258.27,52.01 R2580.1 258.6,51.8 258.99,51.42 260.26,51.42 260.51,51.67 R2575.1 R2570.1 ; R2565.1 279.31,61.96 280.83,60.44 R2566.1 281.29,59.55 v2(281.26,59.52) ; R6666.1 226.05,80.54 226.43,80.92 226.56,80.92 226.9,81.27 R6663.1 226.9,82.2 v2(226.98,82.28) ; 107.09,87.11 107.09,92.9 111.79,97.6 111.79,100.7 113.7,102.6 113.95,102.6 114.46,103.11 114.46,106.16 114.33,106.28 v4(114.35,106.28) ; R6645.2 234.71,82.41 v2(234.82,82.51) ; U4555.AE20 184.31,87.01 183.85,87.01 183.36,86.51 183.36,85.14 182.79,84.57 181.01,84.57 v2(181.01,84.57) 181.01,85.33 179.92,86.41 U4555.AC9 U4555.AA9 178.57,85.38 178.17,84.99 U4555.Y8 ; 165.72,96.25 165.83,96.14 167.44,96.14 167.93,96.63 R4714.1 R4857.1 ; U2402.5 277.03,62.65 276.83,62.85 275.16,62.85 274.72,62.4 U2403.5 ; v2(273.67,70.36) 275.44,70.36 276.61,69.18 276.61,68.36 276.26,68.01 v2(275.95,68.01) ; 155.33,84.14 154.46,84.14 R4792.1 ; v4(156.71,96.35) 156.71,95.52 157.01,95.21 R4736.1
  BOTTOM w0.381: C321.1 144.99,65.76 CN365.8 ; C321.1 C366.1 v2(144.18,67.04) ; C321.1 145.27,65.69 146.13,64.84 R368.2 ; v2(185.6,87.4) 185.6,87.43 U4555.AE21 185.12,87.81 U4555.AE20 ; 285.4,57.39 286.06,57.39 286.54,57.87 286.54,58.28 287.31,59.04 Q801.2 ; C7596.1 143.16,66.66 v2(143.54,67.04) ; v2(279.99,59.52) 279.99,59.34 279.56,58.91 279.05,58.91 278.57,59.4 278.57,60.64 277.48,61.73 277.27,61.73 277.03,61.98 U2402.5 ; R7353.1 106.2,87.23 ; R2203.1 284.43,56.42
  BOTTOM w0.508: v2(285.4,57.9) 285.4,57.39 284.43,56.42
  vias: v5(105.4,86.26) v5(105.4,85.37) v5(106.52,86.26) v5(106.54,85.37)
P3V3A_Q_WLAN: length 31.6
  TOP w0.254: Q1301.1 312.26,128.17 R1304.1 308.09,128.17 308.01,128.26 ; v5(305.47,123.81) 305.59,123.81 306.56,122.84 R1300.1
  TOP w0.381: v5(309.96,112.66) 308.83,111.53 C1303.1 308.09,111.57 C1304.1 ; 306.53,130.98 C1301.1 ; 305.85,133.72 C1305.1
  L5 w0.762: v5(305.47,123.81) 305.59,123.81 306.69,122.72 306.69,113.45 308.26,111.87 309.42,111.87 309.96,112.42 v5(309.96,112.66)
  BOTTOM w0.254: 309.91,112.25 309.96,112.3 v5(309.96,112.66)
  BOTTOM w0.356: CN1300.4 309.06,111.4 309.91,112.25 ; CN1300.2 309.32,110.9 309.66,111.24
  vias: v1(307.5,132.95) v5(307.63,132.07)
P3V3A_SM: length 57.6
  TOP w0.356: 83.85,108.82 84,108.68 CN9000.26 ; CN9000.25 83.5,108.47
  TOP w0.381: 83.5,108.47 83.85,108.82 v1(83.85,111.11) 83.85,149.21 77.76,155.31 74.33,155.31 72.93,156.7 R9045.1
P3V3AL_KBC: length 96.3
  TOP w0.254: U300.106 260.33,105.33 259.73,105.92 258.94,105.92 ; v2(268.13,109.33) 268.26,109.33 268.48,109.56 U300.84 268.48,111.64 267.37,112.75 C308.1 ; U300.14 268.88,93.33 268.61,93.06 268.61,92.67 C314.1 268.13,92.44 v4(268.13,93.58) ; U300.37 278.22,98.13 278.24,98.11 278.72,98.11 279.18,97.65 279.18,96 280.58,94.6 280.91,94.6 C303.1 281.29,94.17 281.21,94.09 280.32,94.09 v2(279.69,94.73) ; 258.94,105.92 v2(259.66,105.21) ; 258.94,105.92 C310.1 ; v2(259.75,100.06) 259.49,100.06 C315.1 259.96,99.51 260.26,99.81 260.77,99.81 261.09,100.13 U300.119 ; v2(279.81,104.25) 280.05,104.01 C131.1 280.4,104.48 279.81,105.07 279.81,105.52 279.18,106.16 v1(279.18,106.54) 279.17,106.53 U300.58
  L3 w0.254: v2(279.81,104.25) 279.9,104.17 279.9,94.94 v2(279.69,94.73)
  L5 w0.254: v2(252.76,94.47) 253.24,93.99 255.48,93.99 259.75,98.26 v2(259.75,100.06) 260.64,99.17 260.64,98.03 v2(262.8,95.87) ; v2(279.69,94.73) 278.8,95.62 275.37,95.62 272.83,98.16 270.29,98.16 268.64,96.51 268.64,94.09 v4(268.13,93.58)
  L6 w0.254: v2(259.66,105.21) 259.66,105.89 263.11,109.33 v2(268.13,109.33) ; v2(262.8,95.87) 265.97,95.87 268.13,93.71 v4(268.13,93.58)
  BOTTOM w0.254: v2(259.66,105.21) 259.35,105.21 258.94,104.79 258.94,100.87 v2(259.75,100.06)
P3V3AL_PB: length 23.6
  TOP w0.381: CN9100.6 278.75,35.85 v2(277.4,35.85)
  L6 w0.381: v4(263.81,31.03) 263.81,31.28 267.62,35.09 275.55,35.09 276.31,35.85 277.39,35.85 v2(277.4,35.85)
  BOTTOM w0.381: R9100.2 v4(263.81,31.03) ; U9100.1 280.72,33.5 C9113.1 279.94,33.31 v2(277.4,35.85)
P3V3AL_RTC_BAT: length 246.6
  L3 w0.254: v3(110.5,137.81) 111.67,138.97 111.67,142.45 119.84,150.63 165.66,150.63 165.76,150.73 178.24,150.73 181.16,153.66 191.29,153.66 197.64,147.31 214.51,147.31 v2(216.14,148.93)
  L5 w0.254: v2(142.53,101.2) 142.4,101.33 142.4,104.51 140.46,106.44 126.91,106.44 116.29,117.06 116.29,124.45 115.25,125.49 115.25,128.01 115.11,128.15 115.11,128.15 111.69,131.58 111.69,136.61 v3(110.5,137.81)
  BOTTOM w0.254: v4(267.12,152.88) 265.74,151.5 254.29,151.5 252.64,153.15 252.64,161.28 251.24,162.67 223.3,162.67 220.12,159.5 220.12,155.99 216.14,152 v2(216.14,148.93) ; R4832.2 v2(142.53,101.2)
P3V3AL_SM: length 72.5
  TOP w0.254: R9032.2 68.82,119.7 69.67,120.55 R9031.2
  TOP w0.356: CN9000.22 82,108.62
  TOP w0.381: R9031.2 v2(69.76,121.27) ; R9047.1 71.15,156.7 73.82,154.04 77.25,154.04 82.2,149.08 v2(82.2,119.56) v1(82.2,115.43) 82.2,112.89 82.46,112.63 82.46,109.71 82,109.26 82,108.62
  BOTTOM w0.381: v2(69.76,121.27) 69.76,120.51 70.71,119.56 v2(82.2,119.56)
P3V3D_P1V8D: length 2.3
  TOP w0.254: C802.1 291.14,67.85 v1(291.65,68.36) 292.15,68.86 U800.18
P3V3DS: length 539.4
  TOP w0.254: R7005.1 306.38,121.96 304.76,121.96 304.07,122.65 304.07,124.57 305.68,126.19 ; v2(271.66,90.54) 271.69,90.54 272.23,91.08 ; CN4941.7 131.6,77.08 132.36,76.32 132.36,73.5 132.36,73.5 132.36,73.41 131.35,72.4 v2(130.64,72.4) ; C313.2 280.7,100.95 v2(280.58,101.08) ; v2(270.54,112.38) 270.16,112.76 R325.2 ; v2(60.99,88.63) 60.99,87.37 Q6903.1 60.4,84.78 R6914.2 ; R373.2 263.3,90.71 R341.2 ; R343.1 135.97,71.06 135.13,71.89 135.13,73.29 134.54,73.88 v2(134.3,73.88) ; v2(107.22,133.34) 106.85,132.96 CN290.1 107.23,131.38 108.03,131.38 110.14,129.27 TP290.1 ; R6074.2 R312.2 R313.2 ; R6074.2 280.19,115.68 v2(280.32,115.81) ; R6074.2 R314.2 ; v2(158.66,60.95) R6058.1 ; v2(257.41,102.4) 257.03,102.4 256.4,103.03 R307.2 256.4,103.19 257.25,104.04 R327.2 ; v2(257.41,102.4) 257.63,102.18 R324.2 R322.2 ; v2(257.41,102.4) 257.48,102.4 258.09,103 R318.2 ; v2(264.45,65.55) 264.45,68.92 265.21,69.68 265.21,71.13 262.8,73.54 262.8,74.66 263.07,74.94 263.68,74.94 264.67,75.93 264.67,76.97 266.2,78.5 266.2,81.19 263.71,83.68 262.41,83.68 262.06,84.03 262.06,84.72 262.36,85.02 263.13,85.02 263.52,85.42 263.52,87.14 263.18,87.49 262.8,87.49 262.41,87.87 U302.5 262.41,89.48 R303.2 262.62,89.6 263.47,90.45 R341.2 ; v2(284.89,116.57) 285.27,116.95 R103.1 R135.1 ; R327.2 257.25,104.19 256.78,104.65 256.42,104.65 255.81,105.27 255.81,106.03 ; R327.2 R306.2 ; U1000.8 242.99,98.67 243.32,99 R1001.1 243.19,99.3 v2(242.73,99.3) ; R101.1 286.29,120.68 285.19,121.78 284.64,121.78 283.75,120.89 282.99,120.89 282.73,121.14 282.73,122.92 v2(282.99,123.18) ; v2(234.98,94.6) 233.97,95.62 232.88,95.62 230.41,98.09 230.41,103.44 R1007.1 ; v2(301.17,130.23) 301.64,130.23 R7001.1 302.27,130.75 303.12,131.6 R1302.1 ; v2(300.51,137.7) 300.51,137.75 300.31,137.95 R6935.2 ; v4(302.62,144.26) 302.39,144.49 302.39,146.49 302.7,146.8 Q6009.5 ; 255.81,106.03 254.79,106.03 253.4,104.63 253.4,102.05 R332.2 R4838.2 ; 255.81,106.03 255.81,107.43 257.08,108.7 R326.2 R309.2 ; v2(155.61,93.96) 155.61,93.93 155.14,93.46 154.85,93.46 154.72,93.58 153.7,93.58 153.4,93.29 R4829.2 153.4,92.87 154.26,92.01 R4717.1 ; 272.23,91.08 272.23,90.88 272.57,90.54 274.73,90.54 274.95,90.32 RS340.5 ; 272.23,91.08 RS340.10 ; v2(290.99,130.13) 290.64,130.13 289.72,131.05 R6024.2 ; v2(264.45,90.92) 264.02,90.92 R341.2 ; v2(129.65,75.5) 129.65,75.32 129.89,75.08 CN4941.3 ; R4743.1 157.4,95.87 v4(157.34,95.81) ; R317.2 284.05,113.27 283.12,114.2 v2(283.12,114.41) ; v2(278.92,99.51) 278.74,99.33 U300.40 ; R320.2 v2(268.26,115.05) ; R4535.1 157.41,85.96 v2(157.26,86.12) ; v2(301.02,132.83) 299.75,132.83 299.07,132.15 R363.1 ; Q6900.1 293.34,100.38 292.58,99.62 v2(291.67,99.62)
  TOP w0.305: CN300.4 266.55,86.2 v1(266.27,86.47) 266.07,86.47 265.38,87.16 265.38,87.32
  TOP w0.356: U1000.1 244.72,95.62 ; CN200.22 110.05,90.63 109.73,90.94 109.73,91.83 110.09,92.19 112.53,92.19 v5(112.94,91.78) ; U1000.14 242.99,95.24
  TOP w0.381: 303.96,126.9 D7605.2 ; Q2971.4 296.56,122.17 C2970.1 R2971.1 ; R7017.1 294.55,125.67 295.34,125.67 295.36,125.69 ; v2(266.99,87.11) 266.78,87.32 C335.1 C305.1 ; R3516.2 v2(129.32,149.59) ; C1308.1 304.26,128.21 ; v2(117.63,124.16) 117.6,124.19 C7581.1 ; C1000.1 244.56,94.06 v2(244.63,93.98) ; C1000.1 244.72,94.9 244.72,95.62 ; C1000.1 243.7,93.88 C1001.1 242.99,94.02 242.99,95.24 ; C7582.1 v2(143.67,152.56)
  TOP w0.508: Q2971.4 296.33,123.52 295.36,124.5 295.36,126.78 v2(296.58,128)
  L3 w0.254: v2(158.66,60.95) 158.66,63.36 156.78,65.24 142.12,65.24 135.48,71.88 135.48,72.7 v2(134.3,73.88) 134.3,73.07 133.62,72.4 v2(130.64,72.4) 130.14,72.9 130.14,75.01 v2(129.65,75.5) ; v5(112.94,91.78) 111.69,90.54 100.67,90.54 v4(99.04,88.91) ; v2(271.71,114.95) 271.11,115.56 268.64,115.56 268.26,115.17 v2(268.26,115.05) ; v5(114.74,91.78) 114.79,91.83 119.89,91.83 121.25,90.48 136.65,90.48 137.58,91.41 141.9,91.41 142.27,91.04 v2(142.27,90.92)
  L5 w0.254: 264.45,65.55 v2(264.45,65.55) ; 264.45,65.55 264.45,65.54 264.45,64.43 258.78,58.76 251.48,58.76 251.31,58.6 251.31,58.6 250.8,58.09 243.81,58.09 v2(243.24,57.52) ; 264.45,65.55 v2(264.45,65.55) ; 264.45,65.55 v2(264.45,65.55) ; v4(157.34,95.81) 157.34,95.69 v2(155.61,93.96) 155.61,93.93 155.21,93.53 153.84,93.53 153.65,93.71 152.25,93.71 151.3,92.75 v2(151.3,92.06) ; v2(157.26,86.12) 156.6,86.78 154.51,86.78 154.18,87.11 150.91,87.11 148.14,84.33 145.87,84.33 145.85,84.36 145.28,84.36 144.38,85.26 144.38,88.81 v2(142.27,90.92) ; v2(60.99,88.63) 62.05,89.69 72.58,89.69 73.31,88.95 79.17,88.95 80.83,90.61 82.56,90.61 83.32,91.38 86.45,91.38 86.62,91.55 88.93,91.55 89.5,90.98 95.22,90.98 95.92,90.28 97.8,90.28 99.04,89.04 v4(99.04,88.91) ; v2(134.3,73.88) 134.78,74.36 134.78,77.09 129.34,82.53 v2(123.18,82.53) ; v2(242.73,99.3) 245.52,99.3 246.03,98.79 246.03,95.57 244.61,94.14 244.61,93.98 v2(244.63,93.98) ; v2(270.54,112.38) 271.71,113.55 v2(271.71,114.95)
  L6 w0.254: v2(151.3,92.06) 154.11,92.06 155.1,91.07 155.78,91.07 156.67,90.18 156.67,86.7 v2(157.26,86.12) ; v2(244.63,93.98) 244.42,93.76 241.95,93.76 240.98,94.73 238.65,94.73 238.14,94.22 235.36,94.22 v2(234.98,94.6) ; 276.94,111.03 272.19,111.03 270.83,112.38 v2(270.54,112.38)
  L6 w0.508: 244.62,93.97 244.62,93.63 245.68,92.57 250.35,92.57 v2(251.87,91.04)
  BOTTOM w0.254: v2(257.41,102.4) 258.3,101.51 258.3,99.17 ; 156.12,96.99 156.98,96.99 157.09,96.89 157.49,96.89 157.59,96.99 R4744.1 158.02,96.99 R4721.1 157.63,96.1 v4(157.34,95.81) ; 156.12,96.99 156.12,97.39 157,98.28 160.43,98.28 161.32,97.39 R340.2 ; 156.12,96.99 156.12,95.11 156.57,94.65 157.69,94.65 R4909.1 R4747.1 ; v2(291.67,99.62) 291.31,99.62 290.99,99.3 288.07,99.3 287.68,99.68 281.97,99.68 v2(280.58,101.08) 279.01,99.51 v2(278.92,99.51) ; v2(123.18,82.53) 123.17,82.53 123.17,82.41 121.9,81.14 115.22,81.14 114.03,82.33 114.03,84.84 ; 261.02,82.15 261.02,81.9 260.72,81.6 R1404.1 C1402.1 ; PAD6241.1 178.47,149.08 177.45,148.07 v2(177.32,148.07) ; v2(290.99,130.13) 291.21,130.35 291.21,135.46 v2(291.62,135.88) ; v2(142.27,90.92) 143.63,89.56 R310.2 R311.2 ; v2(119.46,95.01) 120.5,95.01 120.71,94.8 120.71,93.48 121.7,92.49 R7154.1
  BOTTOM w0.381: C320.1 R346.2 230.87,58.74 231.72,59.59 R344.2 232.69,59.59 R355.1 232.95,60.06 233.63,60.74 240.02,60.74 v2(243.24,57.52) ; C320.1 227.95,57.94 227.13,58.77 U366.8 ; C320.1 C316.1 ; D7603.2 251.3,146.16 ; v2(143.71,151.62) D7604.2
  BOTTOM w0.508: v2(296.58,128) 298.94,128 v2(301.17,130.23) ; 262.16,98.66 261.65,99.17 256.83,99.17 255.43,97.78 252.64,97.78 251.87,97.01 v2(251.87,91.04)
  vias: v2(304.2,127.62) v5(107.09,144.13) v5(107.98,144.89) v5(113.37,92.57) v5(113.82,91.78) v5(114.26,92.57) v5(190.72,148.48) v5(191.79,148.45) v5(192.91,148.43) v5(193.87,148.43) v5(251.75,147.31) v5(251.75,146.16) v5(252.64,146.67) v5(267.49,145.02) v5(268.64,145.02) v5(269.78,145.02) v5(271.81,102.22) v5(272.57,101.33) v5(273.34,100.57) v5(278.29,126.6) v5(278.29,125.46) v5(279.56,126.6) v5(304.72,128.38) v5(305.72,128.38)
