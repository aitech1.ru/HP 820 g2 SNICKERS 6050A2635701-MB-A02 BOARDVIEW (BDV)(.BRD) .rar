# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Copper pours and planes (outline as drawn) (continued)
DGND on L6 (solid shape): 209.33,153.81 209.33,151.88 209.07,151.62 205.32,151.62 205.07,151.88 205.07,153.81 205.32,154.06 209.07,154.06
DGND on L6 (solid shape): 225.26,156.4 225.26,153.12 225,152.86 223.37,152.86 223.12,153.12 223.12,156.65 223.43,156.96 224.7,156.96
DGND on L6 (solid shape): 232.44,81.52 232.44,78.47 232.19,78.22 229.14,78.22 228.38,78.98 228.38,82.03 228.63,82.28 231.68,82.28
DGND on L6 (solid shape): 249.33,87.74 249.33,85.2 249.08,84.95 246.54,84.95 246.29,85.2 246.29,87.74 246.54,88 249.08,88
DGND on L6 (solid shape): 267.49,76.06 267.49,71.99 267.24,71.74 265.97,71.74 265.72,71.99 265.72,76.06 265.97,76.31 267.24,76.31
DGND on L6 (solid shape): 283.88,76.06 283.88,70.47 283.62,70.22 282.1,70.22 281.85,70.47 281.85,76.06 282.1,76.31 283.62,76.31
DGND on L6 (solid shape): 289.72,129.02 289.72,125.72 289.47,125.46 286.16,125.46 285.91,125.72 285.91,129.02 286.16,129.27 289.47,129.27
DGND on L6 (solid shape): 294.29,111.49 294.29,109.21 293.91,108.82 291.62,108.82 291.24,109.21 291.24,111.49 291.62,111.87 293.91,111.87
DGND on L6 (solid shape): 303.76,62.25 303.76,57.92 303.51,57.66 299.26,57.66 299.01,57.92 299.01,62.25 299.26,62.5 303.51,62.5
DGND on L6 (solid shape): 276,62.6 276,58.02 275.75,57.77 273.59,57.77 273.34,58.02 273.34,62.47 273.72,62.85 275.75,62.85
DGND on L6 (solid shape): 322.99,41.26 322.99,39.86 322.61,39.48 319.82,39.48 319.56,39.23 318.8,39.23 318.04,39.99 318.04,41.13 318.55,41.64 318.8,41.64 319.06,41.9 322.36,41.9
DGND on L6 (solid shape): 56.8,77.81 46.15,77.81 44.73,77.22 44.14,75.8 44.14,64.88 42.96,64.88 42.96,76.19 45.5,78.73 56.8,78.73
DGND on TOP: 329.44,96.52 329.31,96.19 328.98,96.06 325.76,96.07 325.76,96.89 325.54,97.47 324.97,97.72 323.55,97.72 322.97,97.48 322.74,96.89 322.74,96.25 320.63,96.25 319.33,97.55 319.32,97.55 318.94,97.93 317.16,97.93 316.03,99.06 316.03,102.97 317.54,104.48 322.98,104.48 323.36,104.1 325.54,104.1 326.32,104.88 326.32,133.35 325.92,133.74 324.26,133.74 324.26,133.74 323.35,133.74 322.96,133.36 318.4,133.36 317.28,134.48 317.28,136.41 316.21,137.47 316.21,140.77 316.69,140.77 316.69,140.45 316.7,140.34 317.06,139.47 317.87,138.98 317.98,138.96 317.98,138.93 318.09,138.92 318.2,138.92 322.63,138.92 322.73,138.87 322.75,138.86 322.83,138.74 322.88,138.6 323.22,137.99 323.87,137.74 324.93,137.74 325.58,137.99 325.92,138.6 325.97,138.74 326.05,138.86 326.07,138.87 326.17,138.92 329.13,138.92 329.3,138.82 329.41,138.66 329.41,137.99 329.24,137.79 328.98,137.71 328.35,137.71 326.84,136.2 328.35,134.69 328.98,134.69 329.24,134.61 329.41,134.41 329.41,102.79 329.24,102.59 328.98,102.51 328.35,102.51 326.84,101 328.35,99.49 328.98,99.49 329.31,99.36 329.44,99.03
DGND on TOP: 157.64,142.35 158.78,142.35 158.91,142.23 158.91,141.46 158.4,140.96 158.4,140.32 158.66,140.07 159.04,140.07 159.16,139.94 159.16,139.56 159.04,139.43 157.89,139.43 157.51,139.81 157.51,142.23
DGND on TOP: 238.79,143.5 238.92,143.62 239.94,143.62 240.19,143.37 240.19,141.08 239.94,140.83 239.17,140.83 238.79,141.21
DGND on TOP: 305.47,133.21 305.59,133.08 305.59,132.19 305.47,132.07 304.2,132.07 303.82,132.45 303.82,132.95 304.07,133.21
DGND on TOP: 316.77,26.15 316.9,26.02 316.9,25.51 316.39,25 316.39,23.61 316.14,23.35 315.25,23.35 314.99,23.61 314.99,25.89 315.25,26.15
DGND on TOP: 291.62,80.63 293.91,80.63 294.29,80.25 294.29,78.22 293.91,77.84 291.62,77.84 291.24,78.22 291.24,80.25
DGND on TOP: 232.7,137.4 235.62,137.4 235.74,137.27 235.74,136.89 235.62,136.76 235.11,136.76 234.98,136.64 234.98,135.75 234.86,135.62 234.35,135.62 234.22,135.75 233.33,135.75 233.2,135.88 233.2,136.38 233.08,136.51 232.7,136.51 232.57,136.64 232.57,137.27
DGND on TOP: 148.88,138.8 149.89,138.8 150.02,138.67 150.02,137.53 149.77,137.27 149.77,136.13 149.51,135.88 148.11,135.88 147.86,136.13 147.86,137.78
DGND on TOP: 276.13,118.48 276.77,118.48 277.02,118.22 277.02,116.7 276.77,116.44 275.62,116.44 274.99,117.08 274.99,118.6 275.24,118.86 275.75,118.86
DGND on TOP: 234.47,128.13 234.98,128.64 234.98,130.29 234.73,130.54 225.33,130.54 225.08,130.29 225.08,128.76 225.71,128.13
DGND on TOP: 152.31,136.51 153.83,136.51 154.72,135.62 154.72,134.86 154.59,134.73 152.43,134.73 152.18,134.99 152.18,136.38
DGND on TOP: 200.44,128.38 201.45,128.38 201.96,127.87 201.96,126.6 201.45,126.1 200.31,126.1 200.18,126.22 200.18,128.13
DGND on TOP: 145.32,137.65 145.32,135.88 145.45,135.75 146.34,135.75 146.46,135.88 146.46,137.65 146.34,137.78 145.45,137.78
DGND on TOP: 143.8,146.67 146.97,146.67 147.1,146.54 147.1,146.04 146.97,145.91 146.34,145.91 146.21,145.78 146.21,141.84 145.83,141.46 144.05,141.46 142.78,142.73 142.78,145.65
DGND on TOP: 303.44,110.6 303.82,110.98 304.83,110.98 305.21,110.6 305.21,108.95 304.96,108.7 303.69,108.7 303.44,108.95
DGND on TOP: 306.1,88.38 306.48,88.76 308.26,88.76 308.64,88.38 308.64,88 307.63,86.98 306.36,86.98 306.1,87.23
DGND on TOP: 248.95,82.66 249.71,82.66 249.84,82.54 249.84,81.65 249.59,81.39 248.06,81.39 247.81,81.65 247.81,82.03 248.06,82.28 248.57,82.28
DGND on TOP: 152.05,142.1 152.69,142.1 152.81,141.97 153.96,141.97 154.08,141.84 154.08,140.83 153.83,140.57 152.56,140.57 151.92,141.21 151.92,141.97
DGND on TOP: 160.56,142.48 162.47,142.48 162.59,142.35 162.59,141.72 161.83,140.96 161.58,140.96 161.45,141.08 161.45,141.34 161.32,141.46 160.56,141.46 160.43,141.59 160.43,142.35
DGND on TOP: 157.77,138.16 158.91,138.16 159.16,137.91 159.16,137.27 158.91,137.02 158.91,135.62 158.66,135.37 157.64,135.37 157.39,135.62 157.39,137.78
DGND on TOP: 134.91,64.25 135.16,63.99 136.68,63.99 136.94,64.25 136.94,67.68 136.68,67.93 136.68,68.31 136.56,68.44 136.56,68.69 135.16,68.69 134.91,68.44
DGND on TOP: 192.56,86.73 192.56,85.84 192.82,85.58 196.37,85.58 196.63,85.84 196.63,86.73 196.37,86.98 192.82,86.98
DGND on TOP: 318.68,36.31 317.66,36.31 316.77,37.2 316.39,37.2 316.26,37.32 316.26,38.72 316.39,38.85 317.15,38.85 317.53,38.47 318.68,38.47 319.06,38.09 319.06,36.69
DGND on TOP: 255.68,81.52 256.06,81.14 256.7,81.14 256.83,81.01 256.83,80.25 256.7,80.12 255.43,80.12 254.67,80.88 254.67,81.77 254.92,82.03 255.43,82.03 255.68,81.77
DGND on BOTTOM: 160.81,150.86 163.23,150.86 163.61,150.48 163.61,149.85 163.48,149.72 163.1,149.72 162.72,149.34 161.07,149.34 160.69,149.72 160.69,150.73
DGND on BOTTOM: 258.48,75.55 258.1,75.17 257.59,75.17 257.59,75.68 257.21,76.06 257.21,76.95 257.33,77.07 259.24,77.07 259.37,76.95 259.37,75.68 259.24,75.55
DGND on BOTTOM: 84.87,88.89 86.75,88.89 87.04,88.6 87.04,85.2 86.78,84.95 82.95,84.95 82.69,85.2 82.69,88.62 83.08,89.01 84.74,89.01
DGND on BOTTOM: 97.44,89.14 98.33,89.14 98.97,88.5 98.97,87.62 98.84,87.49 98.33,87.49 98.08,87.23 97.06,87.23 96.81,87.49 96.81,88.5
DGND on BOTTOM: 184.69,158.1 187.99,158.1 188.5,157.59 188.5,151.24 184.82,151.24 184.31,151.75 184.31,157.72
DGND on BOTTOM: 145.83,131.94 145.83,132.83 124.75,132.83 124.62,132.7 124.62,131.94 124.75,131.81 145.7,131.81
DGND on BOTTOM: 231.17,66.66 231.43,66.41 231.43,62.85 229.52,60.95 227.49,60.95 227.36,61.07 227.36,63.74 226.6,64.5 226.6,65.26 226.98,65.64 228.12,65.64 228.51,66.03 228.51,66.41 228.76,66.66
DGND on BOTTOM: 204.79,154.19 206.09,154.19 206.49,153.78 209.46,153.78 209.71,153.53 209.71,152.13 209.46,151.88 205.65,151.88 205.26,152.26 205.26,153.86 205.11,154.01 204.79,154.01
DGND on BOTTOM: 271.43,61.45 271.43,57.01 271.94,56.5 275.11,56.5 275.24,56.63 275.24,57.77 276,58.53 276,60.95 275.88,61.07 274.35,61.07 274.23,61.2 274.23,62.6 274.73,63.1 275.75,63.1 275.88,63.23 275.88,63.49 273.46,63.49
DGND on BOTTOM: 203.99,132.83 223.17,132.83 223.43,132.57 223.43,131.68 223.93,131.18 225.46,131.18 226.35,130.29 226.35,129.53 226.09,129.27 206.66,129.27 203.87,132.07 203.87,132.7
DGND on BOTTOM: 241.97,131.43 245.9,131.43 246.79,130.54 260.51,130.54 261.4,131.43 263.18,131.43 263.43,131.68 263.43,132.57 263.18,132.83 241.84,132.83 241.84,131.56
DGND on BOTTOM: 299.12,59.8 297.21,59.8 297.21,58.02 297.34,57.9 299.12,57.9 299.24,58.02 299.24,59.68
DGND on BOTTOM: 269.27,141.08 269.27,136 269.65,135.62 271.56,135.62 271.94,136 271.94,141.08 271.56,141.46 269.65,141.46
DGND on BOTTOM: 167.93,150.1 168.94,150.1 169.2,149.85 169.2,148.19 169.07,148.07 168.05,148.07 167.67,148.45 167.67,149.85
DGND on BOTTOM: 326.36,96.06 325.76,96.07 325.76,96.89 325.49,97.51 324.85,97.71 323.65,97.71 323.01,97.52 322.74,96.91 322.74,96.25 320.63,96.25 319.33,97.55 319.32,97.55 318.94,97.93 317.16,97.93 316.03,99.06 316.03,102.97 317.54,104.48 322.98,104.48 323.36,104.1 325.54,104.1 326.32,104.88 326.32,133.35 325.92,133.74 324.26,133.74 324.26,133.74 323.35,133.74 322.96,133.36 318.4,133.36 317.28,134.48 317.28,136.41 316.21,137.47 316.21,140.77 316.69,140.77 316.69,140.45 316.7,140.34 317.06,139.47 317.87,138.98 317.98,138.96 317.98,138.93 318.09,138.92 318.2,138.92 322.63,138.92 322.73,138.87 322.75,138.86 322.83,138.74 322.88,138.6 323.22,137.99 323.87,137.74 324.93,137.74 325.58,137.99 325.92,138.6 325.97,138.74 326.05,138.86 326.07,138.87 326.17,138.92 329.13,138.92 329.3,138.82 329.41,138.66 329.41,137.99 329.24,137.79 328.98,137.71 328.35,137.71 326.84,136.2 328.35,134.69 328.98,134.69 329.24,134.61 329.41,134.41 329.41,102.79 329.24,102.59 328.98,102.51 328.35,102.51 326.84,101 328.35,99.49 328.98,99.49 329.31,99.36 329.44,99.03 329.44,96.52 329.31,96.19 328.98,96.06
DGND on BOTTOM: 159.39,163.31 168.56,163.31 170.09,161.78 170.09,151.5 169.58,150.99 167.55,150.99 167.16,151.37 167.16,159.12 166.71,159.57 157.46,159.57 157.46,161.38
DGND on BOTTOM: 117.76,139.81 117.76,132.19 118.14,131.81 121.95,131.81 122.33,132.19 122.33,139.69 121.95,140.07 118.02,140.07
DGND on BOTTOM: 125.86,97.78 127.03,97.78 127.54,98.28 127.54,99.68 128.68,100.82 129.32,100.82 129.7,101.2 129.7,103.24 129.32,103.62 127.16,103.62 126.4,102.86 126.4,101.97 126.27,101.84 126.27,100.95 125.91,100.59 125.91,99.6 125.86,99.55
DGND on BOTTOM: 194.47,62.72 195.99,62.72 196.25,62.98 196.25,68.95 196.12,69.07 194.34,69.07 194.22,68.95 194.22,62.98
DGND on BOTTOM: 151.8,160.39 151.8,159.37 151.54,159.12 148.62,159.12 148.37,159.37 148.37,160.13 148.62,160.39
DGND on BOTTOM: 174.4,154.16 175.93,154.16 175.93,151.62 176.18,151.37 176.18,149.59 176.05,149.46 175.93,149.46 175.67,149.72 175.67,150.99 175.17,151.5 174.53,151.5 174.4,151.62
DGND on BOTTOM: 221.14,157.59 221.14,154.42 223.06,152.5 225.47,152.5 227.07,150.9 227.07,150.27 227.36,149.97 228.25,149.97 228.46,150.19 228.46,153.06 225.71,155.81 225.71,157.59 225.33,157.97 221.52,157.97
DGND on BOTTOM: 238.33,65.41 238.33,69.91 237.9,70.34 237.9,74.28 237.52,74.66 235.62,74.66 234.86,73.9 234.86,69.96 235.24,69.58 235.87,69.58 236.25,69.2 236.25,65.41
DGND on BOTTOM: 319.06,38.09 318.68,38.47 317.28,38.47 317.02,38.21 317.02,36.43 317.15,36.31 318.8,36.31 319.06,36.56
DGND on BOTTOM: 244.13,144.51 237.9,144.51 236.51,145.91 236.51,147.31 237.01,147.81 237.01,147.81 237.32,148.12 237.7,148.12 237.7,146.81 238.35,146.16 240.57,146.16 241.07,146.67 244.13,146.67 244.38,146.41 244.38,144.77
DGND on BOTTOM: 186.09,132.07 186.21,132.19 186.21,132.7 186.09,132.83 164.37,132.83 164.24,132.7 164.24,132.19 164.37,132.07
DGND on BOTTOM: 299.24,66.03 299.5,66.28 299.5,67.42 299.24,67.68 296.96,67.68 296.7,67.42 296.7,66.28 296.96,66.03
DGND on BOTTOM: 118.65,124.19 119.03,124.57 119.03,125.46 118.27,126.22 118.27,129.78 118.78,130.29 166.4,130.29 167.04,129.65 167.04,128.51 156.37,117.84 152.05,117.84 142.53,108.32 134.27,108.32 133.51,109.08 133.51,112.13 132.95,112.68 129.11,112.68 128.43,112 128.43,108.82 128.05,108.44 119.16,108.44 118.65,108.95
DGND on L2: outline of 348 points within 30.36,1 329.44,163.43 ; 4 cut-outs
DGND on L4: 36.1,71.36 36.1,63.87 36.35,63.61 40.8,63.61 41.05,63.87 41.05,71.36 40.67,71.74 36.48,71.74
DGND on L4: 181.9,95.87 180.63,97.14 180.63,97.52 180.5,97.65 178.09,97.65 174.4,101.33 172.75,101.33 171.86,102.22 168.31,102.22 165.13,105.4 154.34,105.4 152.31,107.43 140.11,107.43 126.52,121.02 124.62,121.02 124.37,121.27 124.37,139.43 125.13,140.19 125.13,141.34 125.51,141.72 139.48,141.72 140.62,142.86 146.08,142.86 148.01,144.78 162.85,144.77 164.63,144.77 165.77,145.91 194.09,145.91 194.34,145.65 194.34,144.38 197.01,141.72 258.99,141.72 259.37,141.34 263.18,141.34 263.81,140.7 263.81,133.21 254.41,123.81 254.41,123.43 242.48,111.49 242.48,110.98 241.33,109.84 239.94,109.84 237.78,107.68 237.78,106.79 229.01,98.03 228.12,98.03 225.08,94.98 225.08,94.47 223.43,92.82 223.43,92.31 218.98,87.87 213.65,87.87 213.37,88.15 212.86,88.15 212.25,88.76 209.71,88.76 208.69,89.77 203.36,89.77 203.26,89.88 186.44,89.88 185.96,89.39 184.74,89.39 181.9,92.23 181.9,94.98 182.15,95.24 182.15,95.74 182.02,95.87
DGND on L5: 184.44,89.39 182.53,91.3 182.53,93.71 182.02,94.22 181.39,94.22 178.72,96.89 178.72,97.5 178.31,97.9 176.94,97.9 170.59,104.25 170.59,104.76 166.66,108.7 166.66,118.22 165.89,118.98 165.89,129.02 164.62,130.29 164.62,140.7 165.77,141.84 225.97,141.84 226.35,142.23 235.36,142.23 235.87,141.72 258.99,141.72 259.37,141.34 262.03,141.34 262.67,140.7 262.67,134.86 261.53,133.72 261.53,129.14 260,127.62 260,120.64 257.72,118.35 257.72,117.84 252.25,112.38 252.25,111.24 245.9,104.89 244.38,104.89 241.46,101.97 233.08,101.97 229.01,97.9 226.85,97.9 218.35,89.39 210.09,89.39 209.84,89.14 209.46,89.14 209.2,89.39
DGND on L7: outline of 325 points within 30.36,14.97 329.44,163.43 ; 3 cut-outs
DGND_CHASSIS1 on TOP (solid shape): 321.85,81.39 322.29,81.32 322.74,81.32 322.74,80.48 322.94,79.96 323.42,79.69 324.95,79.69 325.53,79.92 325.76,80.5 325.76,81.29 329.22,81.29 329.22,80.63 329.39,80.63 329.39,76.06 321.35,76.06 321,76.4 320.54,76.56 320.52,76.57 319.76,76.32 319.39,75.6 319.39,74.66 317.71,74.66 317.71,79.97 318.19,80.45 319.84,80.45 320.78,81.39
DGND_CHASSIS1 on BOTTOM (solid shape): 321.98,81.4 322.36,81.35 322.74,81.34 322.74,80.5 323.01,79.88 323.65,79.69 324.85,79.69 325.47,79.87 325.76,80.45 325.76,81.34 329.44,81.34 329.44,76.01 321.32,76.01 320.98,76.36 320.51,76.51 320.5,76.52 319.78,76.27 319.44,75.6 319.44,74.79 317.66,74.79 317.66,80 318.17,80.5 319.82,80.5 320.73,81.39 321.97,81.39
DGND_CHASSIS2 on TOP (solid shape): 319.43,62.84 319.43,61.6 319.44,61.6 319.5,61.59 319.54,61.55 320.32,61 321.21,61.33 321.32,61.42 321.46,61.48 327.98,61.48 327.98,61.03 327.11,60.16 327.11,58.89 327.36,58.63 327.36,58.48 328.1,57.74 328.1,57.53 321.58,57.53 321.37,57.58 321.21,57.7 320.14,57.99 319.44,57.14 319.44,56.39 319.06,56 317.92,56 317.67,56.25 317.67,58.66 318.29,58.66 318.68,59.04 318.68,60.31 317.67,61.31 317.67,62.84 317.79,62.96 319.3,62.96
DGND_CHASSIS2 on BOTTOM (solid shape): 319.43,62.84 319.43,61.6 319.44,61.6 319.5,61.59 319.54,61.55 320.32,61 321.21,61.33 321.32,61.42 321.46,61.48 327.97,61.48 327.97,61.3 327.35,60.68 327.35,60.4 326.93,59.98 326.93,59.04 327.35,58.62 327.35,58.24 328.06,57.53 321.58,57.53 321.37,57.58 321.21,57.7 320.14,57.99 319.44,57.14 319.44,56.39 319.06,56 317.92,56 317.67,56.25 317.67,62.84 317.79,62.96 319.3,62.96
DGND_CHASSIS3 on TOP (solid shape): 319.44,43.5 320.17,42.53 321.3,42.96 328.84,42.96 328.84,42.15 328.2,42.15 326.82,40.61 328.2,39.08 328.84,39.08 328.84,37.32 327.06,37.32 326.42,37.96 326.42,41.39 325.91,41.9 323.63,41.9 323.25,42.28 321.47,42.28 321.34,42.15 319.18,42.15 317.66,43.67 317.66,44.31 319.44,44.31
DGND_CHASSIS3 on BOTTOM (solid shape): 319.44,43.5 320.17,42.53 321.3,42.96 328.84,42.96 328.84,42.15 328.2,42.15 326.82,40.61 328.2,39.08 328.84,39.08 328.84,34.66 324.14,34.66 321.22,37.58 320.07,37.58 319.82,37.83 319.82,38.34 320.07,38.59 322.1,38.59 322.61,38.09 322.61,37.32 324.52,35.42 326.68,35.42 327.06,35.8 327.06,37.32 326.42,37.96 326.42,41.39 325.91,41.9 323.63,41.9 323.25,42.28 321.47,42.28 321.34,42.15 319.18,42.15 317.66,43.67 317.66,44.31 319.44,44.31
DGND_PBN on TOP, BOTTOM, L2, L3, L4, L5, L6, L7: 268.22,24.86 262.15,24.86 261.08,24.42 260.64,23.35 260.64,18.71 258,18.71 256.07,19 254.31,19.86 254.31,20.4 254.01,21.11 253.3,21.41 252.73,21.41 251.82,23.21 251.51,25.2 251.51,26.84 256.15,26.84 258.28,27.72 259.16,29.85 259.16,32.84 262,32.84 263.07,33.28 263.51,34.35 263.51,37.54 278,37.54 278.85,37.8 279.41,38.5 288.1,38.5 288.75,37.93 288.99,37.1 288.99,29.6 288.75,28.77 288.1,28.2 280.41,28.2 279.85,28.9 279,29.16 269.73,29.16 268.66,28.72 268.22,27.65
DGND_SM on TOP (solid shape): 70.95,122.57 67.36,122.57 67.36,125.57 67.34,125.75 67.29,125.93 67.3,126.03 67.39,126.07 70.95,126.07
DGND_SM on TOP (solid shape): 74.14,133.21 72.3,133.21 69.95,134.2 67.77,132.89 67.71,132.85 67.63,132.86 64.89,131.4 67.63,129.94 67.71,129.95 67.77,129.91 69.95,128.6 72.3,129.59 74.14,129.59 74.14,127.4 64.55,127.4 64.55,135.4 74.14,135.4
DGND_SM on TOP: outline of 81 points within 0.51,96.61 93.29,163.49 ; 13 cut-outs
DGND_SM on BOTTOM: 12.86,163.49 14.09,163.49 16.85,161.19 19.61,163.49 21.14,163.49 21.14,159.4 22.95,157.59 24.76,159.4 24.76,161.29 27.95,161.29 29.2,160.14 30.45,161.29 32.89,161.29 34.14,160.14 35.39,161.29 37.83,161.29 39.08,160.14 40.33,161.29 47.34,161.29 47.34,159.9 48.85,158.39 50.36,159.9 50.36,161.29 85.95,161.29 87.71,160.56 88.44,158.8 88.44,152.6 89.03,151.18 90.45,150.59 91.84,150.59 91.84,134.1 92.23,132.73 93.29,131.76 93.29,105 92.27,102.53 89.8,101.51 69.21,101.51 69.21,107.6 68.77,108.67 67.7,109.11 66.65,109.11 64.88,108.37 64.14,106.6 64.14,100.37 63.07,100.01 60.16,100.01 59.71,101.07 58.65,101.51 30.65,101.51 29.58,101.07 29.14,100 29.14,97.61 24.76,97.61 24.76,99.1 22.95,100.91 21.14,99.1 21.14,96.61 19.61,96.61 16.85,98.91 14.09,96.61 12.86,96.61 12.86,100 12.42,101.07 11.35,101.51 7.85,101.51 6.93,101.2 6.39,100.38 5.27,100.01 0.51,100.01 0.51,156.79 5.27,156.79 6.39,156.42 6.93,155.6 7.85,155.29 11.35,155.29 12.42,155.73 12.86,156.8 ; 1 cut-out
DGND_SM on L2, L4, L5, L6, L7: 12.86,163.49 14.09,163.49 16.85,161.19 19.61,163.49 21.14,163.49 21.14,159.4 22.95,157.59 24.76,159.4 24.76,161.29 27.95,161.29 29.2,160.14 30.45,161.29 32.89,161.29 34.14,160.14 35.39,161.29 37.83,161.29 39.08,160.14 40.33,161.29 47.34,161.29 47.34,159.9 48.85,158.39 50.36,159.9 50.36,161.29 85.95,161.29 87.71,160.56 88.44,158.8 88.44,152.6 89.03,151.18 90.45,150.59 91.84,150.59 91.84,134.1 92.23,132.73 93.29,131.76 93.29,105 92.27,102.53 89.8,101.51 69.21,101.51 69.21,107.6 68.77,108.67 67.7,109.11 66.65,109.11 64.88,108.37 64.14,106.6 64.14,100.37 63.07,100.01 60.16,100.01 59.71,101.07 58.65,101.51 30.65,101.51 29.58,101.07 29.14,100 29.14,97.61 24.76,97.61 24.76,99.1 22.95,100.91 21.14,99.1 21.14,96.61 19.61,96.61 16.85,98.91 14.09,96.61 12.86,96.61 12.86,100 12.42,101.07 11.35,101.51 7.85,101.51 6.93,101.2 6.39,100.38 5.27,100.01 0.51,100.01 0.51,156.79 5.27,156.79 6.39,156.42 6.93,155.6 7.85,155.29 11.35,155.29 12.42,155.73 12.86,156.8
DGND_SM on L3: 12.86,163.49 14.09,163.49 16.85,161.19 19.61,163.49 21.14,163.49 21.14,159.4 22.95,157.59 24.76,159.4 24.76,161.29 27.95,161.29 29.2,160.14 30.45,161.29 32.89,161.29 34.14,160.14 35.39,161.29 37.83,161.29 39.08,160.14 40.33,161.29 47.34,161.29 47.34,159.9 48.85,158.39 50.36,159.9 50.36,161.29 85.95,161.29 87.71,160.56 88.44,158.8 88.44,152.6 89.03,151.18 90.45,150.59 91.84,150.59 91.84,134.1 92.23,132.73 93.29,131.76 93.29,105 92.27,102.53 89.8,101.51 69.21,101.51 69.21,107.6 68.77,108.67 67.7,109.11 66.65,109.11 64.88,108.37 64.14,106.6 64.14,100.37 63.07,100.01 60.16,100.01 59.71,101.07 58.65,101.51 30.65,101.51 29.58,101.07 29.14,100 29.14,97.61 24.76,97.61 24.76,99.1 22.95,100.91 21.14,99.1 21.14,96.61 19.61,96.61 16.85,98.91 14.09,96.61 12.86,96.61 12.86,100 12.42,101.07 11.35,101.51 7.85,101.51 6.93,101.2 6.39,100.38 5.27,100.01 0.51,100.01 0.51,156.79 5.27,156.79 6.39,156.42 6.93,155.6 7.85,155.29 11.35,155.29 12.42,155.73 12.86,156.8 ; 1 cut-out
DGND_SYS1 on TOP, L2, L3, L4, L5, L6, L7: 223.5,46.98 224.26,47.18 224.99,47.92 225.23,47.98 248.48,47.98 248.48,41.52 242.84,41.52 242.71,41.54 242.2,41.76 241.79,41.82 235.21,41.82 234.8,41.76 234.29,41.54 206.84,41.52 206.71,41.54 206.2,41.76 205.79,41.82 199.21,41.82 198.8,41.76 198.29,41.54 192.52,41.52 192.52,47.98 215.77,47.98 216.01,47.92 216.74,47.18 217.5,46.98 ; 1 cut-out
DGND_SYS1 on BOTTOM: 223.5,46.98 224.26,47.18 224.99,47.92 225.23,47.98 248.48,47.98 248.48,41.52 242.84,41.52 242.71,41.54 242.2,41.76 241.79,41.82 235.21,41.82 234.8,41.76 234.29,41.54 206.84,41.52 206.71,41.54 206.2,41.76 205.79,41.82 199.21,41.82 198.8,41.76 198.29,41.54 192.52,41.52 192.52,47.98 215.77,47.98 216.01,47.92 216.74,47.18 217.5,46.98 ; 6 cut-outs
DGND_VGA on TOP (solid shape): 34.96,81.27 34.96,77.56 33.74,76.34 33.29,76.34 33.29,77.73 33.33,77.93 33.45,78.08 33.72,79.22 32.75,79.89 32.17,79.89 31.83,80.03 31.69,80.37 31.69,81.04 32.16,81.52 34.7,81.52
DGND_VGA on BOTTOM (solid shape): 34.96,81.27 34.96,77.56 33.74,76.34 33.29,76.34 33.29,77.73 33.33,77.93 33.45,78.08 33.72,79.22 32.75,79.89 32.17,79.89 31.83,80.03 31.69,80.37 31.69,81.04 32.16,81.52 34.7,81.52
P0V675M_VREF on BOTTOM (solid shape): 182.53,151.62 182.91,151.62 183.42,151.12 183.42,149.72 183.17,149.46 182.79,149.46 182.53,149.72 182.53,149.97 181.52,150.99 181.52,152 181.77,152.26 181.9,152.26
P0V675M_VREF_H on TOP: 203.61,93.2 203.87,93.2 204.38,92.7 204.88,92.7 205.39,93.2 205.9,93.2 206.28,92.82 206.28,89.27 206.15,89.14 204.38,89.14 203.87,89.65 203.87,91.81 203.61,92.06
P0V675S on BOTTOM: 171.23,152.77 171.36,152.77 171.36,148.32 171.1,148.07 169.7,148.07 169.45,148.32 169.45,150.1 170.47,151.12 170.47,153.4 170.59,153.4
P1V2A on TOP (solid shape): 260.64,83.93 260.64,83.17 258.99,83.17 258.48,82.66 258.22,82.66 257.97,82.92 257.97,83.93 257.46,84.44 257.46,85.08 257.72,85.33 259.24,85.33
P1V2A on BOTTOM: 262.03,66.15 262.67,66.15 265.59,63.23 266.35,63.23 266.48,63.1 266.48,61.45 264.45,59.42 261.91,59.42 260.89,60.44 260.89,62.47 261.4,62.98 261.4,65.52
P1V2A on BOTTOM: 266.61,60.06 267.37,60.06 271.18,56.25 275.24,56.25 275.5,56.5 275.5,57.64 276.26,58.41 276.26,60.82 276.51,61.07 277.78,61.07 278.04,60.82 278.04,57.26 277.72,56.94 277.72,56.31 276.77,55.36 276.77,54.6 276.26,54.09 271.05,54.09 266.35,58.79 266.35,59.8
P1V05_LAN_M_PHY on TOP: 293.53,106.41 293.53,106.16 293.91,105.78 293.91,102.35 293.78,102.22 292.64,102.22 292.39,102.47 292.39,105.01 293.15,105.78 293.15,106.41 293.28,106.54 293.4,106.54
P1V05_NIC on TOP: 292.89,106.41 292.89,105.9 291.88,104.89 291.88,102.47 291.62,102.22 290.48,102.22 290.35,102.35 290.35,104.76 290.48,104.89 290.74,104.89 291.75,105.9 292.13,105.9 292.64,106.41
P1V05A on BOTTOM (solid shape): 133.89,91.04 134.88,91.04 134.88,85.3 134.65,85.08 134.02,85.08 133.59,84.64 133.59,81.32 133.28,81.01 130.08,81.01 129.7,81.39 129.7,90.41 130.84,91.55 133.38,91.55
P1V05A on BOTTOM (solid shape): 160.69,69.84 161.96,69.84 162.08,69.71 162.08,68.82 161.96,68.69 161.58,68.69 161.32,68.44 160.18,68.44 159.54,69.07 159.04,69.07 158.27,69.84 158.27,70.34 158.53,70.6 159.93,70.6
P1V05A on L5: 157.64,70.85 159.8,70.85 160.05,70.6 160.05,70.09 159.8,69.84 157.64,69.84
P1V05A_MODPHY on BOTTOM (solid shape): 161.7,67.3 161.7,66.53 162.08,66.15 162.97,66.15 162.97,64.5 162.85,64.37 161.96,64.37 161.58,63.99 160.69,63.99 160.43,64.25 160.43,66.28 160.05,66.66 160.05,67.8 160.18,67.93 161.07,67.93
P1V05A_MODPHY on TOP: 176.31,73.14 176.31,71.11 175.42,70.22 175.42,67.68 175.17,67.42 174.02,67.42 173.77,67.68 173.77,70.6 174.35,71.18 175.19,71.18 175.55,71.54 175.55,72.76 175.17,73.14 174.78,73.14 174.78,73.9 175.55,73.9
P1V05A_MODPHY on TOP: 180.12,81.65 180.12,81.01 179.48,80.38 179.23,80.38 179.1,80.25 179.1,79.87 178.98,79.74 176.31,79.74 175.42,78.85 173.77,78.85 173.77,82.28 174.02,82.54 178.59,82.54 178.85,82.28 178.85,81.77 178.98,81.65
P1V05A_MODPHY on BOTTOM: 168.48,64.45 167.8,65.14 167.8,65.52 168.18,65.9 170.59,65.9 170.85,66.15 171.48,66.15 171.61,66.28 173.39,66.28 174.15,67.04 174.15,67.8 174.4,68.06 175.29,68.06 175.42,67.93 175.42,67.04 173.77,65.39 172.63,65.39 172.37,65.14 172.37,65.01 171.81,64.45
P1V05A_MODPHY on BOTTOM: 179.1,80.88 179.61,81.39 179.99,81.39 180.12,81.27 180.12,80.76 178.98,79.61 178.47,79.61 178.34,79.74 178.34,80.63 178.59,80.88
P1V05M on BOTTOM (solid shape): 138.72,85.2 139.35,85.2 139.86,84.69 141,84.69 141.26,84.44 141.26,84.06 140.24,83.04 139.35,83.04 138.97,82.66 137.45,82.66 137.19,82.41 137.19,81.47 137.04,81.32 133.89,81.32 133.89,82.79 135.41,84.31 137.45,84.31 137.57,84.44 137.57,84.95 137.32,85.2 137.32,85.58 137.45,85.71 138.21,85.71
P1V5S on BOTTOM (solid shape): 97.57,135.37 99.47,135.37 99.85,134.99 99.85,132.95 98.08,132.95 95.92,135.11 95.92,135.62 96.17,135.88 97.06,135.88
P1V05S on BOTTOM (solid shape): 137.45,90.54 140.11,90.54 140.37,90.28 140.37,89.77 140.75,89.39 140.75,88.76 141.26,88.25 141.26,85.46 141,85.2 140.37,85.2 139.86,85.71 138.84,85.71 138.11,86.45 135.31,86.45 135.31,90.43 135.92,91.04 136.94,91.04
P1V05S on L4: 141,83.55 143.16,83.55 143.8,82.92 143.8,81.9 144.18,81.52 149.64,81.52 149.89,81.77 150.91,81.77 151.16,81.52 175.8,81.52 179.86,77.46 182.53,77.46 182.91,77.84 184.69,77.84 184.82,77.96 184.82,79.36 185.33,79.87 188.5,79.87 189.52,80.88 189.52,89.39 189.29,89.62 186.57,89.62 186.09,89.14 184.69,89.14 184.56,89.27 182.66,89.27 182.53,89.14 182.53,88.76 182.28,88.5 180.75,88.5 179.61,89.65 138.34,89.65 137.95,89.27 137.95,86.6
P1V5S on L6: 182.02,78.09 182.02,75.93 181.39,75.3 178.21,75.3 177.96,75.04 177.83,75.04 177.45,75.42 177.45,76.82 178.72,78.09 178.72,79.11 179.74,80.12 184.44,80.12 184.82,80.5 187.1,80.5 189.14,78.47 205.39,78.47 206.66,77.2 208.31,77.2 209.33,76.19 209.33,74.53 205.39,74.53 203.49,76.44 186.6,76.44 185.2,77.84 185.2,78.6 184.82,78.98 182.91,78.98
P1V05S_VCCP on L6: 186.6,85.46 187.74,85.46 187.99,85.71 187.99,87.11 187.23,87.87 186.6,87.87 186.34,87.62 186.34,85.71
P1V8S_SM on TOP: 79.53,116.83 80.04,117.33 80.04,118.22 79.66,118.6 76.36,118.6 76.11,118.35 76.11,115.56 76.36,115.3 78.65,115.3 78.9,115.56 78.9,116.7 79.03,116.83
P1V35 on TOP: 211.49,146.29 211.49,145.78 211.61,145.65 214.79,145.65 214.92,145.78 214.92,146.29 214.79,146.42 211.61,146.42
P1V35 on TOP: 189.64,88.38 189.39,88.63 189.39,89.65 189.26,89.77 187.99,89.77 187.74,90.03 187.74,95.74 186.91,96.57 186.02,96.57 184.06,98.54 184.06,102.86 180.63,106.28 180.63,108.19 175.42,113.4 160.69,113.4 144.69,129.4 144.69,136.89 144.56,137.02 144.56,139.56 146.72,141.72 146.72,145.53 146.84,145.65 147.86,145.65 149.26,147.05 163.48,147.05 167.16,143.37 167.16,136.51 168.18,135.49 179.1,135.49 183.67,130.92 206.41,130.92 208.69,133.21 219.49,133.21 222.54,136.26 222.54,139.05 223.68,140.19 226.47,140.19 226.73,140.45 226.73,142.61 226.98,142.86 226.98,144.64 227.11,144.77 227.74,144.77 227.87,144.64 227.87,142.86 228.12,142.61 229.14,142.61 229.39,142.86 229.39,144 229.01,144.38 229.01,144.64 229.14,144.77 237.27,144.77 238.54,143.5 238.54,141.21 239.3,140.45 240.57,140.45 240.95,140.07 240.95,122.16 236.18,117.38 225.25,117.38 211.23,103.36 211.23,98.92 207.55,95.24 204.76,95.24 203.36,93.84 203.36,89.77 202.72,89.14 198.15,89.14 196.5,87.49 192.82,87.49 191.93,88.38 ; 6 cut-outs
P1V35 on BOTTOM: 224.06,131.43 225.58,131.43 227.62,129.4 232.57,129.4 233.97,130.8 237.9,130.8 238.67,131.56 238.67,132.7 238.54,132.83 223.81,132.83 223.68,132.7 223.68,131.81
P1V35 on BOTTOM: 223.61,144.13 222.62,145.12 212.5,145.12 211.89,144.51 208.82,144.51 208.21,145.12 166.25,145.12 165.36,144.23 150.02,144.23 150.02,148.07 150.78,148.83 159.93,148.83 160.18,149.08 164.62,149.08 164.88,149.34 165.51,149.34 166.15,148.7 167.04,148.7 168.05,147.69 171.74,147.69 172.75,148.7 173.39,148.7 173.77,149.08 173.77,149.85 173.39,150.23 171.74,150.23 171.61,150.35 171.61,152.2 172,152.59 174.07,152.59 174.07,151.45 174.28,151.24 175.04,151.24 175.55,150.73 175.55,149.08 177.45,147.18 194.85,147.18 195.41,147.74 224.67,147.74 224.97,147.43 230.54,147.43 232.82,145.15 236.89,145.15 237.52,144.51 237.52,144.13
P1V35 on BOTTOM: 162.59,132.7 162.47,132.83 146.84,132.83 146.72,132.7 146.72,132.07 146.97,131.81 162.34,131.81 162.59,132.07
P3V3A on BOTTOM (solid shape): 111.26,85.18 110.9,84.82 105.32,84.82 104.97,85.17 104.97,86.73 105.22,86.98 105.7,86.98 105.98,87.26 111.26,87.26
P3V3A on L4: outline of 125 points within 104.81,56.12 294.67,123.3
P3V3A_Q_WLAN on TOP: 306.99,133.97 308.39,132.57 308.39,125.33 306.23,123.18 305.21,123.18 304.96,123.43 304.96,124.83 306.23,126.1 306.23,127.75 306.36,127.87 306.36,129.02 306.23,129.14 306.23,131.94 305.85,132.32 305.85,133.21 305.47,133.59 305.47,133.84 305.59,133.97
P3V3A_Q_WLAN on BOTTOM: 306.23,133.08 307.88,133.08 308.77,132.19 308.77,128.38 308.64,128.26 306.99,128.26 306.99,128.89 306.74,129.14 306.1,129.14 305.59,129.65 305.59,132.45
P3V3A_Q_WLAN on BOTTOM: 309.79,113.14 310.29,113.14 310.55,112.89 310.55,111.49 309.79,110.73 309.02,110.73 308.9,110.86 308.9,111.75 309.53,112.38 309.53,112.89
P3V3AL_KBC on TOP (solid shape): 253.52,93.97 254.54,93.97 254.79,93.71 254.79,93.2 254.54,92.95 253.52,92.95 253.02,92.44 252.2,92.44 252.13,92.52 252.13,94.6 252.25,94.73 252.76,94.73
P3V3AL_RTC_BAT on TOP (solid shape): 268.13,151.62 266.73,151.62 266.48,151.88 266.48,152.51 267.11,153.15 268.13,153.15
P3V3DS on TOP (solid shape): 108.62,145.4 108.62,144.64 107.47,143.5 105.19,143.5 104.93,143.75 104.93,145.27 105.95,145.27 106.46,145.78 108.24,145.78
P3V3DS on TOP (solid shape): 254.92,92.31 254.92,91.17 254.54,90.79 251.75,90.79 251.37,91.17 251.37,91.68 251.62,91.93 253.27,91.93 253.91,92.57 254.67,92.57
P3V3DS on TOP: 305.85,128.89 306.1,128.64 306.1,128 305.98,127.87 305.98,126.22 305.47,125.72 304.96,125.72 303.69,126.99 303.69,128.38 304.07,128.38 304.58,128.89
P3V3DS on BOTTOM: 192.52,149.62 193.94,149.62 194.47,149.08 194.47,148.19 194.09,147.81 190.53,147.81 190.15,148.19 190.15,149.43 191.02,150.3 191.63,150.3 192.32,149.62 192.52,149.62
P3V3DS on BOTTOM: 177.83,150.35 177.96,150.35 178.59,149.72 178.98,149.72 178.98,148.58 178.21,147.81 177.32,147.81 177.07,148.07 177.07,148.96 177.71,149.59 177.71,150.23
P3V3DS on BOTTOM: 258.99,80.12 257.97,80.12 257.84,80 257.84,79.61 257.56,79.33 256.65,79.33 256.57,79.41 256.57,86.98 258.1,88.5 260.64,88.5 263.43,91.3 263.43,95.24 262.03,96.63 262.03,98.66 266.22,102.86 272.07,102.86 273.97,100.95 273.97,97.14 272,95.17 272,86.03 270.67,84.69 264.95,84.69 262.16,81.9 260.26,81.9 259.49,81.14 259.49,79.87 259.24,79.87
P3V3DS on BOTTOM: 111.92,84.69 115.98,84.69 116.41,85.13 116.41,88.3 116.06,88.3 115.22,89.14 115.22,92.19 114.46,92.95 112.94,92.95 112.43,92.44 112.43,91.3 111.67,90.54 111.67,84.95
P3V3DS on BOTTOM: 252.89,150.73 269.53,150.73 270.42,149.85 270.42,143.88 270.03,143.5 266.35,143.5 264.32,145.53 251.67,145.53 251.24,145.96 251.24,149.08
P3V3DS on L4: 165.64,146.16 164.5,145.02 147.86,145.02 145.96,143.11 140.49,143.11 139.35,141.97 125.38,141.97 124.87,141.46 124.87,140.32 124.11,139.56 124.11,121.4 123.73,121.02 122.71,121.02 121.32,119.62 121.32,94.85 117.13,90.66 113.06,90.66 112.3,91.43 112.3,94.47 111.54,95.24 111.54,126.86 104.93,133.46 104.93,148.7 111.79,155.56 169.45,155.56 173.13,151.88 191.55,151.88 194.34,149.08 194.34,146.42 194.09,146.16
P3V3DS on L5: 190.66,152 204.25,152 205.01,151.24 209.2,151.24 209.96,152 226.98,152 228.25,150.73 249.21,150.73 254.54,145.4 274.61,145.4 277.02,142.99 300.9,142.99 302.55,144.64 303.18,144.64 303.82,144 305.21,144 307.12,142.1 307.12,140.58 307.12,140.57 307.12,140.51 307.12,128 306.48,127.37 301.28,127.37 300.77,127.87 300.77,134.61 299.37,136 292.26,136 291.88,135.62 289.47,135.62 289.08,136 282.1,136 280.45,134.35 280.45,124.83 279.94,124.32 277.27,124.32 276.89,124.7 276.89,134.22 276.13,134.99 268.38,134.99 266.35,137.02 266.35,138.67 263.43,141.59 259.49,141.59 259.11,141.97 236,141.97 235.49,142.48 225.97,142.48 225.58,142.1 190.41,142.1 190.02,142.48 190.02,151.37
P3V3DS on L6: 277.91,126.99 280.32,126.99 283.24,124.06 283.24,118.73 285.15,116.83 285.15,113.9 282.42,111.17 282.42,106.98 279.81,104.38 279.81,99.55 279.31,99.05 278.42,99.05 277.27,100.19 272.96,100.19 271.18,101.97 271.18,107.17 277.65,113.65 277.65,126.73
P3V3M on TOP (solid shape): 295.74,118.86 294.04,118.86 293.91,118.98 293.91,120.51 293.66,120.76 292.64,120.76 292.51,120.89 292.51,121.78 292.64,121.91 293.78,121.91 294.09,122.21 294.09,122.41 295.74,122.41
P3V3S on BOTTOM (solid shape): 125.38,84.32 124.86,83.81 116.87,83.81 116.75,83.93 116.75,85.96 116.87,86.09 125.38,86.09
P3V3S on TOP: 314.08,47.43 313.78,48.61 312.96,49.52 311.39,50.58 310.69,50.91 309.94,51.01 308.39,51.01 308.39,51.01 288.99,51.01 288.7,51.29 288.7,51.8 289.59,51.8 289.85,52.06 312.07,52.06 315.12,49.01 315.12,40.37 315.42,40.07 317.35,40.07 317.35,39.3 317.15,39.1 315.37,39.1 315.12,38.85 315.12,37.07 314.87,36.82 314.23,36.82 314.08,36.97
P3V3S on TOP: 287.94,83.68 290.74,83.68 290.99,83.93 290.99,85.2 291.37,85.58 292.51,85.58 293.02,86.09 293.91,86.09 294.29,85.71 294.29,80.88 288.45,80.88 287.94,81.39 287.94,82.66 287.69,82.92 287.69,83.42
P3V3S on L4: outline of 156 points within 94.01,59.04 289.85,120.76 ; 1 cut-out
P3V3S_DP on TOP: 324.14,23.99 323.37,23.23 317.02,23.23 316.64,23.61 316.64,24.88 317.02,25.26 321.85,25.26 322.36,25.77 322.36,38.85 321.98,39.23 319.18,39.23 318.93,39.48 318.93,40.12 320.07,40.12 320.9,40.94 323.31,40.94 324.14,40.12
P3V3S_SSD on TOP: 293.4,89.27 293.4,87.23 293.78,86.85 293.78,86.6 292.77,86.6 292.26,86.09 291.24,86.09 290.48,86.85 290.48,90.92 291.75,92.19 293.91,92.19 294.16,91.93 294.16,90.03
P3V3S_SSD on BOTTOM: 295.43,84.19 294.16,84.19 292.77,85.58 292.77,92.06 293.15,92.44 294.93,92.44 295.31,92.06 295.31,88.76 295.59,88.48 297.39,88.48 297.39,88.12 295.69,88.12 295.69,87.97 297.39,87.97 297.39,87.64 295.71,87.64 295.71,87.46 297.39,87.46 297.39,87.13 295.76,87.13 295.76,86.95 297.39,86.95 297.39,86.62 295.59,86.62 295.43,86.47
P3V3S_SSD on BOTTOM: 297.21,103.11 297.72,102.6 297.72,101.33 297.52,101.13 295.74,101.13 293.91,99.3 293.53,99.3 293.4,99.43 293.4,100.82 293.78,101.2 293.78,101.71 295.18,103.11 ; 3 cut-outs
P3V3S_VCC_READER on BOTTOM: 297.09,64.88 295.82,63.61 295.82,63.23 297.72,63.23 297.97,63.49 298.99,63.49 299.12,63.61 299.12,64.5 298.74,64.88
P5V0A on BOTTOM (solid shape): 311.18,115.68 311.18,114.29 311.06,114.16 309.66,114.16 309.4,114.41 309.4,115.68 309.66,115.94 310.93,115.94
P5V0A on L3 (solid shape): 311.18,115.81 311.18,114.41 310.93,114.16 309.79,114.16 309.4,114.54 309.4,115.81 309.66,116.06 310.93,116.06
P5V0A on L5 (solid shape): 311.18,115.81 311.18,114.41 310.93,114.16 309.79,114.16 309.4,114.54 309.4,115.81 309.66,116.06 310.93,116.06
P5V0A on L6 (solid shape): 311.18,115.68 311.18,114.41 310.93,114.16 309.66,114.16 309.4,114.41 309.4,115.68 309.66,115.94 310.93,115.94
P5V0A on TOP: 305.85,113.27 305.37,113.75 305.37,115.71 306.38,115.71 306.48,115.81 309.66,115.81 309.79,115.94 311.06,115.94 311.44,115.56 311.44,114.16 310.55,113.27
P5V0A on TOP: 307.63,83.3 306.61,83.3 306.61,84.82 306.1,85.33 306.1,86.47 306.36,86.73 307.5,86.73 308.01,86.22 308.52,86.22 308.64,86.09 308.64,85.2 308.39,84.95 307.75,84.95 307.63,84.82
P5V0A on BOTTOM: 321.82,41.06 323.55,41.06 323.88,41.39 325.79,41.39 326.17,41.01 326.17,39.86 325.15,38.85 323.63,38.85 323.63,39.74 323.4,39.96 321.82,39.96
P5V0A on L4: 314.74,1.89 314.74,11.8 314.06,12.48 314.06,48.47 311.49,51.04 309.4,51.04 309.4,61.33 309.02,61.71 309.02,71.87 309.4,72.25 309.4,75.68 307.88,77.2 307.88,81.52 304.96,84.44 304.96,87.11 303.69,88.38 303.69,100.06 304.32,100.7 304.32,112.89 307.5,116.06 310.93,116.06 311.44,115.56 311.44,112.76 318.8,105.4 318.8,104.89 317.79,103.87 317.15,103.87 314.87,101.59 314.87,97.78 317.28,95.36 317.28,81.77 316.92,81.42 316.92,42.76 318.55,41.13 321.47,41.13 321.85,40.75 325.28,40.75 325.28,40.75 326.04,40.75 326.3,40.5 326.3,39.61 326.09,39.41 325.71,39.41 324.9,38.59 324.9,37.32 323.5,35.93 323.5,23.61 322.99,23.1 317.41,23.1 316.26,21.96 316.26,16.24 319.18,13.32 320.45,13.32 322.74,11.03 322.74,1.89
P5V0A_USB2 on TOP (solid shape): 315.12,72.88 315.12,72.5 315.37,72.25 316.26,72.25 316.77,71.74 316.77,70.09 316.39,69.71 315.63,69.71 313.47,71.87 313.47,73.01 313.6,73.14 314.87,73.14
P5V0A_USB2 on TOP: 306.58,78.29 308.31,78.29 308.77,78.75 308.77,80.63 308.52,80.88 306.86,80.88 306.58,80.6
P5V0A_USB2 on BOTTOM: 314.1,64.25 314.1,69.2 312.96,70.34 312.96,74.41 308.64,78.73 307.12,78.73 306.48,79.36 306.48,81.39 306.99,81.9 309.66,81.9 315.5,76.06 315.5,72.5 316.9,71.11 316.9,67.3 317.41,66.79 319.06,66.79 319.44,66.41 319.44,65.01 319.44,65 319.44,63.99 319.44,63.99 319.06,63.61 314.74,63.61
P5V0A_USB2 on L6: 314.87,71.23 316.52,71.23 316.9,70.85 316.9,68.31 317.41,67.8 318.17,67.8 319.44,66.53 319.44,65.01 319.44,65 319.44,63.99 319.44,63.99 319.06,63.61 316.26,63.61 314.48,65.39 314.48,70.85
P5V0A_USB3 on BOTTOM: 318.29,39.99 316.77,39.99 316.52,39.74 316.52,38.72 316.26,38.47 316.26,36.43 316.14,36.31 314.36,36.31 314.1,36.56 314.1,47.36 316.39,49.64 317.91,49.64 319.44,48.11 319.44,45.2 319.06,44.82 317.53,44.82 317.15,44.44 317.15,42.15 317.28,42.02 318.04,42.02 318.29,41.77
P5V0A_USB_CHARGE on TOP (solid shape): 39.66,84.57 39.66,80 39.15,79.49 37.88,79.49 37.62,79.74 37.62,84.57 37.88,84.82 39.4,84.82
P5V0A_USB_CHARGE on BOTTOM: 41.31,83.17 41.31,83.17 41.05,83.42 37.88,83.42 37.62,83.17 37.62,79.87 38.01,79.49 39.02,79.49 39.4,79.87 39.4,80.88 40.04,81.52 41.31,81.52 41.31,81.52
P5V0A_USB_CHARGE on L3: 40.02,50.6 39.93,51.17 39.66,51.68 39.66,59.55 37.5,61.71 37.5,63.1 37.75,63.36 40.67,63.36 43.47,60.56 43.47,41.26 42.58,40.37 42.07,40.37 41.31,39.61 40.67,39.61 39.48,40.8 39.48,49.34 40.02,49.88
P5V0A_USB_CHARGE on L4: 42.83,44.56 40.55,44.56 39.48,45.63 39.48,48.75 39.66,48.75 39.66,59.55 37.5,61.71 37.5,63.1 37.75,63.36 40.93,63.36 41.31,63.74 41.31,71.61 40.93,71.99 36.48,71.99 36.1,72.38 36.1,82.66 36.35,82.92 39.28,82.92 39.53,82.66 39.53,79.36 41.31,77.58 43.47,77.58 43.47,45.2
P5V0A_USB_CHARGE on L5: 39.53,82.66 39.53,78.73 39.02,78.22 39.02,76.31 40.04,75.3 40.04,71.99 41.18,70.85 41.18,61.71 40.67,61.2 38.01,61.2 36.1,63.1 36.1,75.17 35.34,75.93 35.34,78.6 35.72,78.98 35.85,78.98 36.1,79.23 36.1,82.79 36.35,83.04 39.15,83.04
P5V0DS on TOP (solid shape): 304.96,116.95 304.96,113.27 303,111.31 298.79,111.31 298.79,113.47 298.36,113.9 298.36,115.05 299.24,115.94 299.24,116.7 299.63,117.08 304.83,117.08
P5V0DS on TOP (solid shape): 252.25,84.31 252.25,83.55 253.27,82.54 253.27,81.65 253.14,81.52 252.13,81.52 251.75,81.9 251.75,83.17 251.24,83.68 251.24,84.31 251.49,84.57 252,84.57
P5V0DS on BOTTOM (solid shape): 301.91,116.44 301.91,113.65 301.53,113.27 298.99,113.27 298.36,113.9 298.36,116.44 298.74,116.83 301.53,116.83
P5V0DS on L3 (solid shape): 301.91,116.44 301.91,113.65 301.53,113.27 299.12,113.27 298.36,114.03 298.36,115.05 300.13,116.83 301.53,116.83
P5V0DS on L5 (solid shape): 301.91,116.44 301.91,113.65 301.53,113.27 298.99,113.27 298.36,113.9 298.36,115.56 299.63,116.83 301.53,116.83
P5V0DS on L6 (solid shape): 301.91,116.44 301.91,113.9 301.28,113.27 298.99,113.27 298.36,113.9 298.36,115.56 299.63,116.83 301.53,116.83
P5V0DS on BOTTOM: 44.74,82.03 47.78,82.03 48.04,82.28 48.04,83.3 47.78,83.55 44.74,83.55 43.59,82.41 43.59,81.52 44.23,81.52
P5V0DS on BOTTOM: 229.49,159.3 228.78,160.01 226.24,160.01 225.97,160.29 225.97,162.04 226.22,162.29 231.05,162.29 231.3,162.04 231.3,159.88 230.72,159.3
P5V0DS on L4: outline of 151 points within 39.78,77.81 325.91,163.43
P5V0S on BOTTOM (solid shape): 302.29,110.98 302.29,109.46 302.04,109.21 300.26,109.21 300.01,109.46 300.01,110.98 300.26,111.24 302.04,111.24
P5V0S on BOTTOM (solid shape): 99.85,83.3 101,83.3 101.38,82.92 101.38,81.65 101.12,81.39 98.33,81.39 98.08,81.65 98.08,83.42 98.46,83.81 99.35,83.81
P5V0S on L3 (solid shape): 302.17,110.73 302.17,109.33 301.91,109.08 300.39,109.08 300.01,109.46 300.01,110.73 300.26,110.98 301.91,110.98
P5V0S on L5 (solid shape): 302.29,110.6 302.29,109.33 302.04,109.08 300.39,109.08 300.26,109.21 300.26,110.6 300.51,110.86 302.04,110.86
P5V0S on L6 (solid shape): 302.17,110.73 302.17,109.33 301.91,109.08 300.39,109.08 300.13,109.33 300.13,110.6 300.39,110.86 302.04,110.86
P5V0S on TOP: 301.91,74.79 302.17,74.53 302.17,72.12 301.78,71.74 301.78,70.47 301.66,70.34 300.13,70.34 300.01,70.47 300.01,74.53 300.26,74.79
P5V0S on TOP: 303.18,110.6 302.8,110.98 300.26,110.98 300.01,110.73 300.01,108.82 300.69,108.14 302.8,108.14 303.18,108.52
P5V0S on L4: outline of 92 points within 94.01,51.01 309.15,113.9 ; 3 cut-outs
P5V0S_AUDIO_AVDD on TOP: 304.76,72.93 306.46,72.93 306.61,72.78 306.61,71.74 306.23,71.36 305.98,71.36 305.72,71.61 304.83,71.61 304.71,71.74 304.71,72.88
P5V0S_AUDIO_AVDD on TOP: 303.05,68.82 300.51,68.82 300.39,68.95 300.39,69.96 300.51,70.09 303.94,70.09 304.58,69.45 304.58,68.18 304.32,67.93 303.94,67.93
P5V0S_AUDIO_AVDD on BOTTOM: 304.58,67.17 303.18,68.57 303.18,70.72 309.02,76.57 309.79,76.57 311.94,74.41 311.94,73.77 309.28,71.11 309.28,69.45 310.42,68.31 310.42,63.1 309.79,62.47 309.79,57.77 311.44,56.12 311.44,54.6 311.06,54.21 305.21,54.21 304.83,54.6 304.83,56.75 305.98,57.9 305.98,62.22 304.58,63.61 ; 3 cut-outs
P5V0S_CRTVDD on BOTTOM: 40.29,73.14 39.91,72.76 38.01,72.76 38.01,74.15 37.75,74.41 37.24,74.41 36.86,74.03 36.1,74.03 36.1,75.8 36.48,76.19 39.78,76.19 40.29,75.68
P5V0S_HDD on BOTTOM: 97.48,80.32 97.2,80.04 94.2,80.04 93.89,80.34 93.89,81.66 95.16,82.92 95.16,84.44 96.81,86.09 96.81,86.73 97.06,86.98 98.2,86.98 98.33,87.11 100.24,87.11 101.25,86.09 101.25,84.31 101,84.06 100.24,84.06 99.85,84.44 98.58,84.44 98.46,84.31 98.46,84.19 97.7,83.42 97.7,81.36 97.48,81.14
PVBAT on TOP (solid shape): 245.9,84.57 245.02,83.68 245.02,80.38 242.09,77.46 240.44,77.46 239.94,77.96 239.94,79.23 240.7,80 241.08,80 242.48,81.39 242.48,84.19 243.36,85.08 243.36,89.14 245.9,89.14
PVBAT on BOTTOM (solid shape): 146.84,160.01 148.11,160.01 148.11,158.35 147.86,158.1 145.57,158.1 145.32,158.35 145.32,160.26 145.57,160.51 146.34,160.51
PVBAT on BOTTOM (solid shape): 270.42,117.59 270.42,116.57 270.03,116.19 270.03,115.05 269.78,114.79 269.65,114.79 269.02,115.43 268.64,115.43 267.75,116.32 267.75,118.73 268,118.98 269.02,118.98
PVBAT on TOP: outline of 110 points within 111.92,101.2 286.67,163.18 ; 6 cut-outs
PVBAT on BOTTOM: 242.1,74.79 241.59,75.3 239.81,75.3 239.43,75.68 239.43,75.68 239.43,77.07 239.94,77.58 239.94,79.36 240.19,79.61 243.24,79.61 243.49,79.36 243.49,75.17 243.11,74.79
PVBAT on BOTTOM: 209.84,158.1 212.5,158.1 212.88,157.72 212.88,156.07 212.63,155.81 211.61,155.81 211.11,156.32 209.84,156.32 209.58,156.58 209.58,157.85
PVBAT on BOTTOM: 123.22,103.87 123.6,103.49 123.6,102.73 122.97,102.09 122.97,101.08 120.3,101.08 120.05,100.82 120.05,100.06 119.92,99.93 119.54,99.93 119.03,99.43 118.4,99.43 117.89,99.93 117.89,102.98 118.77,103.87
PVBAT on BOTTOM: 249.84,149.08 250.12,148.8 250.12,147.2 249.59,146.67 246.92,146.67 246.79,146.8 246.79,147.31 247.17,147.69 247.17,149.08 247.43,149.34 248.95,149.34 249.21,149.08
PVBAT_CHG on BOTTOM (solid shape): 272.7,121.27 272.7,119.62 273.34,118.98 273.97,118.98 274.1,118.86 274.1,115.68 273.97,115.56 271.69,115.56 271.05,114.92 270.54,114.92 270.54,115.56 271.05,116.06 271.05,117.33 268.76,119.62 268.76,121.14 269.02,121.4 272.57,121.4
PVBAT_CHG on TOP: 272.19,119.37 273.21,119.37 273.46,119.11 273.46,117.21 273.21,116.95 272.45,116.95 271.94,117.46 271.94,119.11
PVBAT_CPU on BOTTOM: 242.98,73.9 242.98,70.6 241.59,69.2 241.59,67.55 241.33,67.3 239.55,67.3 239.43,67.17 239.43,67.04 239.3,66.91 238.8,66.91 238.67,67.05 238.67,74.28 239.05,74.66 241.08,74.66 241.59,74.15 242.73,74.15
Net_4360 on BOTTOM (solid shape): outline of 162 points within 305.42,165.39 310.7,167.29
Net_4361 on TOP (solid shape): outline of 162 points within 305.42,165.39 310.7,167.29
Net_4362 on BOTTOM (solid shape): outline of 162 points within 13.44,-85.18 18.73,-83.28
Net_4363 on TOP (solid shape): outline of 162 points within 13.44,-85.18 18.73,-83.28
Net_4364 on BOTTOM: 50.2,78.01 53.7,81.5 57.2,78.01 57.2,77.81 50.21,77.81 50.21,78.01
PVADPTR on TOP: 300.51,141.21 302.04,142.73 303.94,142.73 303.96,142.72 304.12,142.89 305.7,142.89 305.7,140.24 306.64,139.3 313.6,139.3 316.14,136.76 316.14,134.1 317.66,132.57 322.46,132.57 323.35,131.68 324.9,131.68 325.28,131.3 325.28,129.91 324.9,129.53 322.74,129.53 321.47,128.26 313.98,128.26 313.09,129.14 312.45,129.14 310.55,131.05 310.55,132.19 310.17,132.57 309.28,132.57 307.37,134.48 301.28,134.48 300.9,134.86 300.9,137.91 300.26,138.54 297.97,138.54 297.47,139.05 297.47,141.21
PVCORE on TOP: 193.71,62.22 193.26,62.22 192.63,62.85 192.63,72.06 191.42,73.26 189.14,73.26 188.75,73.65 188.75,74.92 187.87,75.8 187.23,75.8 186.6,76.44 186.6,79.61 186.85,79.87 190.02,79.87 191.17,81.01 194.22,81.01 194.34,80.88 194.34,78.34 194.6,78.09 196.76,78.09 197.01,78.34 197.01,79.61 197.26,79.87 198.79,79.87 199.04,79.61 199.04,78.22 199.3,77.96 201.58,77.96 202.09,78.47 207.3,78.47 208.19,77.58 208.19,77.33 210.47,75.04 210.47,70.47 212.63,68.31 212.63,64.12 214.54,62.22 217.33,62.22 219.23,64.12 219.23,67.93 219.62,68.31 225.33,68.31 225.58,68.06 225.58,61.2 225.97,60.82 225.97,55.36 225.84,55.23 224.31,55.23 224.06,54.98 224.06,54.47 222.16,52.56 201.84,52.56 198.15,56.25 198.15,57.77
PVCORE on BOTTOM: 221.77,51.93 196.75,51.93 192.95,55.74 191.93,55.74 191.42,56.25 191.42,68.82 191.68,69.07 193.58,69.07 193.71,68.95 193.71,62.72 193.96,62.47 196.25,62.47 196.5,62.72 196.5,68.95 196.63,69.07 198.41,69.07 198.53,68.95 198.53,62.72 198.79,62.47 201.07,62.47 201.33,62.72 201.33,68.95 201.45,69.07 203.23,69.07 203.36,68.95 203.36,62.72 203.61,62.47 205.9,62.47 206.15,62.72 206.15,68.18 206.53,68.57 208.06,68.57 208.19,68.44 208.19,62.85 208.57,62.47 210.98,62.47 211.49,62.98 213.01,62.98 213.9,62.09 217.33,62.09 219.36,64.12 219.36,68.06 220.76,69.45 228.38,69.45 228.51,69.33 228.51,68.22 228.29,68 226.13,68 226.13,67.44 228.25,67.44 228.25,66.15 228,65.9 226.85,65.9 226.35,65.39 226.35,64.37 226.98,63.74 226.98,61.07 226.85,60.95 223.3,60.95 222.41,60.06 222.41,52.57
PVCORE on L4: 188.63,79.61 189.77,80.76 189.77,89.39 190,89.62 203,89.62 203.11,89.52 208.57,89.52 209.58,88.5 212.12,88.5 212.73,87.89 213.24,87.89 213.52,87.62 219.11,87.62 219.62,88.12 220,88.12 220.12,88 220.12,80 220.5,79.61 224.82,79.61 225.08,79.36 225.08,65.01 224.44,64.37 220.25,64.37 219.62,63.74 213.14,63.74 212.12,62.72 191.93,62.72 191.17,63.49 191.17,70.6 187.87,73.9 187.87,74.79 185.07,77.58 185.07,79.11 185.58,79.61
PVPACK on TOP (solid shape): 288.2,145.27 288.2,140.45 288.07,140.32 287.31,140.32 286.93,140.7 279.69,140.7 276.89,143.5 276.89,145.4 277.27,145.78 287.69,145.78
PVPACK on BOTTOM (solid shape): 132.75,111.62 132.75,109.21 132.49,108.95 129.45,108.95 129.19,109.21 129.19,111.62 129.45,111.87 132.49,111.87
PVPACK on L3 (solid shape): 132.75,111.62 132.75,109.21 132.49,108.95 129.45,108.95 129.19,109.21 129.19,111.62 129.45,111.87 132.49,111.87
PVPACK on L6 (solid shape): 132.75,111.62 132.75,109.21 132.49,108.95 129.45,108.95 129.19,109.2 129.19,110.1 129.19,110.1 129.19,111.62 129.45,111.87 132.49,111.87
PVPACK on TOP: 134.46,78.79 132.11,81.14 132.11,83.04 130.46,84.69 130.46,103.36 129.19,104.63 129.19,111.49 129.57,111.87 133.89,111.87 134.27,111.49 134.27,108.19 137.83,104.63 137.83,88.76 139.99,86.6 139.99,78.98 142.15,76.82 142.15,72.02 145.35,68.82 151.92,68.82 153.32,67.42 153.32,60.69 152.81,60.18 150.15,60.18 149.64,60.69 149.64,61.58 149,62.22 138.21,62.22 137.32,63.1 137.32,67.93 137.07,68.18 137.07,68.69 137.32,68.95 137.32,71.99 134.46,74.85
PVPACK on BOTTOM: 281.46,137.65 278.29,134.48 274.73,134.48 274.73,135.49 273.72,135.49 273.72,134.48 272.57,134.48 272.32,134.73 272.32,141.46 276.64,145.78 280.7,145.78 281.46,145.02
PVPACK on L5: 126.52,107.81 119.54,114.79 119.54,124.57 111.92,132.19 111.92,155.81 117.63,161.53 139.22,161.53 140.62,160.13 154.85,160.13 156.37,161.66 172.24,161.66 176.82,157.08 181.64,157.08 185.07,160.51 187.36,160.51 189.52,162.67 251.87,162.67 255.3,159.24 255.3,154.54 257.87,151.98 279.94,151.98 280.3,151.62 280.32,151.62 280.32,143.88 279.81,143.37 277.15,143.37 274.73,145.78 254.85,145.78 249.97,150.66 249.97,156.32 248.7,157.59 234.35,157.59 232.82,156.07 226.35,156.07 224.82,157.59 203.61,157.59 202.6,156.58 192.69,156.58 189.39,153.27 185.33,153.27 182.4,150.35 172.5,150.35 169.83,153.02 138.59,153.02 136.18,155.43 122.59,155.43 118.9,151.75 118.9,132.57 124.62,126.86 124.62,118.86 130.59,112.89 132.37,112.89 132.75,112.51 132.75,108.32 132.24,107.81 ; 1 cut-out
PVSIM on TOP: 256.95,69.45 256.95,56.75 255.05,54.85 254.16,54.85 253.91,55.1 253.91,57.26 254.67,58.02 254.67,72.25 255.05,72.63 257.21,72.63 257.59,72.25 257.59,70.09
PVSIM on BOTTOM: 258.35,79.74 258.73,79.74 259.14,79.33 259.49,79.33 259.49,78.6 259.37,78.47 258.22,78.47 257.97,78.22 257.97,77.58 257.72,77.33 257.08,77.33 256.83,77.07 256.83,76.06 257.21,75.68 257.21,74.41 257.08,74.28 254.03,74.28 253.91,74.15 253.91,72.63 254.03,72.5 256.95,72.5 257.59,71.87 257.59,69.96 256.95,69.33 256.95,69.07 256.7,68.82 256.06,68.82 255.81,69.07 255.81,70.72 255.68,70.85 253.02,70.85 252,71.87 252,74.28 250.98,75.3 250.98,76.95 253.14,79.11 257.72,79.11
PVSIM on BOTTOM: 253.55,58.18 256.04,58.18 256.45,57.77 256.45,56.37 255.94,55.87 255.94,55.1 255.68,54.85 254.16,54.85 253.91,55.1 253.91,56.5 253.14,57.26 253.14,57.77 ; 2 cut-outs
SD_MMC_CD# on BOTTOM (solid shape): 299.63,53.2 299.63,52.56 299.5,52.44 297.09,52.44 296.96,52.56 296.96,53.2 297.09,53.33 299.5,53.33
SD_MMC_CLK on BOTTOM: 297.47,61.07 297.59,61.07 297.85,60.82 298.99,60.82 299.12,60.95 299.12,62.22 298.99,62.34 297.47,62.34 296.83,61.71
SD_MMC_DATA0 on BOTTOM (solid shape): 299.37,57.26 299.37,56.12 299.12,55.87 297.47,55.87 296.2,57.14 296.2,57.39 296.32,57.52 299.12,57.52
SD_MMC_DATA1 on BOTTOM (solid shape): 297.34,55.61 299.12,55.61 299.37,55.36 299.37,54.72 299.12,54.47 297.47,54.47 297.34,54.6 297.34,54.72 297.09,54.98 296.96,54.98 295.69,56.25 295.69,56.5 295.82,56.63 296.32,56.63
