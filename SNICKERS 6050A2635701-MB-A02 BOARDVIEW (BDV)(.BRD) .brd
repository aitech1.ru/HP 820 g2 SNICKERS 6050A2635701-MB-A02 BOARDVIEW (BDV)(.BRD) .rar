# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Library data of the parts (continued)
R4550 R4588 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet21
R4553 = RSC_0402: part number: RSC_0402-470_5%_2,60130B4710ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-470-5%-1/16W-0402-TAP; signal model: R2_60130B4710ZT_470_5%_2; room: Sheet21
R4568 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet30
R4569 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.55MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet30
R4571 R4770 R4782 R4924 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet24
R4572 R4929 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet24
R4573 R4576 R4578 R4781 = RSC_0402: part number: RSC_0402-8.2K_5%_2,6013A0050801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-8.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0050801_8_2K_5%_2; room: Sheet24
R4574 R4575 R4577 = RSC_0402: part number: RSC_0402-8.2K_5%_2_DY,6013A0050801_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-8.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0050801_DY_8_2K_5%_2_DY; room: Sheet24
R4590 = RSC_0402: part number: RSC_0402-150_5%_2,60130B15100Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-150-5%-1/16W-0402-TAP; signal model: R2_60130B15100Y_150_5%_2; room: Sheet30
R4593 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet30
R4700 R4734 R4778 R4825 R4857 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet26
R4705 R4707 R4711 R4712 R4715 R4775 R4791 R4798 R4800 R4801 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet28
R4706 R4720 R4721 R4726 R4730 R4751 R4760-R4762 R4767 R4769 R4806 R4809 R4814 R4880 R4919 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet23
R4708 R4709 R4714 R4717 R4724 R4725 R4728 R4731 R4735 R4736 R4738 R4741 R4745 R4747 R4749 R4750 R4752-R4755 R4757 R4763 R4764 R4771 R4780 R4785 R4803-R4805 R4810 R4813 R4859 R4906-R4909 R4911 R4912 R4914-R4918 R4960 R4961 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet23
R4713 R4743 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet22
R4718 R4723 R4790 R4799 R4802 R4815 R4860 R4925 R4936 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet22
R4722 R4835 R4836 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet22
R4727 = RSC_0402: part number: RSC_0402-8.2K_5%_2,6013A0050801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-8.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0050801_8_2K_5%_2; room: Sheet22
R4729 = RSC_0402: part number: RSC_0402-200K_5%_2,60130B20400Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200K-5%-1/16W-0402-TAP; signal model: R2_60130B20400Y_200K_5%_2; room: Sheet23
R4732 R4733 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet23
R4737 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet26
R4742 = RSC_0402: part number: RSC_0402-330K_5%_2,60130B33400Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-330K-5%-1/16W-0402-TAP; signal model: R2_60130B33400Z_330K_5%_2; room: Sheet22
R4744 R4839 R4840 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet22
R4746 = RSC_0402: part number: RSC_0402-100K_5%_2_DY,60130B1040ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_DY_100K_5%_2_DY; room: Sheet22
R4748 = RSC_0402: part number: RSC_0402-49.9_1%_2,6013A0076901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-49.9-1%-1/16W-0402-TAP; signal model: R2_6013A0076901_49_9_1%_2; room: Sheet23
R4756 = RSC_0402: part number: RSC_0402-22.6_1%_2,6013A0078901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-22.6-1%-1/16W-0402-TAP; signal model: R2_6013A0078901_22_6_1%_2; room: Sheet26
R4758 R4759 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet24
R4765 R4816-R4818 R4863 R4899 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet27
R4774 R4996 R4997 = RSC_0402: part number: RSC_0402-22_5%_2,60130B2200ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-22-5%-1/16W-0402-TAP; signal model: R2_60130B2200ZT_22_5%_2; room: Sheet28
R4776 R4783 R4792 R4797 R4827 R4828 R4830 R4856 R4884 R4913 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet22
R4786-R4789 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet24
R4793-R4796 = RSC_0402: part number: RSC_0402-33_5%_2,60130B3300ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33-5%-1/16W-0402-TAP; signal model: R2_60130B3300ZT_33_5%_2; room: Sheet22
R4807 R4886 R4891 = RSC_0402: part number: RSC_0402-51_5%_2,60130B5100ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-51-5%-1/16W-0402-TAP; signal model: R2_60130B5100ZT_51_5%_2; room: Sheet27
R4808 = RSC_0402: part number: RSC_0402-51_5%_2_DY,60130B5100ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-51-5%-1/16W-0402-TAP; signal model: R2_60130B5100ZT_DY_51_5%_2_DY; room: Sheet27
R4811 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet26
R4812 = RSC_0402: part number: RSC_0402-3K_1%_2,6013A0067201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-3K-1%-1/16W-0402-TAP; signal model: R2_6013A0067201_3K_1%_2; room: Sheet26
R4820 = RSC_0402: part number: RSC_0402-43K_1%_2,6013A0117001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP-43K-1%-1/16W-0402-TAP; signal model: R2_6013A0117001_43K_1%_2; room: Sheet27
R4821 = RSC_0402: part number: RSC_0402-110_1%_2,6013A0087701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,110,1%,1/16W,0402,TR; signal model: R2_6013A0087701_110_1%_2; room: Sheet30
R4822 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet20
R4823 R4922 R4931 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet20
R4824 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet27
R4829 R4838 = RSC_0402: part number: RSC_0402-2.2K_5%_2_DY,6013A0049601_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_DY_2_2K_5%_2_DY; room: Sheet22
R4831 R4833 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet27
R4832 R4861 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet27
R4834 = RSC_0402: part number: RSC_0402-20K_5%_2,6013A0050701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-5%-1/16W-0402-TAP; signal model: R2_6013A0050701_20K_5%_2; room: Sheet27
R4841 = RSC_0402: part number: RSC_0402-8.2K_5%_2,6013A0050801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-8.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0050801_8_2K_5%_2; room: Sheet28
R4842 = RSC_0402: part number: RSC_0402-330K_5%_2,60130B33400Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-330K-5%-1/16W-0402-TAP; signal model: R2_60130B33400Z_330K_5%_2; room: Sheet27
R4845 = RSC_0402: part number: RSC_0402-33K_5%_2,60130B33300T,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33K-5%-1/16W-0402-TAP; signal model: R2_60130B33300T_33K_5%_2; room: Sheet27
R4850 R4855 R4875 R4877 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet29
R4852 = RSC_0402: part number: RSC_0402-3.01K_1%_2,6013A008810W,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-3.01K-1%-1/16-0402-TAP; signal model: R2_6013A008810W_3_01K_1%_2; room: Sheet27
R4858 = RSC_0603: part number: RSC_0603-0_5%_3,60130B00000Z,RSC_160X080X055_2,0.7MM,RSC_0603,0603,RES-CHIP-0-5%-1/10W-TAP; signal model: R2_60130B00000Z_0_5%_3; room: Sheet29
R4862 = RSC_0402: part number: RSC_0402-10M_5%_2,60130B10600Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10M-5%-1/16W-0402-TAP; signal model: R2_60130B10600Y_10M_5%_2; room: Sheet27
R4866 R4868 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet24
R4867 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet24
R4869 R4901 R4903 R4910 = RSC_0402: part number: RSC_0402-33_5%_2,60130B3300ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-33-5%-1/16W-0402-TAP; signal model: R2_60130B3300ZT_33_5%_2; room: Sheet27
R4874 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet27
R4876 = RSC_0402: part number: RSC_0402-330K_5%_2_DY,60130B33400Z_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-330K-5%-1/16W-0402-TAP; signal model: R2_60130B33400Z_DY_330K_5%_2_DY; room: Sheet27
R4892 = RSC_0402: part number: RSC_0402-3K_1%_2,6013A0067201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-3K-1%-1/16W-0402-TAP; signal model: R2_6013A0067201_3K_1%_2; room: Sheet28
R4898 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet28
R4900 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet29
R4904 = RSC_0402: part number: RSC_0402-680_5%_2,6013A0028301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-680-5%-1/16W-0402-TAP; signal model: R2_6013A0028301_680_5%_2; room: Sheet29
R4921 R4926 R4939 = RSC_0402: part number: RSC_0402-1K_5%_2_DY,60130B1020ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_DY_1K_5%_2_DY; room: Sheet20
R4923 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet20
R4934 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet23
R4937 R4938 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet20
R5032 R5039 R5044 = RSC_0402: part number: RSC_0402-2.2K_5%_2,6013A0049601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.2K-5%-1/16W-0402-TAP; signal model: R2_6013A0049601_2_2K_5%_2; room: Sheet19
R5049 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet19
R5301-R5314 = RSC_0402: part number: RSC_0402-4.7K_5%_2_DY,60130B4720ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_DY_4_7K_5%_2_DY; room: Sheet34
R5315 = RSC_0402: part number: RSC_0402-4.99K_1%_2,6013A0015201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.99K-1%-1/16W-0402-TAP; signal model: R2_6013A0015201_4_99K_1%_2; room: Sheet34
R5316 R5319 = RSC_0402: part number: RSC_0402-100K_5%_2_DY,60130B1040ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_DY_100K_5%_2_DY; room: Sheet34
R5317 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet34
R5318 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet34
R5320 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet34; signal model: R2_60130B1030ZT_10K_5%_2
R5403 R5407 R5418 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet35
R5409 R5410 R5419 R5421 = RSC_0402: part number: RSC_0402-4.7K_5%_2_DY,60130B4720ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_DY_4_7K_5%_2_DY; room: Sheet35
R5415 = RSC_0402: part number: RSC_0402-4.99K_1%_2,6013A0015201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.99K-1%-1/16W-0402-TAP; signal model: R2_6013A0015201_4_99K_1%_2; room: Sheet35
R5416 R5417 R5424 R5425 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet35
R5420 R5422 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet35
R5423 R5426 = RSC_0402: part number: RSC_0402-100K_5%_2_DY,60130B1040ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_DY_100K_5%_2_DY; room: Sheet35
R6000 = RSC_1206_4PIN: part number: RSC_1206_4PIN-0.01_1%_6,6013B0162701,RSC_320X160X080_4,0.95MM,RSC_1206_4PIN,RES-M/F,0.01,1%,1W,1206,TR; signal model: R4_6013B0162701_0_01_1%_6; room: Sheet5
R6001 = RSC_1206_4PIN: part number: RSC_1206_4PIN-0.02_1%_6,6013B0181301,RSC_320X160X160_4,1.6MM,RSC_1206_4PIN,RESISTOR-M/F,0.02,1%,1W,1206,TR; signal model: R4_6013B0181301_0_02_1%_6; room: Sheet5
R6005 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet5
R6015 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet5
R6016 R6017 = RSC_0402: part number: RSC_0402-220K_5%_2,6013A0076001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-220K-5%-1/16W-0402-TAP; signal model: R2_6013A0076001_220K_5%_2; room: Sheet5
R6018 R6028 = RSC_0402: part number: RSC_0402-4.3K_5%_2,60130B43200Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.3K-5%-1/16W-0402-TAP; signal model: R2_60130B43200Z_4_3K_5%_2; room: Sheet5
R6020 R6025 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.55MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet5
R6021 = RSC_0402: part number: RSC_0402-127K_1%,6013A008870F,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-127K-1%-1/16-0402-TAP; signal model: R2_6013A008870F_127K_1%; room: Sheet5
R6022 = RSC_0402: part number: RSC_0402-1M_5%_2,60130B10500Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_1M_5%_2; room: Sheet5
R6023 = RSC_0402: part number: RSC_0402-20K_1%_2,6013A0015301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-1%-1/16W-0402-TAP; signal model: R2_6013A0015301_20K_1%_2; room: Sheet5
R6024 = RSC_0402: part number: RSC_0402-22K_5%_2,60130B22300Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-22K-5%-1/16W-0402-TAP; signal model: R2_60130B22300Y_22K_5%_2; room: Sheet5
R6027 = RSC_0805: part number: RSC_0805-10_5%_5,60130BA1003S,RSC_200X125X115_2,1.3MM,RSC_0805,0805,RES-CHIP-10-5%-1/8W-0805-TAP; signal model: R2_60130BA1003S_10_5%_5; room: Sheet5
R6029 = RSC_0402: part number: RSC_0402-18.2K_1%_2,6013A0019501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-18.2K-1%-1/16W-0402-TAP; signal model: R2_6013A0019501_18_2K_1%_2; room: Sheet5
R6030 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet5
R6049 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet5
R6051 R6053 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet16
R6057 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet16
R6058 R6074 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet16
R6110 R6160 = RSC_0402: part number: RSC_0402-10K_5%_2_DY,60130B1030ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_DY_10K_5%_2_DY; room: Sheet7
R6115 R6165 = RSC_0603: part number: RSC_0603-2.2_5%_3,60130B2R200T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-2.2-5%-1/10W-0603-TAP; signal model: R2_60130B2R200T_2_2_5%_3; room: Sheet7
R6149 R6161 R6199 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.55MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet7
R6150 R6166 = RSC_0402: part number: RSC_0402-RSC_0402_DY,RSC_0402_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402_DY; signal model: R2_RSC_0402_DY_RSC_0402_DY; room: Sheet7
R6151 = RSC_0402: part number: RSC_0402-10K_1%_2_DY,60130B10029Z_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_DY_10K_1%_2_DY; room: Sheet7
R6167 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet7
R6200 = RSC_0402: part number: RSC_0402-14K_1%_2,6013A0088407,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-14K-1%-1/16-0402-TAP; signal model: R2_6013A0088407_14K_1%_2; room: Sheet9
R6201 = RSC_0402: part number: RSC_0402-20K_1%_2,6013A0015301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-1%-1/16W-0402-TAP; signal model: R2_6013A0015301_20K_1%_2; room: Sheet9
R6207 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.55MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet9
R6209 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet9
R6210 = RSC_0402: part number: RSC_0402-10_5%_2,60130B10000X,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10-5%-1/16W-0402-TAP; signal model: R2_60130B10000X_10_5%_2; room: Sheet9
R6211 = RSC_0402: part number: RSC_0402-127K_1%,6013A008870F,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-127K-1%-1/16-0402-TAP; signal model: R2_6013A008870F_127K_1%; room: Sheet9
R6215 = RSC_0603: part number: RSC_0603-2.2_5%_3,60130B2R200T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-2.2-5%-1/10W-0603-TAP; signal model: R2_60130B2R200T_2_2_5%_3; room: Sheet9
R6300 = RSC_0402: part number: RSC_0402-6.49K_1%_2,6013A0088303,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-6.49K-1%-1/16W-0402-TAP; signal model: R2_6013A0088303_6_49K_1%_2; room: Sheet10
R6301 = RSC_0402: part number: RSC_0402-20K_1%_2,6013A0015301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-1%-1/16W-0402-TAP; signal model: R2_6013A0015301_20K_1%_2; room: Sheet10
R6307 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.55MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet10
R6309 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet10
R6310 = RSC_0402: part number: RSC_0402-10_5%_2,60130B10000X,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10-5%-1/16W-0402-TAP; signal model: R2_60130B10000X_10_5%_2; room: Sheet10
R6311 = RSC_0402: part number: RSC_0402-88.7K_1%_2,6013A008860Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-88.7K-1%-1/16W-0402-TAP; signal model: R2_6013A008860Y_88_7K_1%_2; room: Sheet10
R6315 = RSC_0603: part number: RSC_0603-2.2_5%_3,60130B2R200T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-2.2-5%-1/10W-0603-TAP; signal model: R2_60130B2R200T_2_2_5%_3; room: Sheet10
R6350 = RSC_0402: part number: RSC_0402-15K_1%_2,6013A0017201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-15K-1%-1/16W-0402-TAP; signal model: R2_6013A0017201_15K_1%_2; room: Sheet11
R6351 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet11
R6450 = RSC_0402: part number: RSC_0402-11K_1%_2,6013B0095801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,11K,1%,1/16W,0402,TAP; signal model: R2_6013B0095801_11K_1%_2; room: Sheet12
R6451 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet12
R6612 R6652 R6659 = RSC_0402: part number: RSC_0402-RSC_0402_DY,RSC_0402_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402_DY; signal model: R2_RSC_0402_DY_RSC_0402_DY; room: Sheet13
R6615 = RSC_0603: part number: RSC_0603-2.2_5%_3,60130B2R200T,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RES-CHIP-2.2-5%-1/10W-0603-TAP; signal model: R2_60130B2R200T_2_2_5%_3; room: Sheet14
R6616 = RSC_0402: part number: RSC_0402-2.32K_1%,6013A008810G,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-2.32K-1%-1/16-0402-TAP; signal model: R2_6013A008810G_2_32K_1%; room: Sheet14
R6617 = RSC_THERMISTOR: part number: RSC_THERMISTOR-10K_1%_NTC,6013B0192901,RSC_100X050X055_2,0.55MM,RSC_THERMISTOR,,RESISTOR-THER,NTC,10K,0402.1%,100MW,SMD,TR; signal model: R2_6013B019290_10K_1%_NTC; room: Sheet14
R6618 = RSC_0402: part number: RSC_0402-3.01K_1%_2,6013A008810W,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-3.01K-1%-1/16-0402-TAP; signal model: R2_6013A008810W_3_01K_1%_2; room: Sheet14
R6619 = RSC_0402: part number: RSC_0402-18.7K_1%_2,6013A0017101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-18.7K-1%-1/16W-0402-TAP; signal model: R2_6013A0017101_18_7K_1%_2; room: Sheet14
R6633 R6656 R6658 = RSC_0402: part number: RSC_0402-10K_1%_2,60130B10029Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10K-1%-1/16W-0402-TAP; signal model: R2_60130B10029Z_10K_1%_2; room: Sheet13
R6640 = RSC_0402: part number: RSC_0402-110_1%_2,6013A0087701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,110,1%,1/16W,0402,TR; signal model: R2_6013A0087701_110_1%_2; room: Sheet13
R6641 = RSC_0402: part number: RSC_0402-54.9_1%_2,6013A0075001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-54.9-1%-1/16W-0402-TAP; signal model: R2_6013A0075001_54_9_1%_2; room: Sheet13
R6643 R6663 R6666 = RSC_0402: part number: RSC_0402-0_5%_2,60130B0000ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_0_5%_2; room: Sheet13
R6645 R6665 = RSC_0402: part number: RSC_0402-10_5%_2,60130B10000X,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-10-5%-1/16W-0402-TAP; signal model: R2_60130B10000X_10_5%_2; room: Sheet13
R6646 = RSC_0402: part number: RSC_0402-9.31K_1%_2,6013A008830J,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,9.31KOHM,1%,1/16W,0402,TAP; signal model: R2_6013A008830J_9_31K_1%_2; room: Sheet13
R6647 R6650 R6653 = RSC_0402: part number: RSC_0402-150K_1%_2,6013A0015901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-150K-1%-1/16W-0402-TAP; signal model: R2_6013A0015901_150K_1%_2; room: Sheet13
R6649 = RSC_0402: part number: RSC_0402-1.02M_1%_2,6013B0270501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,1.02M,1%,1/16W,0402,TR; signal model: R2_6013B0270501_1_02M_1%_2; room: Sheet13
R6651 = RSC_0402: part number: RSC_0402-2.05K_1%_2,6013A008810B,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP,2.05KOHM,1%,1/16W,0402,TAP; signal model: R2_6013A008810B_2_05K_1%_2; room: Sheet13
R6654 = RSC_0402: part number: RSC_0402-100K_1%_2,6013A0014701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-1%-1/16W-0402-TAP; signal model: R2_6013A0014701_100K_1%_2; room: Sheet13
R6655 = RSC_0402: part number: RSC_0402-432K_1%_2,6013A0013901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-432K-1%-1/16W-0402-TAP; signal model: R2_6013A0013901_432K_1%_2; room: Sheet13
R6657 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet13
R6660 = RSC_0402: part number: RSC_0402-39K_1%_2,6013A0085601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-39K-1%-1/16W-0402-TAP; signal model: R2_6013A0085601_39K_1%_2; room: Sheet13
R6661 = RSC_THERMISTOR: part number: RSC_THERMISTOR-100K_1%_NTC,6013B0171701,RSC_100X050X055_2,0.7MM,RSC_THERMISTOR,,RESISTOR-THER,NTC,100K,0402,1%,0.1A,0.1W,SMD,TR; signal model: R2_6013B0171701_100K_1%_NTC; room: Sheet13
R6902 = RSC_0402: part number: RSC_0402-220K_5%_2,6013A0076001,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-220K-5%-1/16W-0402-TAP; signal model: R2_6013A0076001_220K_5%_2; room: Sheet6
R6903 = RSC_0402: part number: RSC_0402-130K_1%_2,6013A0075701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-130K-1%-1/16W-0402-TAP; signal model: R2_6013A0075701_130K_1%_2; room: Sheet6
R6904 = RSC_0402: part number: RSC_0402-45.3K_1%_2,6013A0107901,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RESISTOR-CHIP-45.3K-1%-1/16W-0402-TAP; signal model: R2_6013A0107901_45_3K_1%_2; room: Sheet6
R6909 = RSC_0402: part number: RSC_0402-8.66K_1%_2,6013A008830F,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-8.66K-1%-1/16-0402-TAP; signal model: R2_6013A008830F_8_66K_1%_2; room: Sheet6
R6910 = RSC_0402: part number: RSC_0402-6.04K_1%_1/16W_2,6013A0077201,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-6.04K-1%-1/16W-0402-TAP; signal model: R2_6013A0077201_6_04K_1%_1_16W_2; room: Sheet6
R6913 = RSC_0402: part number: RSC_0402-46.4K_1%_2,6013A0088601,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-46.4K-1%-1/16-0402-TAP; signal model: R2_6013A0088601_46_4K_1%_2; room: Sheet8
R6914 R6935 = RSC_0402: part number: RSC_0402-47K_5%_2,60130B4730ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47K-5%-1/16W-0402-TAP; signal model: R2_60130B4730ZT_47K_5%_2; room: Sheet6
R6915 R6999 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet6
R6916 = RSC_0402: part number: RSC_0402-RSC_0402_DY,RSC_0402_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402_DY; signal model: R2_RSC_0402_DY_RSC_0402_DY; room: Sheet6
R6917 = RSC_0402: part number: RSC_0402-619_1%_2,6013A0023401,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-619-1%-1/16W-0402-TAP; signal model: R2_6013A0023401_619_1%_2; room: Sheet6
R6918 = RSC_0402: part number: RSC_0402-2.1K_1%_2,6013B0010101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,2.1K,1%,1/16W,0402,TR; signal model: R2_6013B0010101_2_1K_1%_2; room: Sheet6
R6930 = RSC_0402: part number: RSC_0402-86.6K_1%_2,6013A0079801,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-86.6K-1%-1/16W-0402-TAP; signal model: R2_6013A0079801_86_6K_1%_2; room: Sheet6
R6931 = RSC_0402: part number: RSC_0402-200K_1%_2,60130B20039Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200K-1%-1/16W-0402-TAP; signal model: R2_60130B20039Z_200K_1%_2; room: Sheet6
R6933 = RSC_0402: part number: RSC_0402-274K_1%_2,6013A0015501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-274K-1%-1/16W-0402-TAP; signal model: R2_6013A0015501_274K_1%_2; room: Sheet6
R6934 = RSC_0402: part number: RSC_0402-22K_5%_2,60130B22300Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-22K-5%-1/16W-0402-TAP; signal model: R2_60130B22300Y_22K_5%_2; room: Sheet6
R6936 = RSC_0402: part number: RSC_0402-3.24K_1%_2,6013A0088202,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-3.24K-1%-1/16W-0402-TAP; signal model: R2_6013A0088202_3_24K_1%_2; room: Sheet6
R6990 = RSC_0402: part number: RSC_0402-RSC_0402_DY,RSC_0402_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RSC_0402_DY; signal model: R2_RSC_0402_DY_RSC_0402_DY; room: Sheet8
R6994 R6996 = RSC_0402: part number: RSC_0402-49.9K_1%_2,6013A0014301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-49.9K-1%-1/16W-0402-TAP; signal model: R2_6013A0014301_49_9K_1%_2; room: Sheet8
R6995 = RSC_0402: part number: RSC_0402-576K_1%_2,6013A008890P,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-576K-1%-1/16-0402-TAP; signal model: R2_6013A008890P_576K_1%_2; room: Sheet8
R6998 = RSC_0402: part number: RSC_0402-13K_1%_2,6013A0088404,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-13K-1%-1/16W-0402-TAP; signal model: R2_6013A0088404_13K_1%_2; room: Sheet6
R7000 R7353 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet17
R7001 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet17
R7005 R7115 R7154 = RSC_0402: part number: RSC_0402-200K_5%_2,60130B20400Y,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-200K-5%-1/16W-0402-TAP; signal model: R2_60130B20400Y_200K_5%_2; room: Sheet15
R7010 R7012 R7019-R7021 R7112 R7113 R7116-R7119 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet15
R7017 R7350 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet17
R7023 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet15
R7100 = RSC_0402: part number: RSC_0402-100_5%_2,60130B1010ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100-5%-1/16W-0402-TAP; signal model: R2_60130B1010ZT_100_5%_2; room: Sheet15
R7101 R7151 = RSC_0402: part number: RSC_0402-470K_5%_2,60130B47400Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-470K-5%-1/16W-0402-TAP; signal model: R2_60130B47400Z_470K_5%_2; room: Sheet15
R7110 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet15
R7111 R7114 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet15
R7150 R7152 = RSC_0402: part number: RSC_0402-220_5%_2,60130B2210ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-220-5%-1/16W-0402-TAP; signal model: R2_60130B2210ZT_220_5%_2; room: Sheet15
R7153 = RSC_0402: part number: RSC_0402-22_5%_2,60130B2200ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-22-5%-1/16W-0402-TAP; signal model: R2_60130B2200ZT_22_5%_2; room: Sheet15
R7354 = RSC_0402: part number: RSC_0402-470K_5%_2,60130B47400Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-470K-5%-1/16W-0402-TAP; signal model: R2_60130B47400Z_470K_5%_2; room: Sheet17
R7355 = RSC_0402: part number: RSC_0402-47_5%_2,60130B4700ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-47-5%-1/16W-0402-TAP; signal model: R2_60130B4700ZT_47_5%_2; room: Sheet17
R7401 = RSC_0402: part number: RSC_0402-53.6K_1%_2,6013A0073101,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-53.6K-1%-1/16W-0402-TAP; signal model: R2_6013A0073101_53_6K_1%_2; room: Sheet18
R7404 = RSC_0402: part number: RSC_0402-20K_5%_2,6013A0050701,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-20K-5%-1/16W-0402-TAP; signal model: R2_6013A0050701_20K_5%_2; room: Sheet18
R7405 = RSC_0402: part number: RSC_0402-38.3K_1%_2,6013A008850M,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,38.3K,1%,1/16W,0402,TR; signal model: R2_6013A008850M_38_3K_1%_2; room: Sheet18
R7410 = RSC_0402: part number: RSC_0402-57.6K_1%_2,60130B57629Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-57.6K-1%-1/16W-0402-TAP; signal model: R2_60130B57629Z_57_6K_1%_2; room: Sheet18
R7412 = RSC_0402: part number: RSC_0402-31.6K_1%_2,6013A008850D,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-31.6K-1%-1/16W-0402-TAP; signal model: R2_6013A008850D_31_6K_1%_2; room: Sheet18
R7418 = RSC_0402: part number: RSC_0402-13.7K_1%_2,6013A0013501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-13.7K-1%-1/16W-0402-TAP; signal model: R2_6013A0013501_13_7K_1%_2; room: Sheet18
R7425 = RSC_0402: part number: RSC_0402-51.1K_1%_2,6013A0073501,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-51.1K-1%-1/16W-0402-TAP; signal model: R2_6013A0073501_51_1K_1%_2; room: Sheet18
R7426 = RSC_0402: part number: RSC_0402-16.2K_1%_2,6013A008840D,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-16.2K-1%-1/16W-0402-TAP; signal model: R2_6013A008840D_16_2K_1%_2; room: Sheet18
R7428 = RSC_0402: part number: RSC_0402-3.3K_1%_2,60130B33019Z,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-3.3K-1%-1/16W-0402-TAP; signal model: R2_60130B33019Z_3_3K_1%_2; room: Sheet18
R7600 = RSC_0603: part number: RSC_0603-RSC_0603_DY,RSC_0603_DY,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603_DY; signal model: R2_RSC_0603_DY_RSC_0603_DY; room: Sheet5
R7610 R7615 = RSC_0603: part number: RSC_0603-RSC_0603_DY,RSC_0603_DY,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603_DY; signal model: R2_RSC_0603_DY_RSC_0603_DY; room: Sheet7
R7620 = RSC_0603: part number: RSC_0603-RSC_0603_DY,RSC_0603_DY,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603_DY; signal model: R2_RSC_0603_DY_RSC_0603_DY; room: Sheet9
R7627 R7629 R7631 = RSC_0402: part number: RSC_0402-1M_5%_2_DY,60130B10500Y_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1M-5%-1/16W-0402-TAP; signal model: R2_60130B10500Y_DY_1M_5%_2_DY; room: Sheet61
R7630 = RSC_0603: part number: RSC_0603-RSC_0603_DY,RSC_0603_DY,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603_DY; signal model: R2_RSC_0603_DY_RSC_0603_DY; room: Sheet10
R7661 = RSC_0603: part number: RSC_0603-RSC_0603_DY,RSC_0603_DY,RSC_160X080X080_2,0.95MM,RSC_0603,0603,RSC_0603_DY; signal model: R2_RSC_0603_DY_RSC_0603_DY; room: Sheet14
R9000 = RSC_0402: part number: RSC_0402-4.7K_5%_2,60130B4720ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-4.7K-5%-1/16W-0402-TAP; signal model: R2_60130B4720ZT_4_7K_5%_2; room: Sheet58
R9001 = RSC_0402: part number: RSC_0402-470_5%_2,60130B4710ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-470-5%-1/16W-0402-TAP; signal model: R2_60130B4710ZT_470_5%_2; room: Sheet58
R9002 = RSC_0402: part number: RSC_0402-100K_5%_2,60130B1040ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_100K_5%_2; room: Sheet58
R9011 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_5,SHORT_0402_5,RSC_100X050X040_2_SHORT,0.55MM,RSC_SHORT,SHORT_0402_5; signal model: R2_short_0402_5_short_0402_5; room: Sheet58
R9012 R9038 R9045 R9047 R9049 = RSC_0402: part number: RSC_0402-0_5%_2_DY,60130B0000ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-0OHM-5%-1/16W-0402-TAP; signal model: R2_60130B0000ZT_DY_0_5%_2_DY; room: Sheet58
R9031-R9034 = RSC_0402: part number: RSC_0402-270_5%_2,6013A0076301,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-270-5%-1/16W-0402-TAP; signal model: R2_6013A0076301_270_5%_2; room: Sheet58
R9035 R9044 = RSC_0402: part number: RSC_0402-10K_5%_2,60130B1030ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP,10K,5%,1/16W,0402,TR; signal model: R2_60130B1030ZT_10K_5%_2; room: Sheet58
R9036 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet58
R9037 = RSC_0402: part number: RSC_0402-100K_5%_2_DY,60130B1040ZT_DY,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-100K-5%-1/16W-0402-TAP; signal model: R2_60130B1040ZT_DY_100K_5%_2_DY; room: Sheet58
R9040 R9046 R9048 = RSC_SHORT: part number: RSC_SHORT-SHORT_0402_15,SHORT_0402_15,RSC_100X050X040_2_15_SHORT,0.55MM,RSC_SHORT,SHORT_0402_15; signal model: R2_short_0402_15_short_0402_15; room: Sheet58
R9100 = RSC_0402: part number: RSC_0402-1K_5%_2,60130B1020ZT,RSC_100X050X040_2,0.55MM,RSC_0402,0402,RES-CHIP-1K-5%-1/16W-0402-TAP; signal model: R2_60130B1020ZT_1K_5%_2; room: Sheet57
RS340 = 10P8R: part number: 10P8R-10K_5%,60130CJ0053T,RSC_368X216X050_10_064,0.65MM,10P8R,RES-AR-10P8R-10K-5%-1/16W-TAP; signal model: R10_60130CJ0053T_10k_5%; room: Sheet47
S0 S2 S4 = SCREW_1: part number: SCREW_1-SCREW300_800_1P,SCREW300_800_1P,SCREW300_800_1P,0.127MM,SCREW_1,SCREW300_800_1P; room: Sheet60
S1 = SCREW_1: part number: SCREW_1-SCREW230_500_1P,SCREW230_500_1P,SCREW230_500_1P,0.127MM,SCREW_1,SCREW230_500_1P; room: Sheet60
S3 = SCREW_1: part number: SCREW_1-SCREW280_500_NP_1P,SCREW280_500_NP_1P,SCREW280_500_NP_1P,0.127MM,SCREW_1,SCREW280_500_NP_1P; room: Sheet60
S13 S42 = SCREW_1: part number: SCREW_1-SCREW230_600_NP_1P,SCREW230_600_NP_1P,SCREW230_600_NP_1P,0.127MM,SCREW_1,SCREW230_600_NP_1P; room: Sheet60
S14-S17 = SCREW_1: part number: SCREW_1-SCREW330_600_1P,SCREW330_600_1P,SCREW330_600_1P,0.127MM,SCREW_1,SCREW330_600_1P; room: Sheet60
S25 = SCREW_1: part number: SCREW_1-SCREW360_800_1P,SCREW360_800_1P,SCREW360_800_1P,0.127MM,SCREW_1,SCREW360_800_1P; room: Sheet60
S26 = SCREW_1: part number: SCREW_1-SCREW360_800_NP_1P,SCREW360_800_NP_1P,SCREW360_800_NP_1P,0.127MM,SCREW_1,SCREW360_800_NP_1P; room: Sheet60
S37-S39 S41 = SCREW_1: part number: SCREW_1-SCREW300_800_NP_1P,SCREW300_800_NP_1P,SCREW300_800_NP_1P,0.127MM,SCREW_1,SCREW300_800_NP_1P; room: Sheet60
S9101 S9102 = SCREW_1: part number: SCREW_1-SCREW230_600_1P,SCREW230_600_1P,SCREW230_600_1P,0.127MM,SCREW_1,SCREW230_600_1P; room: Sheet57
ST1 ST3 ST4 = STDPAD_1: part number: STDPAD_1-STDPAD_1.15_6-TOP,6052B0103501,STD_R_F45016_D10008_M20012_SN,1.6MM,STDPAD_1,STANDOFF,F,M2.0,2.4MM,4.5MM,RND,SN,0.8MM; room: Sheet60
ST5 = STDPAD_1: part number: STDPAD_1-STDPAD_3.15_5.5_TOP,6052B0191401,STD_R_FF40016_D30010_M20026_SN,1.75MM,STDPAD_1,STANDOFF,FF,M2.0,2.6MM,4.0MM,RND,SN,1.0MM; room: Sheet60
SW152 SW154 SW9100 = NTC011_BA1J_A160T: part number: NTC011_BA1J_A160T-MISAKI_NTC011_BA1J_A160T_4P,6026B0239401,SWCH-TACT_MISKI_5_SMD_V_170,1.95MM,,SWITCH,TACT,5P,STR,SMD,TR; room: Sheet57
TP2 TP7 TP8 TP10 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet49
TP290-TP294 = TPX_1: part number: TPX_1-TP40,TPX40,SMDTEST40,0.127MM,TPX_1,TP40; room: Sheet57
TP303 TP304 TP332 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet46
TP640-TP643 = TPX_1: part number: TPX_1-TP40,TPX40,SMDTEST40,0.127MM,TPX_1,TP40; room: Sheet54
TP1301-TP1303 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet50
TP1951 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet40
TP3000 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet38
TP3065-TP3068 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet36
TP4500 TP4509 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet24
TP4501 TP4502 TP4552-TP4557 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet21
TP4503 TP4504 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet22
TP4531 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet23
TP4562-TP4565 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet30
TP4703 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet29
TP5300 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet34
TP5400 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet35
TP9001 TP9002 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet58
TP90664 TP90665 = TPX_1: part number: TPX_1-TP24,TPX24,TP24,0.127MM,TPX_1,TP24; room: Sheet25
U300 = MECC1322_NU: part number: MECC1322_NU-SMSC_MEC1324_TQFP_128P,6019B1193301,TQFP_1400X1400X120_128_040,1.35MM,,IC,MICROCONTROLLER,32BIT ARM,VTQFP,128P,TRAY; room: Sheet46
U302 = NL27WZ07DFT2G: part number: NL27WZ07DFT2G-OSRAM_NL27WZ07DFT2G_SC88_6P_DY,6019B0262201_DY,TSSC88_200X125X110_6_065,1.25MM,,IC,BUFFER,DUAL N_INV,SC88,6P,TR; room: Sheet46
U365 = W25Q64FVSSIG: part number: W25Q64FVSSIG-WINB_W25Q128FVSIQ_SOIC_8P,6019B1048101,SOP_528X528X216_8_127,2.31MM,,IC,FLASH MEMORY,128M,-40~+85C,2.7~3.6V,1; room: Sheet46
U366 = W25Q16DVSSIG: part number: W25Q16DVSSIG-WINBOND_W25Q16DVSSIG_8P,6019B1048002,SOP_523X528X216_8_127,2.31MM,,IC,FLASH MEMORY,16M,-40~+85C,2.7~3.6V,104MHZ,4KBYTE,SOIC-8 (208MIL),8P,TUBE; room: Sheet46
U400 = I218_LM: part number: I218_LM-INTEL_CLARKVILLE_I218_LM_48P,6019B1048201,QFN_600X600X090_48_040_T4,1.05MM,,IC,ETHERNET PHY,QFN,48P,TR; room: Sheet49
U470 = NA0069RLF: part number: NA0069RLF-BOTH_NA0069RLF_SMD_24P,6016B0013101,SOP_1560X850X240_24_127,2.55MM,,TRANSFORMER,1000,SMD,24P,TR; room: Sheet49
U501 = ALC3228_CG: part number: ALC3228_CG-REALTEK_ALC3228_CG_QFN_48P,6019B1029301,QFN_600X600X100_48_040_T1,1.15MM,,IC,AUDIO CODEC,4 CHANNEL,QFN,48P,TR; room: Sheet54
U550 U551 = TPA6130A2RTJR: part number: TPA6130A2RTJR-HP_HPA022642RTJ_QFN_20P,6019B1120701,QFN_400X400X080_20_050_T1,0.95MM,,IC,HEADPHONE AMPLIFIER,138MW,QFN,20P,TR; room: Sheet55
U610 = TLV2462CDGKR: part number: TLV2462CDGKR-TI_TLV2462CDGKR_MSOP_8P_DY,6019A0187501_DY,MSOP_305X483X110_8_065,1.25MM,,IC-OP AMPLIFIER-DUAL-MSOP-8P-TAP; room: Sheet55
U800 = RTS5237_GR: part number: RTS5237_GR-REALTEK_RTS5237_GR_QFN_32P,6019B1038001,QFN_400X400X090_32_040_T1,1.05MM,,IC,PCI-E CARD READER CONTRONLLER,QFN,32P,TR; room: Sheet56
U1000 = HP3DC2TR: part number: HP3DC2TR-ST_HP3DC2TR_LGA_16P,6019B0914201,LGA_300X300X100_16_050,1.15MM,,IC,3-AXES ACCELEROMETER SENSOR,LGA,16P,TR; room: Sheet45
U2400 U2401 = BD82034FVJ_GE2: part number: BD82034FVJ_GE2-ROHM_BD82034FVJ_GE2_MSOP_8P,6019B1050101,MSOP_300X300X110_8_065,1.25MM,,IC,POWER SWITCH,USB CHARGER,MSOP-8,8P,TR; room: Sheet42
U2402 U2403 = AND_GATE: part number: AND_GATE-TC7SZ08FU,6019B0090701,SSOP_200X125X100_5_065,1.15MM,AND_GATE,IC,AND GATE,ONE,5PIN; room: Sheet42
U2511 = TPS2546RTER: part number: TPS2546RTER-TEXAS_TPS2546RTER_QFN_16P,6019B1035901,QFN_300X300X080_16_050_T1,0.95MM,,TEXAS_TPS2546RTER_QFN_16P; room: Sheet42
U2550 = USB5534B_5000JZX: part number: USB5534B_5000JZX-SMSC_USB5534B_6080JZX_QFN_64P,6019B1193401,QFN_900X900X100_64_050_T5,1.15MM,,IC,HUB CONTROLLER,USB3.0,QFN,64P,TR; room: Sheet41
U2551 = MX25L1606EM2I_12G: part number: MX25L1606EM2I_12G-MXIC_MX25L1606EM2I_12G_SOP_8P_DY,6019B0795501_DY,SOP_523X528X216_8_127,2.31MM,,IC,FLASH MEMORY,16M,SOP,8P,TR; room: Sheet41
U2950 = COMPARATOR: part number: COMPARATOR-AZV331KTR_E1,6019B0628101,TSOT23_292X160X125_5_095,1.4MM,COMPARATOR,IC,COMPARATOR,ONE,SOT23,5P,TR; room: Sheet18
U3000 = NCT3521U: part number: NCT3521U-NUVO_NCT3521U_SOT23_5P,6019B0849401,TSSOT23_290X160X135_5_095,1.5MM,,IC,POWER SWITCH,SOT23,5P,TR; room: Sheet38
U3051 = BD82034FVJ_GE2: part number: BD82034FVJ_GE2-ROHM_BD82034FVJ_GE2_MSOP_8P,6019B1050101,MSOP_300X300X110_8_065,1.25MM,,IC,POWER SWITCH,USB CHARGER,MSOP-8,8P,TR; room: Sheet37
U3065 = PTN3355BS: part number: PTN3355BS-NXP_PTN3355BS_HVQFN_40P,6019B1100101,HVQFN_600X600X100_40_050_T1,1.15MM,,IC,TRANSLATOR,DP TO VGA,HVQFN,40P,TR; room: Sheet36
U3300 = NCT3521U: part number: NCT3521U-NUVO_NCT3521U_SOT23_5P,6019B0849401,TSSOT23_290X160X135_5_095,1.5MM,,IC,POWER SWITCH,SOT23,5P,TR; room: Sheet37
U3500 = SLB9660TT1_2: part number: SLB9660TT1_2-INFINEON_SLB9660TT1_2_TSSOP_28P,6019B1132101,TSSOP_970X440X110_28_065_P2,1.25MM,,IC,HARDWARE SECURITY,TPM,FW4.40,TSSOP28P,SMD,TR; room: Sheet48
U4411 = G708T1U: part number: G708T1U-GMT_G708T1U_SOT23_5P,6019B0158401,TSOT23_290X160X130_5_095,1.45MM,IC,TEMPERATURE SENSOR,SOT23-5,5P,TR; room: Sheet19
U4555 = CL8064701477702_SR170: part number: CL8064701477702_SR170-INTEL_CL8064701477702_SR170_1168P,6025B0200401,CPU_INT_BDW_2CGT3_B_400X240,1.537MM,,CPU,1.6GHZ,DUAL CORE,15W,C0,I5-4200U,4MB,FCBGA,1168P; room: Sheet24
U4700 = TC7SH17F: part number: TC7SH17F-TSB_TC7SH17F_SSOP_5P,6019B0600401,SSOP_290X160X140_5_095,1.55MM,,IC,SERDES CIRCUIT,SSOP,5P,TR; room: Sheet22
U5000 = G780P81U: part number: G780P81U-GMT_G780P81U_MSOP_8P,6019B0567801,MSOP_300X300X122_8_065,1.37MM,,VS_GMT_8P; room: Sheet19
U5301 = PS8338AQFN60GTR: part number: PS8338AQFN60GTR-PARADE_PS8338AQFN60GTR_QFN_60P,6019B1101001,QFN_900X500X080_60_040_T1,0.95MM,,IC,DISPLAY PORT 1.2,DUAL,1:2,QFN,60P,TRAY; room: Sheet34
U5401 = PS8338AQFN60GTR: part number: PS8338AQFN60GTR-PARADE_PS8338AQFN60GTR_QFN_60P,6019B1101001,QFN_900X500X080_60_040_T1,0.95MM,,IC,DISPLAY PORT 1.2,DUAL,1:2,QFN,60P,TRAY; room: Sheet35
U6000 = BQ24736RGRR: part number: BQ24736RGRR-TI_BQ24736RGRR_QFN_20P,6019B0888201,QFN_350X350X100_20_050_T1,1.15MM,,IC,BATTERY CHARGER,SMBUS,QFN,20P,TR; room: Sheet5
U6100 = NB670GQ: part number: NB670GQ-MPS_NB670GQ_QFN_16P,6019B1132701,QFN_300X300X100_14_040_T2,1.15MM,,IC,DC/DC CONVERTER,QFN16,16P,TR; room: Sheet7
U6150 = NB670GQ: part number: NB670GQ-MPS_NB676AGQ_QFN_16P,6019B1181401,QFN_300X300X100_14_040_T2,1.15MM,,IC,DC/DC CONVERTER,QFN16,16P,TR; room: Sheet7
U6200 = AOZ1268QI_02: part number: AOZ1268QI_02-ALPHA_OMEGA_AOZ1268QI_02_QFN_23P,6019B1147601,QFN_400X400X100_23_050_P3,1.15MM,,IC,SYNC BUCK REGULATOR,QFN,23P,TR; room: Sheet9
U6240 = G2997BF61U: part number: G2997BF61U-GMT_G2997RE1U_TDFN_10P,6019B1158901,TDFN_300X300X080_10_050_T5,0.95MM,,IC,REGULATOR,ADJ,1.2_3.6V,TDFN3X3-10,10P; room: Sheet9
U6300 = AOZ1268QI_02: part number: AOZ1268QI_02-ALPHA_OMEGA_AOZ1268QI_02_QFN_23P,6019B1147601,QFN_400X400X100_23_050_P3,1.15MM,,IC,SYNC BUCK REGULATOR,QFN,23P,TR; room: Sheet10
U6350 = RT8068AZQW: part number: RT8068AZQW-RICHTEK_RT8068AZQW_WDFN_10P,6019B0952001,WDFN_300X300X080_10_050_T1,0.95MM,,IC,DC/DC CONVERTER,3A,1 MHZ,WDFN,10P,TR; room: Sheet11
U6450 = RT8068AZQW: part number: RT8068AZQW-RICHTEK_RT8068AZQW_WDFN_10P,6019B0952001,WDFN_300X300X080_10_050_T1,0.95MM,,IC,DC/DC CONVERTER,3A,1 MHZ,WDFN,10P,TR; room: Sheet12
U6600 = TPS51622ARSMR: part number: TPS51622ARSMR-TEXAS_TPS51622ARSMR_VQFN_32P,6019B1130501,QFN_400X400X100_32_040_T3,1.15MM,,IC,PWM CONTROLLER,VQFN,32P,TR; room: Sheet13
U6610 = CSD97374CQ4M: part number: CSD97374CQ4M-TI_CSD97374CQ4M_SON_8P,6019B0999601-002,DB10SG-6019B0999601-002,1.15MM,,IC,DRIVER MOSFET,25A,SON 3.5X4.5MM,8P,TR; room: Sheet14
U6903 = COMPARATOR: part number: COMPARATOR-AZV331KTR_E1,6019B0628101,TSOT23_292X160X125_5_095,1.4MM,COMPARATOR,IC,COMPARATOR,ONE,SOT23,5P,TR; room: Sheet6
U7000 = TC7SZ07FU: part number: TC7SZ07FU-TSB_TC7SZ07FU_SSOP_5P,6019B0599801,SSOP_200X125X100_5_065,1.15MM,,IC,NON_INVERTER,ONE,SSOP,5P,TR; room: Sheet17
U7400 = COMPARATOR_2: part number: COMPARATOR_2-ON_LMV393DMR2G_SOP_8P,6019B0618101,MICRO_300X300X110_8_065,1.25MM,COMPARATOR_2,IC,COMPARATOR,DUAL,MSOP,8P,TR; room: Sheet18
U9000 = AU9542B55_GBS_GR: part number: AU9542B55_GBS_GR-ALCOR_AU9560B62_GBS_GR_SSOP_28P,6019B1099001,SSOP_1020X530X200_28_065,2.15MM,,IC,CARD READER CONTROLLER,USB2.0,SSOP,28P,TR; room: Sheet58
