# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BAT_AMBERLED#: length 218.4
  TOP w0.102: v2(108.54,91.12) 108.55,91.13 CN200.19 ; R318.1 v1(259.73,103.07) 259.94,103.07 260.26,102.75 v2(260.39,102.75) 260.7,102.75 260.92,102.53 U300.113
  L5 w0.102: v2(260.39,102.75) 260.71,102.75 262.16,101.31 262.16,98.92 263.61,97.47 263.61,93.04 263.28,92.71 263.28,79.84 262.08,78.64 262.08,78.48 262.08,75.42 260.99,74.34 260.99,73.33 258.69,71.02 254.71,71.02 252.48,68.79 250.39,68.79 249.63,68.03 248.44,68.03 248.07,67.66 248.07,67.42 246.17,65.52 245.56,65.52 244.79,64.76 241.69,64.76 240.38,66.07 240.38,71.64 239.32,72.7 234.3,72.7 232.8,71.21 225.94,71.21 223.03,68.3 213.96,68.3 212.91,67.25 203.25,67.25 202.77,67.73 198.57,67.73 197.88,68.41 191.87,68.41 191.19,67.73 185.37,67.73 185.11,67.47 183.21,67.47 181.49,69.19 178.7,69.19 177.82,68.32 176.58,68.32 176.2,68.69 174.16,68.69 173.42,69.43 168.23,69.43 167.62,68.82 165.11,68.82 163.47,67.18 148.49,67.18 147.3,68.36 144.84,68.36 142.63,70.57 136.43,70.57 135.18,71.82 135.18,77.2 129.36,83.02 116.59,83.02 112.45,87.16 112.45,88.02 109.35,91.12 v2(108.54,91.12)
BAT_GRNLED#: length 237.5
  TOP w0.102: v2(148.15,77.58) 148.02,77.71 148.02,85.09 147.57,85.54 147.57,90.54 148.39,91.36 148.39,98.26 147.73,98.92 v1(147.73,105.27) 147.73,105.9 148.24,106.41 149.64,106.41 v2(150.53,107.3) 151.12,107.89 R4863.1 ; CN200.20 109.05,88.94 107.86,87.74 106.03,87.74 v2(104.27,85.99) ; v2(263.4,99.67) 263.34,99.73 U300.120
  L3 w0.102: v2(148.15,77.58) 147.23,76.67 140.4,76.67 138.53,78.55 138.16,78.55 133.32,83.38 116.41,83.38 115.1,84.69 104.85,84.69 104.27,85.26 v2(104.27,85.99)
  L5 w0.102: v2(263.4,99.67) 263.94,100.22 263.94,101.31 265.46,102.83 265.46,104.76 264.07,106.16 262.41,106.16 259.24,109.33 259.24,114.97 259.53,115.26 259.53,118.59 261.19,120.25 261.19,121.73 v2(260.89,122.03)
  BOTTOM w0.102: v2(260.89,122.03) 260.27,122.03 259.57,122.74 259.24,123.07 259.24,123.07 257.99,124.32 241.02,124.32 239.85,123.15 232.84,123.15 225.9,123.15 208.49,123.15 208.36,123.03 206.99,121.65 166.25,121.65 157.24,112.64 153.98,112.64 150.53,109.19 v2(150.53,107.3)
BAT_SM_AMBERLED#: length 111.5
  TOP w0.102: v4(33.18,155.43) 33.18,156.58 35.15,158.55 D9032.3 ; v3(81.69,111.75) 81.19,111.24 81.19,110.09 81.06,109.97 80.5,109.41 CN9000.19
  L6 w0.102: v4(33.18,155.43) 32.95,155.43 31.78,154.27 31.78,151.88 33.31,150.35 33.31,117.84 37.75,113.4 61.61,113.4 62.7,112.3 67.68,112.3 71.79,108.19 71.79,105.4 72.17,105.01 80.58,105.01 81.31,105.75 81.31,106.92 80.22,108.01 80.22,111.29 80.68,111.75 v3(81.69,111.75)
BAT_SM_GRNLED#: length 111
  TOP w0.102: CN9000.20 81,108.25 80.8,108.44 80.8,109.33 81.69,110.22 v3(81.69,110.35) ; D9032.2 36.65,158.52 34.32,156.2 v4(33.94,156.2)
  L6 w0.102: v3(81.69,110.35) 81.44,110.35 80.65,109.56 80.65,108.47 81.79,107.33 81.79,105.4 80.9,104.51 71.03,104.51 70.39,105.14 70.39,108.32 68.61,110.09 66.96,110.09 66.5,110.55 66.5,110.68 66.07,111.11 63.26,111.11 61.48,112.89 37.47,112.89 32.87,117.49 32.87,150.02 31.27,151.62 31.27,154.54 32.93,156.2 v4(33.94,156.2)
BATLOW#: length 198.9
  TOP w0.102: v2(255.56,99.3) 256.72,98.13 262.08,98.13 U300.124 ; v2(142.53,98.66) 141.7,98.66 Q302.3
  L3 w0.102: v3(157.29,97.37) 153.98,97.37 151.52,99.83 143.69,99.83 v2(142.53,98.66) ; v2(175.16,92.01) 174.86,92.31 171.45,92.31 169.22,90.09 169.22,89.29 167.77,87.84 167.77,83.39 165.79,81.42 165.79,78.61 v2(165.77,78.58)
  L5 w0.102: v2(165.77,78.58) 166.32,79.13 169.65,79.13 170.49,78.29 171.79,78.29 175.13,74.95 176.23,74.95 176.45,74.74 178.12,74.74 178.55,75.16 183.81,75.16 184.23,74.74 184.69,74.74 184.74,74.78 185.06,74.78 185.15,74.7 203.52,74.7 204.07,74.15 206.18,74.15 206.26,74.06 206.26,74.06 207.26,73.06 223.48,73.06 224.26,73.85 227.56,73.85 229.53,75.82 249.99,75.82 251.24,77.07 255.94,77.07 257.72,75.3 258.83,75.3 259.79,76.25 259.79,78.72 257.16,81.36 257.16,89.05 254.91,91.3 252.71,91.3 250.6,93.41 250.6,96.38 252.38,98.16 254.41,98.16 v2(255.56,99.3)
  L6 w0.102: v2(175.16,92.01) 175.14,92.02 174.55,92.02 172.61,93.97 172.3,93.97 170.59,95.67 170.59,96.61 169.79,97.41 157.25,97.41 v3(157.29,97.37)
  BOTTOM w0.076: v2(175.16,92.01) 175.49,92.34 U4555.AN4
  BOTTOM w0.102: R4744.2 158.87,97.13 158.35,97.65 157.57,97.65 v3(157.29,97.37)
BKLT_EN: length 5.3
  TOP w0.102: v3(110.71,116.76) 110.67,116.72 109.91,116.72 R3009.2 109.86,117.36 109.07,118.15 D3000.1
  BOTTOM w0.102: CN3000.19 110.73,116.75 v3(110.71,116.76)
BRD_ID1: length 18.8
  TOP w0.102: R4571.2 165.01,74.28 165.39,74.66 165.39,76.14 166.17,76.93 166.17,78.83 165.79,79.21 165.05,79.21 v2(164.42,78.58) 164.42,78.01 R4572.2
  BOTTOM w0.076: 171.7,81.31 171.83,81.31 172.37,81.85 173.03,81.85 173.05,81.86 173.54,81.86 U4555.P1
  BOTTOM w0.102: v2(164.42,78.58) 164.42,78.78 164.98,79.33 v1(165.69,79.33) 166.64,79.33 168.16,80.86 169.03,80.86 169.48,81.31 171.7,81.31
BRD_ID2: length 22.3
  TOP w0.102: v3(159.78,80.86) 159.78,80.13 159.24,79.59 159.24,79.21 R4573.2 R4574.2
  L6 w0.076: v2(176.65,82.61) 176.26,82.99 175.8,82.99 175.08,82.27 174.19,82.27 173.65,81.73 172.33,81.73 172.24,81.65 171.74,81.65
  L6 w0.102: v3(159.78,80.86) 160.36,80.28 168.97,80.28 169.7,81.01 171.1,81.01 171.74,81.65
  BOTTOM w0.102: v2(176.65,82.61) 176.65,82.9 176.82,83.08 U4555.U6
BRD_ID3: length 14.5
  BOTTOM w0.076: U4555.P4 175.49,81.9 175.11,82.27 174.72,82.27 174.68,82.31 173.03,82.31 172.9,82.18 172.03,82.18 171.7,81.84 171.16,81.84
  BOTTOM w0.102: 171.16,81.84 168.37,81.84 167.37,80.83 v1(167.04,80.83) 166.35,80.14 164.77,80.14 163.86,79.23 R4575.2 163.52,78.85 R4576.2
BRD_ID4: length 19
  L6 w0.102: v2(160.33,79.06) 160.91,79.64 169.5,79.64 169.58,79.56 171.58,79.56 172.47,80.45 174.11,80.45 v2(175.13,81.48)
  BOTTOM w0.076: v2(175.13,81.48) 175.13,81.42 175.49,81.07 U4555.N4
  BOTTOM w0.102: R4577.2 R4578.2 159.84,78.58 v2(160.33,79.06)
BT_OFF: length 174
  TOP w0.102: v2(172.4,105.31) 172.73,105.31 173.59,104.45 173.59,101.02 173.01,100.44 173.01,96.63 174.14,95.49 174.14,90.02 v2(175.16,89) ; v2(299.96,108.09) 299.96,107.2 301.08,106.08 306.28,106.08 v1(306.99,106.79) 307.88,107.68 311.06,107.68 312.2,108.82 312.2,109.33 313.85,110.98 Q1302.2
  L5 w0.102: v2(299.96,108.09) 299.96,106.36 v2(298.79,105.19)
  BOTTOM w0.076: U4555.AG4 175.49,88.56 175.17,88.88 175.17,89 v2(175.16,89)
  BOTTOM w0.102: v2(172.4,105.31) 172.4,106.33 172.98,106.91 172.98,108.02 175.53,110.58 206.05,110.58 206.05,110.58 211.02,110.58 213.34,110.58 213.34,110.58 213.71,110.95 213.78,110.95 238.69,110.95 238.89,110.74 240.92,110.74 241.05,110.62 243.7,110.62 243.81,110.73 254.79,110.73 255.27,111.21 261.37,111.21 262.6,109.99 263.31,109.28 265.34,109.28 267.18,107.43 267.62,107.43 269.09,108.9 269.65,108.9 270.29,108.27 284.18,108.27 287.26,105.19 v2(298.79,105.19)
BT_OFF#: length 20.6
  TOP w0.102: v2(312.15,112.74) 312.15,112.56 312.33,112.38 313.13,112.38 R1306.2 314.38,112.89 v1(314.46,112.81) 314.46,111.93 Q1302.3 313.86,111.63 312.56,110.33 Q1302.6
  BOTTOM w0.102: v2(312.15,112.74) 312.88,113.47 312.88,115.86 308.77,119.97 308.77,123.7 308.57,123.9 CN1300.54
BUF_PLT_RST#: length 496.7
  TOP w0.102: v2(154.82,109.99) 155.49,110.66 Q4754.1 ; R4921.2 226.77,88.13 v2(226.75,88.15) ; v2(299.5,78.8) 298.86,78.8 295.62,75.56 D801.1 ; v3(123.04,149.57) 123.04,148.19 122.71,147.86 R3507.1 ; v2(141.38,89.14) 141.51,89.01 141.51,87.48 141.32,87.29 141.32,80.4 v2(142.93,78.79)
  L3 w0.102: v2(241.83,121.19) 241.34,120.7 241.34,117.17 245.52,112.98 245.52,109.33 244.5,108.31 v2(244.5,103.44) ; v2(141.38,89.14) 142.09,88.43 143.09,88.43 144.57,86.94 147.16,86.94 149.6,89.39 154.87,89.39 v2(155.79,90.31) ; v2(299.5,78.8) 299.5,79.72 300.84,81.06 300.84,88.58 302.88,90.61 302.88,107.5 303.61,108.23 303.61,111.06 v2(304.6,112.05)
  L5 w0.102: v2(257.23,55.18) 257.99,54.42 261.2,54.42 261.92,53.7 265.3,53.7 267.24,55.64 275.72,55.64 276.89,54.47 278.05,54.47 278.48,54.9 279.21,54.9 280.15,55.84 281.18,55.84 281.92,56.57 281.92,57.59 283.75,59.42 283.75,62.6 282.66,63.69 282.65,63.69 282.6,63.74 281.59,63.74 280.32,65.01 280.32,65.9 282.15,67.73 285.02,67.73 291.95,74.66 292.89,74.66 293.33,75.09 297.72,75.09 299.5,76.87 v2(299.5,78.8) ; v2(242,86.73) 242,86.91 240.88,88.02 237.37,88.02 236.89,88.5 234.12,88.5 233.92,88.71 227.31,88.71 v2(226.75,88.15) ; v2(304.58,123.93) 304.58,123.39 304.81,123.16 304.81,121.04 305.57,120.28 305.57,115.66 304.5,114.59 304.5,112.15 v2(304.6,112.05)
  L6 w0.102: v3(123.04,149.57) 123.04,148.78 119.67,145.4 119.67,133.46 128.7,124.43 140.39,124.43 v2(154.82,109.99) ; v2(243.03,67.45) 242.42,67.45 241.59,68.29 241.59,69.86 243.03,71.31 243.03,81.9 242.14,82.79 239.91,82.79 239.38,83.32 239.38,84.14 240.32,85.08 240.82,85.08 242,86.25 v2(242,86.73)
  BOTTOM w0.102: v2(299.5,78.8) 299.5,82.03 299.22,82.31 296.3,82.31 291.62,86.98 291.62,88.12 290.48,89.27 289.08,89.27 288.07,90.28 288.07,93.71 288.7,94.35 293.56,94.35 295.51,96.3 CN1951.50 ; v2(243.03,67.45) 243.11,67.37 243.69,67.37 243.92,67.15 243.92,63.57 245.1,62.39 R1410.1 245.1,54.89 247.3,52.69 255.69,52.69 257.23,54.23 v2(257.23,55.18) ; v2(155.79,90.31) 155.84,90.35 155.84,92.97 155.48,93.33 154.94,93.33 154.46,93.81 154.46,96.76 154.85,97.15 154.85,100.19 154.46,100.57 154.46,109.63 v2(154.82,109.99) 158.08,109.99 167.68,119.59 208.17,119.59 209.27,120.69 241.33,120.69 v2(241.83,121.19) ; CN375.6 136.04,75.3 136.68,74.66 137.19,74.66 137.45,74.92 137.45,75.93 136.56,76.82 136.56,79.01 136.77,79.22 139.34,79.22 139.5,79.39 139.65,79.53 141.97,79.53 142.72,78.79 v2(142.93,78.79) ; U3500.16 119.9,151.62 119.9,149.46 120.3,149.06 122.54,149.06 v3(123.04,149.57) ; R4713.1 141.38,88.71 v2(141.38,89.14) 141.38,89.39 140.75,90.03 140.75,92.19 141.38,92.82 U4700.4 ; CN1300.52 306.38,123.4 306.02,123.05 304.96,123.05 304.58,123.43 v2(304.58,123.93) ; v2(242,86.73) 242,86.73 242.2,86.73 246.11,90.63 246.11,100.77 246.67,101.33 246.67,102.47 245.7,103.44 v2(244.5,103.44)
C_DN: length 58.2
  TOP w0.089: v2(310.95,94.96) 310.95,95.11 310.66,95.4 310.51,95.4 310.09,94.98 309.79,94.98
  L3 w0.089: v2(319.79,109.61) 319.82,109.59 319.82,109.57 319.97,109.42 320.38,109.42 320.64,109.67 320.64,110.53 320.27,110.89 319.7,110.89 316.52,107.71 316.52,106.09 312.87,102.44 312.87,89.68 314.06,88.49 314.38,88.49 314.48,88.49 314.59,88.6 314.59,88.63 314.69,88.73 314.84,88.73 314.94,88.63 314.94,88.6 315.05,88.49 315.2,88.49 315.3,88.6 315.3,88.63 315.4,88.73 315.55,88.73 315.66,88.63 315.66,88.6 315.76,88.49 315.93,88.49 316.41,88.97 317.56,88.97 JACK485.5
  BOTTOM w0.089: v2(310.95,94.96) 310.72,95.19 310.44,95.19 310.16,95.47 310.16,95.77 310.16,104.2 313.39,107.43 313.88,107.92 316.69,107.92 318.46,109.7 319.41,109.7 319.5,109.61 v2(319.79,109.61) 319.95,109.61 320.36,109.2 CN3601.52
C_DP: length 58.2
  TOP w0.089: U470.18 309.96,96.25 310.57,95.64 310.81,95.64 310.96,95.79 v2(310.96,95.92)
  L3 w0.089: JACK485.4 316.69,88.2 315.6,88.2 313.94,88.2 312.58,89.56 312.58,102.56 316.23,106.21 316.23,107.83 319.58,111.18 320.39,111.18 320.93,110.65 320.93,109.55 320.5,109.13 320,109.13 v2(319.82,108.95)
  BOTTOM w0.089: CN3601.51 320.47,108.7 320.12,109.05 319.92,109.05 v2(319.82,108.95) 319.31,109.46 318.56,109.46 316.79,107.68 313.98,107.68 313.63,107.33 310.4,104.1 310.4,95.67 310.4,95.57 310.54,95.43 310.98,95.43 311.13,95.58 311.13,95.77 310.98,95.92 v2(310.96,95.92)
CAMERA_ON: length 104
  TOP w0.102: v3(164.59,77.04) 164.59,76.14 R4770.2
  L6 w0.102: v2(111.41,120.64) 112.05,120 112.05,103.87 113.14,102.78 115.53,102.78 119.33,106.58 123.7,106.58 125.74,104.55 135.62,104.55 140.64,99.53 140.64,95.35 145.45,90.54 146.59,90.54 150.09,87.04 150.09,84.44 153.76,80.77 153.76,80.15 155.06,78.85 155.33,78.85 155.77,78.41 157.95,78.41 159.42,76.95 161.98,76.95 162.67,77.63 163.99,77.63 v3(164.59,77.04)
  BOTTOM w0.076: U4555.L4 175.49,80.39 175.1,80.78 174.72,80.78 174.68,80.82 173.05,80.82 172.94,80.7 172.56,80.7 172.56,80.7 172.33,80.7 172.33,80.7 171.54,79.92 169.6,79.92
  BOTTOM w0.102: CN3000.11 111.53,120.75 v2(111.41,120.64) ; 169.6,79.92 168.23,79.92 165.77,77.46 165.01,77.46 v3(164.59,77.04)
CAPS_LED#: length 11.9
  TOP w0.102: v2(259.79,85.63) 259.8,85.63 R360.2 ; v3(264.45,90.24) 264.19,90.24 R341.1 263.06,89.11 U302.4 263.06,88.23 264.07,87.23 R393.1
  L3 w0.102: v3(264.45,90.24) 263.77,90.24 259.79,86.26 v2(259.79,85.63)
CATERR_N: length 1.5
  TOP w0.076: TP4502.1 210.51,80.46 v2(210.51,79.94)
  BOTTOM w0.076: U4555.K61 210.51,79.88 v2(210.51,79.94)
CFG<0>: length 43.8
  TOP w0.102: CN4920.9 236.13,78.02 v2(235.31,77.21)
  L6 w0.102: v2(235.31,77.21) 235.25,77.21 234.62,77.84 234.62,79.88 235.14,80.4 236.18,80.4 237.34,81.56 237.34,86.14 233.99,89.49 226.25,89.49 225.98,89.22 222.6,89.22 220.1,86.72 215.18,86.72 214.87,86.41 213.92,86.41 213.49,86.83 v2(213.49,86.88)
  BOTTOM w0.076: v2(213.49,86.88) 213.29,86.69 212.66,86.69 212.58,86.77 211.87,86.77 211.7,86.61 211.02,86.61 210.99,86.64 210.51,86.64 U4555.AC60
CFG<1>: length 46.4
  TOP w0.102: CN4920.11 238.69,78.52 240.67,80.5 v2(240.67,81.39)
  BOTTOM w0.076: 214.95,86.6 214.83,86.48 212.61,86.48 212.49,86.6 212.04,86.6 211.75,86.31 U4555.AC62
  BOTTOM w0.102: 214.95,86.6 216.69,86.6 221.65,91.55 223.85,91.55 226.9,94.59 232.66,94.59 238.41,88.85 v1(238.41,87.97) 238.41,83.42 238.79,83.04 239.17,83.04 240.67,81.54 v2(240.67,81.39)
CFG<2>: length 44.2
  TOP w0.102: CN4920.15 239.11,79.53 v2(240.19,80.6)
  BOTTOM w0.102: U4555.AC63 212.53,86.31 212.54,86.3 217.03,86.3 221.9,91.17 223.76,91.17 226.98,94.39 232.58,94.39 237.72,89.25 v1(237.72,85.66) 237.72,83.6 238.67,82.66 239.07,82.66 240.19,81.54 v2(240.19,80.6)
CFG<3>: length 40.5
  TOP w0.102: v2(235.41,85.14) 235.41,84.57 235.21,84.36 235.21,83.35 235.63,82.93 235.63,82.24 236.02,81.85 236.02,80.16 236.15,80.02 CN4920.17 ; v3(221.65,86.6) 223.81,86.6 225.18,87.96 225.18,88.65 226.1,89.57 226.1,89.78 226.6,90.28 R4939.2
  L6 w0.102: v2(235.41,85.14) 235.41,86.27 234.45,87.23 225.13,87.23 225.1,87.21 225.09,87.21 224.48,86.6 v3(221.65,86.6)
  BOTTOM w0.076: 214.66,85.2 214.47,85.2 214.07,85.6 212.2,85.6 212.16,85.56 U4555.AA63
  BOTTOM w0.102: 214.66,85.2 220.28,85.2 221.68,86.6 v3(221.65,86.6)
CFG<4>: length 38.1
  TOP w0.076: R4523.1 210.39,86.06 v3(210.51,85.94)
  TOP w0.102: CN4920.27 236.09,82.52 235.96,82.66 235.96,82.89 235.61,83.23 v2(235.61,83.59)
  L6 w0.102: v3(210.51,85.94) 210.51,84.39 209.37,83.24 209.37,82.58 209.48,82.47 212.61,82.47 212.98,82.1 214.46,82.1 215.56,81 222.9,81 223.68,81.77 225.71,81.77 225.99,82.05 225.99,82.75 227.93,84.69 230.91,84.69 233.06,82.54 233.92,82.54 234.97,83.59 v2(235.61,83.59)
  BOTTOM w0.076: v3(210.51,85.94) 210.21,85.64 U4555.AA60
CFG<5>: length 36.5
  TOP w0.102: v2(235.61,84.2) 235.61,84.16 236.02,83.75 236.02,83.16 236.16,83.02 CN4920.29
  BOTTOM w0.076: U4555.Y62 211.51,84.81 211.52,84.81 211.75,84.81 212.04,85.1 212.71,85.1 212.88,85.27 213.81,85.27 214.32,84.76 214.52,84.76
  BOTTOM w0.102: 214.52,84.76 220.82,84.76 223.17,87.11 223.17,88.91 226.22,91.95 231.15,91.95 235.31,87.79 v1(235.31,86.6) 235.31,85.94 235.9,85.35 235.9,84.48 v2(235.61,84.2)
CFG<6>: length 35.6
  TOP w0.102: v2(234.9,86.04) 235.18,86.04 235.82,85.4 235.82,84.65 236.03,84.44 236.03,84.27 236.27,84.03 CN4920.33
  BOTTOM w0.076: U4555.Y61 210.86,84.85 211.27,84.44 211.83,84.44 211.91,84.52 212.62,84.52 212.63,84.51 213.5,84.51
  BOTTOM w0.102: 234.45,87.76 v1(234.45,87.77) ; 234.45,87.76 234.45,88.27 230.97,91.75 226.3,91.75 223.43,88.88 223.43,86.98 220.96,84.51 213.5,84.51 ; 234.45,87.76 234.45,86.49 v2(234.9,86.04)
CFG<7>: length 37.1
  TOP w0.102: CN4920.35 236.23,84.52 236.23,84.53 236.02,84.73 236.02,85.82 v2(235.85,85.99)
  BOTTOM w0.076: 214.54,85 214.44,85 214,85.44 212.66,85.44 212.49,85.27 211.97,85.27 211.81,85.11 211.02,85.11 210.99,85.14 210.51,85.14 210.21,84.85 U4555.Y60
  BOTTOM w0.102: v2(235.85,85.99) 236.38,86.52 v1(236.38,87.74) 235.62,88.5 234.98,88.5 231.33,92.16 226.13,92.16 222.92,88.94 222.92,87.26 220.65,85 214.54,85
CFG<8>: length 39
  TOP w0.102: v2(235.59,81.21) 235.13,80.76 235.13,79.54 233.62,78.02 CN4920.10
  L6 w0.102: v2(213.51,83.88) 213.47,83.88 214.47,84.89 216.67,84.89 218.09,86.31 220.32,86.31 221.37,87.36 224.64,87.36 224.99,87.72 234.99,87.72 236.61,86.09 236.61,82.24 v2(235.59,81.21)
  BOTTOM w0.076: v2(213.51,83.88) 213.5,83.88 213.06,84.32 212.52,84.32 212.49,84.35 211.98,84.35 211.68,84.06 211.51,84.06 U4555.V62
CFG<9>: length 39.6
  TOP w0.076: R4534.1 212.29,85.33 213.34,85.33 v1(214.1,84.57) v2(214.1,83.86)
  TOP w0.102: v2(234.28,86.03) 234.28,86.03 234.61,85.7 234.67,85.7 235.01,85.37 235.01,84.97 235.08,84.89 235.08,84.53 235,84.45 235,83.27 235.43,82.84 235.43,82.14 234.61,81.32 234.61,79.36 233.78,78.52 CN4920.12
  L6 w0.102: v2(214.1,83.86) 214.64,84.4 222.57,84.4 225.18,87.01 233.59,87.01 234.28,86.32 v2(234.28,86.03)
  BOTTOM w0.076: v2(214.1,83.86) 213.74,83.5 212.61,83.5 212.45,83.67 211.47,83.67 211.12,84.02 210.86,84.02 U4555.V61
CFG<10>: length 34.6
  TOP w0.102: v2(233.76,79.74) 233.56,79.74 233.34,79.53 CN4920.16
  L6 w0.102: v2(233.76,79.74) 233.76,80.63 230.33,84.06 228.38,84.06 227.39,83.06 227.39,82.11 226.82,81.54 223.83,81.54 222.92,80.63 215.65,80.63 215.09,81.19 212.66,81.19 211.61,82.23 209.44,82.23 209.18,82.5 209.18,83.69 v3(209.92,84.44)
  BOTTOM w0.076: U4555.V60 210.21,84.02 209.92,84.31 v3(209.92,84.44)
CFG<11>: length 35.2
  TOP w0.102: v2(234.62,84.59) 234.66,84.55 234.66,83.33 235.23,82.76 235.23,82.23 233.02,80.02 CN4920.18
  L6 w0.102: v2(234.62,84.59) 234.46,84.75 233.04,84.75 231.62,86.17 225.62,86.17 222.02,82.56 213.26,82.56 212.29,83.53 210.47,83.53 209.86,82.92 v3(209.88,82.92)
  BOTTOM w0.076: v3(209.88,82.92) 209.88,83.02 U4555.U60
CFG<12>: length 27.8
  TOP w0.102: CN4920.28 233.29,82.52 233.81,83.05 v2(233.81,83.58)
  L6 w0.102: v2(233.81,83.58) 233.81,83.07 233.51,82.77 233.17,82.77 230.98,84.97 225.57,84.97 222.25,81.65 217.58,81.65 217.23,82 v3(217.23,82)
  BOTTOM w0.102: U4555.T63 213.1,82.57 213.36,82.3 216.92,82.3 v3(217.23,82)
CFG<13>: length 26.1
  TOP w0.102: CN4920.30 233.15,83.02 233.31,83.18 v2(233.34,83.18)
  L6 w0.102: v2(217.89,82.07) 222.18,82.07 225.27,85.17 231.09,85.17 233.08,83.18 v2(233.34,83.18)
  BOTTOM w0.076: U4555.T62 211.81,82.86 213.06,82.86 213.36,82.55 213.39,82.55
  BOTTOM w0.102: 213.39,82.55 217.37,82.55 217.84,82.07 v2(217.89,82.07)
CFG<14>: length 22.6
  TOP w0.102: CN4920.34 230.49,84.03 230.33,84.19 228,84.19 227.49,83.68 v1(226.85,83.68) 226.21,83.68 v2(226.16,83.63)
  L6 w0.102: v2(226.16,83.63) 225.12,83.63 222.7,81.21 216.73,81.21 v4(216.29,81.65)
  BOTTOM w0.076: 213.22,82.16 213.11,82.27 211.12,82.27 210.87,82.53 210.86,82.53 U4555.T61
  BOTTOM w0.102: v4(216.29,81.65) 215.86,82.08 213.3,82.08 213.22,82.16
CFG<15>: length 24.1
  TOP w0.102: CN4920.36 230.38,84.52 230.26,84.65 v1(227.74,84.65) 226.56,84.65 v2(226.17,84.26)
  L6 w0.102: v2(226.17,84.26) 225.39,84.26 222.58,81.45 217.1,81.45 216.79,81.76 216.79,81.93 216.34,82.37 213.18,82.37 212.22,83.34 210.95,83.34 v2(210.54,82.92)
  BOTTOM w0.076: U4555.T60 210.21,82.53 210.54,82.85 v2(210.54,82.92)
CFG<16>: length 38.4
  TOP w0.102: CN4920.6 233.21,77.02 v2(233.4,77.21)
  L6 w0.102: v2(233.4,77.21) 234.21,78.02 234.21,80.83 236.26,82.87 236.26,86.16 234.93,87.49 225.05,87.49 224.67,87.11 221.46,87.11 219.99,85.63 v3(218.47,85.63)
  BOTTOM w0.076: 212.83,86.1 212.82,86.11 212.58,86.11 212.49,86.02 211.97,86.02 211.51,85.56 U4555.AA62
  BOTTOM w0.102: v3(218.47,85.63) 218,86.1 212.83,86.1
CFG<17>: length 42.3
  TOP w0.102: v2(234.01,77.21) 233.32,76.52 CN4920.4
  L6 w0.102: v3(216.14,85.68) 216.97,86.51 220.21,86.51 222,88.3 225.68,88.3 226.29,88.91 234.08,88.91 236.92,86.08 236.92,81.7 235.85,80.63 235,80.63 234.42,80.04 234.42,77.62 v2(234.01,77.21)
  BOTTOM w0.076: 213.12,85.84 212.5,85.84 212.49,85.86 212.04,85.86 211.87,85.68 211.87,85.51 211.64,85.27 211.12,85.27 210.86,85.53 U4555.AA61
  BOTTOM w0.102: v3(216.14,85.68) 215.98,85.84 213.12,85.84
CFG<18>: length 29.4
  TOP w0.102: CN4920.24 232.96,81.52 234.22,82.79 234.22,83.74 234.21,83.75 234.21,83.76 233.81,84.16 v2(233.81,85.28)
  L6 w0.102: v3(214.3,82.96) 222.04,82.96 225.45,86.38 232.26,86.38 233.06,85.57 233.52,85.57 v2(233.81,85.28)
  BOTTOM w0.076: v3(214.3,82.96) 213.92,83.34 212.19,83.34 212.16,83.32 U4555.U63
CFG<19>: length 31.7
  TOP w0.102: CN4920.22 232.96,81.02 233.48,81.54 233.48,81.75 234.42,82.69 234.42,83.88 234.22,84.09 234.22,85.01 v2(234.5,85.3)
  L6 w0.102: v2(213.57,82.96) 214.08,83.47 214.26,83.47 214.27,83.47 221.94,83.47 225.24,86.78 232.21,86.78 233.22,85.77 233.93,85.77 234.41,85.3 v2(234.5,85.3)
  BOTTOM w0.076: v2(213.57,82.96) 213.51,83.02 211.81,83.02 211.51,83.32 U4555.U62
CHR_ILIM: length 317.3
  TOP w0.102: v2(62.77,88.63) 62.52,88.63 61.88,88 Q6901.3 v1(61.88,86.5) R6914.1
  TOP w0.254: U6000.10 286.81,129.38 285.15,131.05 C6032.1 284.94,131.26 284.62,131.58 284.62,132.55 284.89,132.83 v2(285.15,132.83)
  L6 w0.102: v2(285.15,132.83) 285.15,133.3 283.8,134.65 282.62,134.65 281.47,135.8 281.47,136.77 274.46,143.78 265.84,143.78 262.91,146.71 255.49,146.71 253.61,148.59 246.85,148.59 245.47,149.96 245.47,158.86 242.99,161.35 233.6,161.35 231.85,159.6 219.19,159.6 217.44,161.35 190.01,161.35 184.4,155.74 174.8,155.74 168.47,162.06 116.38,162.06 114.24,159.93 105.77,151.46 105.77,133.73 109.33,130.17 109.33,126.09 105.55,122.31 105.55,109.04 103.43,106.91 103.43,102.9 96.81,96.28 95.71,95.18 92.63,95.18 89.58,92.12 89.25,92.12 88.81,91.68 88.81,90.9 87.52,89.62 82.43,89.62 80.17,87.36 64.04,87.36 v2(62.77,88.63)
CHRG_ADP_DET: length 2.6
  TOP w0.102: U300.1 263.63,93.73 v1(263.23,93.33) 263.3,93.25 R373.1
CL_CLK1: length 179.9
  TOP w0.102: v2(170.96,87.36) 171.31,87.71 171.31,97.69 170.23,98.77 170.23,102.83 170.64,103.24 170.64,104.51 170.26,104.89 v2(169.83,104.89)
  BOTTOM w0.076: v2(170.96,87.36) 170.99,87.39 173.21,87.39 173.21,87.39 173.73,87.39 174.19,87.85 U4555.AF2
  BOTTOM w0.102: v2(169.83,104.89) 169.83,106.35 170.96,107.48 170.96,108.59 174.78,112.41 206.81,112.41 211.78,112.41 211.78,112.4 212.58,112.4 212.58,112.41 212.95,112.78 243.78,112.78 244.23,113.23 249.89,113.23 249.89,113.23 250.46,113.23 251.01,113.79 255.21,113.79 255.7,113.29 261.88,113.29 262.01,113.17 264.07,111.1 288.84,111.1 291.59,108.35 295.55,108.35 295.9,107.99 296.21,107.68 300.22,107.68 300.63,108.09 304.2,108.09 305.4,109.28 305.4,110.26 305.39,110.27 305.39,120.3 305.99,120.9 CN1300.42
CL_DATA1: length 179.8
  TOP w0.102: v2(170.49,86.64) 170.49,87.62 171.06,88.19 171.06,97.55 169.86,98.75 169.86,103.99 v2(170.23,104.36)
  BOTTOM w0.076: U4555.AD2 173.89,86.81 172.87,86.81 172.62,87.06 171.71,87.06 171.29,86.64 v2(170.49,86.64)
  BOTTOM w0.102: v2(170.23,104.36) 171.18,105.31 v1(171.18,106.16) 171.18,106.83 171.61,107.26 171.61,108.38 175.03,111.8 206.56,111.8 211.53,111.8 212.83,111.8 213.2,112.17 244.03,112.17 244.48,112.62 250.71,112.62 251.27,113.18 254.96,113.18 255.45,112.68 261.63,112.68 263.82,110.5 288.58,110.5 291.34,107.74 295.29,107.74 295.96,107.07 296.46,107.07 300.47,107.07 300.88,107.48 304.45,107.48 306.03,109.05 306.03,119.92 306.5,120.4 CN1300.40
CL_RST#1: length 183.3
  TOP w0.102: v2(169.37,105.4) 170.21,105.4 171.1,104.51 171.1,103.01 170.57,102.47 170.57,98.94 171.54,97.97 171.54,92.49 172.37,91.66 172.37,88.91 v4(171.74,88.28)
  BOTTOM w0.076: v4(171.74,88.28) 171.99,88.03 173.1,88.03 173.21,88.14 173.73,88.14 173.89,88.31 174.67,88.31 174.72,88.27 175.11,88.27 175.48,87.89 175.49,87.89 U4555.AF4
  BOTTOM w0.102: CN1300.38 306.89,119.9 306.69,119.69 306.69,108.85 304.71,106.87 301.13,106.87 300.72,106.46 296.72,106.46 295.71,106.46 295.04,107.13 291.09,107.13 289.66,108.56 288.33,109.89 263.56,109.89 263.21,110.24 263.21,110.24 261.38,112.08 255.2,112.08 255,112.28 251.23,112.28 250.96,112.01 244.9,112.01 244.39,111.5 240.33,111.5 240.18,111.35 239.15,111.35 238.94,111.56 213.53,111.56 213.46,111.56 213.08,111.19 213.08,111.19 211.27,111.19 206.3,111.19 206.3,111.19 175.28,111.19 172.37,108.28 172.37,107.16 171.79,106.58 171.79,105.07 171.79,104.55 v1(171.36,104.12) 171.22,103.98 171.21,103.98 171.05,103.82 169.88,103.82 169.22,104.48 169.22,105.24 v2(169.37,105.4)
CLK_KBC_SIO: length 26.4
  TOP w0.114: v2(164.24,104.63) R4774.2
  L3 w0.076: v2(182.11,92.69) 181.63,93.17 181.63,93.21 181.35,93.48 181.35,95.27 180.81,95.81 180.05,95.81 179.74,96.12
  L3 w0.102: 179.74,96.12 179.14,96.72 178.31,96.72 174.33,100.7 167.67,100.7 164.24,104.13 v2(164.24,104.63)
  BOTTOM w0.076: v2(182.11,92.69) 182.08,92.69 U4555.AN15
CLK_PCIE2_DN: length 116.8
  TOP w0.102: U800.6 292.64,73.35 292.64,73.85 292,74.48 287.97,74.48 287.86,74.38 287.86,74.23 v2(288.04,74.05)
  L3 w0.102: v2(288.04,74.05) 287.82,74.27 287.82,74.45 287.23,75.04 286.54,75.04 284.64,76.95 281.21,76.95 280.19,75.93 280.19,69.58 279.99,69.38 278.64,69.38 276.84,67.58 269.78,67.58 269.32,67.12 263.07,67.12 261.18,65.22 254.57,65.22 254.15,65.64 245.04,65.64 243.42,64.03 239.4,64.03 239.12,63.75 228.41,63.75 227.17,62.52 219.97,62.52 219.38,63.11 209.55,63.11 208.77,63.9 208.77,65.44 206.75,67.46 205.77,67.46 204.91,68.31 199.4,68.31 198.38,69.33 198.38,70.8 198.57,70.99 198.57,71.02 v2(198.81,71.26)
  BOTTOM w0.076: U4555.B41 198.28,74.53 198.28,74.31 197.9,73.92 197.9,72.55 198.43,72.01 198.43,71.64 v2(198.81,71.26)
CLK_PCIE2_DP: length 116.8
  TOP w0.102: v2(287.44,74.07) 287.54,74.07 287.65,74.18 287.65,74.47 287.88,74.7 292.09,74.7 292.86,73.94 292.86,73.35 U800.5
  L3 w0.102: v2(198.83,71.94) 198.83,71.9 198.32,71.39 198.32,71.09 198.13,70.91 198.13,69.22 199.3,68.06 204.81,68.06 205.66,67.2 206.65,67.2 208.51,65.34 208.51,63.79 209.44,62.86 219.27,62.86 219.87,62.27 227.28,62.27 228.51,63.5 239.23,63.5 239.51,63.78 243.53,63.78 245.14,65.39 254.05,65.39 254.47,64.97 261.29,64.97 263.18,66.86 269.43,66.86 269.89,67.32 276.95,67.32 278.75,69.12 280.1,69.12 280.45,69.48 280.45,75.83 281.32,76.69 284.53,76.69 286.44,74.79 287.12,74.79 287.57,74.34 287.57,74.2 v2(287.44,74.07)
  BOTTOM w0.076: U4555.A41 198.28,73.88 198.28,73.75 198.06,73.53 198.06,72.71 v2(198.83,71.94)
CLK_PCIE3_DN: length 134.8
  TOP w0.102: U400.45 289.57,109.35 289.47,109.46 288.42,109.46 287.6,108.64 287.6,108.28 v2(287.74,108.14)
  L3 w0.102: v2(200.11,71.28) 199.74,71.65 199.74,73.15 200.13,73.54 217.01,73.54 218.85,75.37 220.91,75.37 221.77,76.24 221.77,76.85 223.86,78.94 226.96,78.94 228.51,80.48 228.51,82.09 229.1,82.69 233.63,82.69 234.11,83.18 235.98,83.18 237.34,84.54 241.75,84.54 242.23,84.06 249.31,84.06 252.07,81.3 254.48,81.3 254.65,81.14 256.7,81.14 258.73,83.17 263.3,83.17 264.83,84.69 269.53,84.69 271.66,82.57 280.43,82.57 283.07,85.22 285.44,85.22 287.78,87.56 287.78,98.6 284.97,101.41 284.97,107.46 286.5,108.99 287.28,108.99 287.62,108.64 287.62,108.26 v2(287.74,108.14)
  BOTTOM w0.076: 198.58,73.06 198.58,74.72 198.55,74.74 198.55,74.91 U4555.C41
  BOTTOM w0.127: 198.58,73.06 198.58,72.81 199.68,71.71 v2(200.11,71.28)
CLK_PCIE3_DP: length 134.7
  TOP w0.102: v3(286.97,108.16) 287.16,108.16 287.38,108.38 287.38,108.73 288.33,109.67 289.47,109.67 289.54,109.75 U400.44
  L3 w0.102: v2(200.14,71.98) 200.03,72.09 200.03,72.32 200.21,72.51 200.21,72.74 200.04,72.91 200.04,73.1 200.23,73.29 200.41,73.29 200.56,73.14 200.81,73.14 200.96,73.29 217.12,73.29 218.95,75.12 221.01,75.12 222.03,76.13 222.03,76.74 223.97,78.68 227.07,78.68 228.76,80.38 228.76,81.99 229.2,82.43 233.73,82.43 234.22,82.92 236.08,82.92 237.45,84.29 241.64,84.29 242.12,83.81 249.21,83.81 251.96,81.05 254.38,81.05 254.54,80.88 256.8,80.88 258.84,82.92 263.41,82.92 264.93,84.44 269.43,84.44 271.55,82.32 280.53,82.32 283.18,84.96 285.55,84.96 288.03,87.45 288.03,98.7 285.22,101.51 285.22,107.35 286.6,108.73 287.17,108.73 287.37,108.53 287.37,108.33 287.2,108.16 v3(286.97,108.16)
  BOTTOM w0.076: U4555.B42 198.84,74.86 198.74,74.76 198.74,74.61 198.86,74.49 198.86,74.34 198.74,74.22 198.74,74.15 198.86,74.03 198.86,73.88 198.74,73.76 198.74,73.62 198.86,73.5 198.86,73.42 198.74,73.3 198.74,73.17 198.81,73.11
  BOTTOM w0.127: v2(200.14,71.98) 200.14,71.94 200.07,71.87 199.82,71.87 199.65,72.05 199.65,72.17 199.85,72.37 199.85,72.53 199.7,72.68 199.6,72.68 199.37,72.45 199.25,72.45 199.04,72.66 199.04,72.76 199.14,72.86 199.14,73 199.04,73.11 198.81,73.11
CLK_PCIE4_DN: length 213.8
  L3 w0.102: v3(310.38,125.98) 310.59,125.98 310.75,125.82 310.75,125.15 310.3,124.7 304.32,124.7 303.31,123.68 299.51,123.68 295.91,120.09 293.87,120.09 292.61,118.83 291.13,118.83 290.1,117.8 290.1,113.01 288.22,111.13 288.22,107.93 288.22,107.53 287.18,106.5 287.18,100.53 289.09,98.62 289.09,87.6 285.93,84.44 283.75,84.44 283.23,83.92 283.23,83.1 v2(282.96,82.84)
  L6 w0.102: v2(282.96,82.84) 283.07,82.84 283.17,82.94 283.17,83.25 282.85,83.58 281.51,83.58 280.61,82.67 276.9,82.67 275.93,83.65 265.82,83.65 264.29,82.13 264.29,81.08 261.7,78.49 261.7,72.85 260.7,71.84 260.7,68.22 262.03,66.88 262.03,65.36 263.63,63.76 267.43,63.76 268.37,62.82 268.37,61.1 267.64,60.37 266.62,60.37 266.01,59.76 266.01,59.08 264.93,58.01 261.2,58.01 259.57,59.63 255.83,59.63 254.96,60.49 229.72,60.49 227.41,58.19 223,58.19 222.59,57.78 212.37,57.78 209.37,60.79 209.37,66.92 207.28,69 207.28,70.27 206.69,70.87 204.8,70.87 203.28,72.39 198.59,72.39 198.5,72.3 198.5,72.19 198.41,72.1 198.31,72.1 198.22,72.19 198.22,72.3 198.13,72.39 197.8,72.39 197.64,72.23 197.64,72.14 197.81,71.97 v2(197.88,71.97)
  BOTTOM w0.076: U4555.B38 196.33,74.86 196.31,74.86 196.23,74.78 196.23,74.52 196.27,74.48 196.37,74.48 196.46,74.57 196.57,74.57 196.61,74.53 196.61,74.36 196.56,74.31 196.56,73.6 196.8,73.35 196.8,73.18 196.86,73.12 197.02,73.12 197.1,73.04 197.1,72.88 197.19,72.8 197.35,72.8 197.43,72.72 197.43,72.56 197.5,72.48 197.5,71.76 197.64,71.62 197.72,71.62 197.88,71.79 v2(197.88,71.97)
  BOTTOM w0.127: CN1300.49 314.62,122.65 314.49,122.52 314.06,122.52 312.96,123.61 312.96,125.97 312.1,126.83 311.16,126.83 310.76,126.44 310.76,126.17 310.57,125.98 v3(310.38,125.98)
CLK_PCIE4_DP: length 213.9
  L3 w0.102: v2(311.13,125.95) 311,125.82 311,125.04 310.4,124.45 304.43,124.45 303.41,123.43 299.61,123.43 296.02,119.84 293.97,119.84 292.71,118.58 291.24,118.58 290.35,117.69 290.35,112.91 288.47,111.03 288.47,107.99 288.47,107.43 287.43,106.39 287.43,100.64 289.34,98.73 289.34,87.49 286.04,84.19 283.86,84.19 283.48,83.81 283.48,82.93 v2(283.57,82.84)
  L6 w0.102: v2(283.57,82.84) 283.41,83 283.41,83.35 282.95,83.82 281.41,83.82 280.51,82.92 277,82.92 276.03,83.89 265.72,83.89 264.05,82.23 264.05,81.18 261.46,78.59 261.46,72.95 260.46,71.94 260.46,68.12 261.79,66.78 261.79,65.26 263.53,63.52 267.33,63.52 268.13,62.72 268.13,61.2 267.54,60.61 266.52,60.61 265.77,59.86 265.77,59.18 264.83,58.25 261.3,58.25 259.67,59.87 255.93,59.87 255.06,60.74 229.62,60.74 227.31,58.43 222.9,58.43 222.49,58.03 212.47,58.03 209.61,60.89 209.61,67.02 207.52,69.1 207.52,70.37 206.79,71.11 204.9,71.11 203.38,72.63 197.7,72.63 197.4,72.33 197.4,71.7 v3(197.85,71.26)
  BOTTOM w0.076: v3(197.85,71.26) 197.65,71.46 197.57,71.46 197.33,71.69 197.33,72.42 196.64,73.11 196.64,73.28 196.39,73.53 196.39,74.11 196.07,74.44 196.07,74.72 196.04,74.74 196.04,74.92 U4555.C37
  BOTTOM w0.127: v2(311.13,125.95) 311,126.09 311,126.34 311.26,126.59 312,126.59 312.72,125.87 312.72,123.51 313.96,122.28 314.52,122.28 314.65,122.15 CN1300.47
CLK_PCIE6_DN: length 145.9
  TOP w0.102: v2(290.07,91.43) 290.1,91.43 290.35,91.67 290.53,91.67 291.49,92.63 296.95,92.63 297.36,93.05 297.36,96.68 297.5,96.82 297.67,96.82 297.9,96.59 v3(297.9,96.47)
  L3 w0.102: v2(196.94,71.88) 196.94,71.99 197.24,72.28 197.24,72.38 197.19,72.43 197.19,72.56 197.28,72.65 197.4,72.65 197.46,72.6 197.58,72.6 197.69,72.71 197.89,72.71 197.98,72.79 197.98,72.92 198.07,73.01 198.19,73.01 198.28,72.92 198.28,72.79 198.37,72.71 198.5,72.71 198.59,72.79 198.59,72.92 198.68,73.01 198.8,73.01 198.89,72.92 198.89,72.79 198.98,72.71 199.07,72.71 199.48,72.29 199.48,71.16 199.98,70.66 204.24,70.66 204.76,70.15 204.76,69.8 206.37,68.19 207.16,68.19 208.26,67.09 213.7,67.09 214.38,67.78 214.62,67.78 215.03,68.18 217.84,68.18 219.35,66.67 219.35,64.59 220.24,63.7 226.96,63.7 227.76,64.5 235.01,64.5 236.29,65.78 238.2,65.78 239.81,67.39 239.81,68.36 241.78,70.34 248.95,70.34 250.59,68.7 254.02,68.7 255.92,66.79 259.14,66.79 261.15,68.8 263.61,68.8 264.39,69.58 268.9,69.58 270.21,70.89 271.52,70.89 272.57,69.84 274.22,69.84 274.45,70.07 276.35,70.07 277.65,71.37 277.65,75.8 278.57,76.72 278.57,77.99 280.18,79.6 283,79.6 286.57,83.17 286.57,83.65 290.34,87.42 290.34,91.3 290.21,91.43 v2(290.07,91.43)
  BOTTOM w0.127: CN1951.53 303.44,97.05 303.31,97.18 301.66,97.18 301.25,96.77 298.89,96.77 298.79,96.67 298.1,96.67 v3(297.9,96.47) ; v2(196.94,71.88) 196.61,71.88 196.31,72.19 196.31,73.26 196.09,73.47 196.09,74.02 195.77,74.33 195.77,74.53 U4555.B37
CLK_PCIE6_DP: length 145.9
  TOP w0.102: v2(297.91,97.16) 297.79,97.04 297.41,97.04 297.15,96.77 297.15,93.14 296.86,92.85 291.4,92.85 290.44,91.89 290.27,91.89 v3(290.07,92.09)
  L3 w0.102: v2(196.93,71.26) 197.47,71.79 197.47,72.12 197.8,72.45 198.96,72.45 199.23,72.18 199.23,71.06 199.88,70.41 204.14,70.41 204.5,70.04 204.5,69.7 206.26,67.94 207.05,67.94 208.16,66.84 213.8,66.84 214.49,67.52 214.73,67.52 215.13,67.93 217.73,67.93 219.09,66.57 219.09,64.48 220.13,63.45 227.06,63.45 227.86,64.25 235.11,64.25 236.4,65.53 238.31,65.53 240.06,67.28 240.06,68.25 241.89,70.08 248.84,70.08 250.48,68.44 253.91,68.44 255.82,66.54 259.25,66.54 261.25,68.55 263.71,68.55 264.5,69.33 269.01,69.33 270.31,70.64 271.41,70.64 272.47,69.58 274.33,69.58 274.56,69.81 276.46,69.81 277.91,71.27 277.91,75.7 278.82,76.61 278.82,77.88 280.29,79.35 283.1,79.35 286.82,83.07 286.82,83.55 290.6,87.32 290.6,91.48 290.07,92 v3(290.07,92.09)
  BOTTOM w0.127: CN1951.55 303.44,97.55 303.31,97.42 301.56,97.42 301.15,97.01 298.79,97.01 298.69,96.91 298.13,96.91 298.02,97.01 298.02,97.01 297.91,97.13 v2(297.91,97.16) ; v2(196.93,71.26) 196.07,72.13 196.07,73.16 195.85,73.37 195.85,73.38 195.77,73.46 195.77,73.88 U4555.A37
CLK_PCIE_XDP_DN: length 44.6
  TOP w0.102: v2(224.81,82.4) 224.9,82.48 224.9,86.5 225.1,86.7 225.28,86.7 225.63,87.05 R4938.2
  L3 w0.102: v4(194.91,72.44) 195.11,72.64 195.11,73.22 196.75,74.86 216.25,74.86 219.62,78.22 219.62,80.05 220.82,81.25 224.4,81.25 225.03,81.88 225.03,82.18 224.88,82.33 v2(224.81,82.4)
  BOTTOM w0.076: U4555.B35 194.39,74.62 194.35,74.66 194.22,74.66 194.09,74.53 194.09,73.5 194.1,73.48 194.56,73.02 194.59,72.99 194.97,72.99 195.15,72.81 195.15,72.55 195.03,72.44 v4(194.91,72.44)
CLK_PCIE_XDP_DN_R: length 6.2
  TOP w0.102: CN4920.42 230.46,86.02 229.98,86.51 228.04,86.51 v1(227.31,87.23) 227.31,86.98 227.06,86.73 226.8,86.73 226.48,87.05 R4938.1
CLK_PCIE_XDP_DP: length 44.8
  TOP w0.102: R4937.2 225.37,86.49 225.19,86.49 225.11,86.41 225.11,82.81 v3(225.49,82.43)
  L3 w0.102: v2(194.91,71.7) 195.26,72.05 195.37,72.15 195.37,73.12 196.85,74.6 216.36,74.6 219.87,78.11 219.87,79.94 220.93,81 224.51,81 225.28,81.77 225.28,82.22 v3(225.49,82.43)
  BOTTOM w0.076: U4555.A35 194.25,73.75 194.25,73.57 194.26,73.55 194.66,73.15 195.03,73.15 195.31,72.88 195.31,72.1 195.19,71.97
  BOTTOM w0.127: 195.19,71.97 v2(194.91,71.7)
CLK_PCIE_XDP_DP_R: length 6.2
  TOP w0.102: CN4920.40 230.55,85.52 230.3,85.77 230.3,85.88 229.89,86.29 227.64,86.29 v1(227.31,85.96) 227.31,86.27 227.07,86.51 226.77,86.51 R4937.1
CLK_R3S_DEBUG: length 16.1
  TOP w0.114: R4996.1 129.95,86.05 129.95,84.57 131.6,82.92 131.6,80.78 133.77,78.62 133.77,75.67 v2(133.51,75.41)
  BOTTOM w0.114: CN375.2 134.64,77.3 134.41,77.07 134.41,76.31 v2(133.51,75.41)
CLK_R3S_KBPCI: length 132.4
  TOP w0.114: U300.54 276.31,104.93 v2(275.5,104.12) ; v2(164.04,110.58) 164.17,110.45 v1(164.17,108.06) 163.35,107.25 C7476.2 R4774.1
  L5 w0.114: v2(275.5,104.12) 275.49,104.13 274.35,104.13 271,107.48 267.74,107.48 263.45,111.77 263.45,112.43 262.72,113.16 262.72,115.62 262.03,116.31 v2(262.03,118.35)
  BOTTOM w0.114: v2(262.03,118.35) 259.93,118.35 259.73,118.56 259.72,118.56 258.79,119.49 252.18,119.49 251.45,118.75 251.04,118.75 251.04,118.75 243.01,118.75 242.18,117.92 211.68,117.92 210.7,116.93 208.68,116.93 169.45,116.93 164.04,111.52 v2(164.04,110.58)
CLK_R3S_TPM: length 11.4
  TOP w0.114: v2(124.37,154.29) 120.94,150.86 R4997.1
  BOTTOM w0.114: U3500.21 v1(123.15,153.22) 123.15,153.67 C3501.1 124.32,154.24 v2(124.37,154.29)
CLK_TPM_DEBUG: length 152
  TOP w0.076: v2(182.07,93.26) 181.01,93.26 179.55,94.72 179.55,95.37 179,95.92 177.71,95.92 177.35,96.28 176.8,96.28 176.34,96.73 176.34,98.16 175.83,98.66 175.83,103.52 176.87,104.55 177.15,104.83 177.15,105.09
  TOP w0.114: 127.79,115.05 133.64,115.05 135.03,113.65 135.03,108.44 135.67,107.81 137.32,107.81 141.3,111.79 174.84,111.79 177.28,109.35 177.28,106.05 177.15,105.92 177.15,105.09 ; 127.79,115.05 126.91,115.94 126.91,126.6 119.67,133.84 119.67,141.59 v1(120.94,142.86) R4997.2 ; 127.79,115.05 127.79,112.25 126.91,111.36 126.91,103.49 123.83,100.42 122.31,100.42 122.13,100.24 122.13,96.17 122.51,95.79 124.42,95.79 125.86,94.35 128,94.35 129.54,92.8 129.54,87.31 R4996.2
  BOTTOM w0.076: v2(182.07,93.26) 182,93.26 U4555.AP15
CLKREQ_PCIE2_N: length 239.3
  TOP w0.102: R4711.2 159.25,80.11 159.25,81.04 160.15,81.94 160.15,83.69 v3(159.98,83.86)
  L5 w0.102: v2(262.62,120.76) 262.62,119.95 261.02,118.35 261.02,113.14 262.25,111.91 262.25,111.27 262.29,111.23 270.12,103.4 272.14,103.4 272.16,103.37 272.25,103.37 274.96,100.67 283.15,100.67 283.62,100.19 283.62,99.34 286.33,96.63 288.27,96.63 290.86,94.04 290.86,84.21 v2(290.58,83.93)
  L6 w0.076: 174.99,84.88 175,84.88 175.01,84.89 175.57,84.89 v2(175.88,84.58)
  L6 w0.102: 174.99,84.88 174.28,84.88 173.73,84.33 171.93,84.33 171.4,83.8 169.52,83.8 169.37,83.8 169.36,83.8 169.18,83.8 168.59,84.39 168.54,84.39 165.92,84.39 165.57,84.04 163.03,84.04 162.81,84.26 161.53,84.26 161.22,84.57 160.68,84.57 v3(159.98,83.86) 159.98,82.92 159.81,82.75 157.98,82.75 157.66,83.07 156.06,83.07 155.61,82.61 155.61,82.29 155.24,81.92 154.11,81.92 153.68,82.36 153.68,88.89 v3(155.1,90.31)
  BOTTOM w0.076: v2(175.88,84.58) 176.17,84.88 U4555.Y5
  BOTTOM w0.102: Q802.3 290.58,80.79 v2(290.58,83.93) ; v3(155.1,90.31) 154.62,90.31 151.07,93.85 151.07,97.27 150.58,97.75 150.58,104 151.56,104.98 151.56,109.02 154.27,111.73 157.62,111.73 166.83,120.94 207.57,120.94 208.77,122.14 240.13,122.14 240.18,122.19 241.4,123.4 251.43,123.4 252.17,122.66 259.07,122.66 260.13,121.6 261.4,121.6 262.24,120.76 v2(262.62,120.76)
CLKREQ_PCIE3_N: length 172.6
  TOP w0.102: U400.48 289.89,107.71 v2(289.76,107.58) ; v2(168.8,105.89) 168.8,105.28 169.52,104.56 169.52,98.61 170.71,97.42 170.71,94.34 170.04,93.67 170.04,90.34 170.63,89.75 170.63,88.17 169.94,87.48 v2(169.94,86.79)
  L5 w0.102: v2(289.76,107.58) 289.76,106.86 284.87,101.97 279.89,101.97 279.31,101.38 278.16,101.38 277.06,102.47 274.16,102.47 272.76,103.88 272.55,104.08 272.46,104.08 272.43,104.11 272.14,104.11 270.42,104.11 262.96,111.57 262.96,112.21 262.16,113.02 262.16,114.89 v2(262.29,115.02)
  BOTTOM w0.076: v2(169.94,86.79) 170.17,87.03 170.65,87.03 170.69,86.98 171.39,86.98 171.64,87.23 173.41,87.23 U4555.AD1
  BOTTOM w0.102: v2(168.8,105.89) 168.8,106.93 168.16,107.57 168.16,109.92 172.52,114.29 207.59,114.29 211.8,114.28 212.43,114.91 243.42,114.91 244.61,116.1 258.34,116.1 258.88,115.56 261.8,115.56 262.29,115.07 v2(262.29,115.02) ; R4798.2 165.06,89.46 165.64,88.89 165.64,88.65 166.06,88.23 166.06,87.66 166.32,87.4 169.03,87.4 169.64,86.79 v2(169.94,86.79)
CLKREQ_PCIE4_N: length 232
  TOP w0.102: R1310.1 314.74,127.03 Q1301.3 313.05,128.64 311.94,128.64 v1(311.59,128.99) 311.23,128.64 309.4,128.64 308.77,129.27 308.77,131.81 v2(309.02,132.07)
  L3 w0.102: v2(309.02,132.07) 308.2,131.24 306.41,131.24 306.1,131.56 296.58,131.56 292.39,127.36 292.39,126.79 288.79,123.2 285.98,123.2 283.37,120.59 283.37,116.19 281.03,113.85 268.99,113.85 267.19,112.05 267.19,111.2 265.61,109.62 265.61,106.94 263.91,105.24 263.91,104.1 260.89,101.08 258.64,101.08 258.37,101.35 v2(257.46,101.35)
  L5 w0.076: 186.93,76 186.01,76.92 185.5,76.92 184.56,77.86 184.56,79.06 184.27,79.35 178.95,79.35 178.16,80.14 178.16,80.91 177.94,81.13 176.97,81.13 176.89,81.05 176.07,81.05 176.05,81.07 175.5,81.07 175.37,80.94 175.37,80.93 175.35,80.91 172.93,80.91 v4(172.73,81.11)
  L5 w0.102: 186.93,76 203.29,76 204.38,74.91 206.48,74.91 207.62,73.77 223.07,73.77 224,74.7 227.24,74.7 228.72,76.18 249.71,76.18 250.98,77.46 256.5,77.46 257.84,76.11 259.13,76.11 259.43,76.42 259.43,78.57 256.8,81.21 256.8,81.26 256.8,88.9 254.79,90.92 252.59,90.92 250.22,93.28 250.22,97.65 253.27,100.7 256.81,100.7 v2(257.46,101.35)
  BOTTOM w0.076: U4555.N1 v4(172.73,81.11) 172.5,81.11 171.48,80.08 169.87,80.08 169.58,80.38
  BOTTOM w0.102: R4705.2 154.76,76.82 156.5,76.82 157.13,76.19 159.16,76.19 159.8,76.82 160.74,76.82 161.37,77.46 163.86,77.46 164.34,77.94 165.75,77.94 168.19,80.38 169.58,80.38
CLKREQ_PCIE4_R_N: length 12.1
  TOP w0.102: R1304.2 310.59,127.37 v1(311.44,127.37) 311.64,127.37 312.67,126.33 Q1301.2 312.95,126.18 R1310.2 315.75,126.1 316.52,125.33 v2(318.17,125.33)
  BOTTOM w0.102: v2(318.17,125.33) 317.94,125.33 316.25,123.65 CN1300.53
CLKREQ_PCIE5_N: length 25
  TOP w0.102: R4712.2 155.39,83.17 156.12,82.44 v3(156.12,82.43)
  L6 w0.102: v2(175.99,82.61) 175.67,82.61 175.15,82.09 174.25,82.09 173.72,81.55 172.56,81.55 171.05,80.05 170.29,80.05 170.26,80.07 159.99,80.07 157.2,82.87 156.55,82.87 v3(156.12,82.43)
  BOTTOM w0.076: v2(175.99,82.61) 175.99,82.61 175.99,82.9 176.17,83.08 U4555.U5
CLKREQ_PCIE6_N: length 210.7
  TOP w0.102: v2(167.93,63.61) 166.48,65.05 166.48,66.58 v1(165.64,67.42) 165.13,67.93 165.13,68.57 165.74,69.17 166.12,69.17 166.88,69.94 166.88,70.57 168.98,72.66 168.98,72.98 167.04,74.92 167.04,75.83 167.77,76.57 v2(167.77,81.87) ; v2(275.45,68.59) 275.45,70.41 274.85,71.02 274.85,81.73 275.85,82.74 280.12,82.74 280.91,83.53 287.45,83.53 287.86,83.93 289.85,83.93 290.18,84.26 290.18,85.76 289.34,86.6 289.34,88.25 v2(289.85,88.76)
  L5 w0.102: v2(167.93,63.61) 170.64,63.61 177.44,56.8 195.31,56.8 196.48,55.63 222.15,55.63 223.63,57.11 230.61,57.11 231.23,57.72 240.77,57.72 242.22,56.27 250.67,56.27 250.72,56.32 251.81,57.4 252,57.6 259.63,57.6 263.99,61.96 265.19,61.96 265.82,62.59 265.82,63.06 266.66,63.9 267.34,64.58 267.34,65.94 268.18,66.79 269.58,66.79 269.91,67.12 271.67,67.12 273.38,68.83 275.21,68.83 v2(275.45,68.59)
  BOTTOM w0.076: 171.46,82.51 171.69,82.74 171.69,82.75 171.93,82.99 172.9,82.99 172.99,82.9 173.89,82.9 174.19,82.6 U4555.T2
  BOTTOM w0.102: R4715.2 160.77,81.34 161.09,81.02 161.09,80.61 161.96,79.74 164.07,79.74 164.82,80.5 165.82,80.5 166.73,81.42 167.32,81.42 v2(167.77,81.87) 168.09,82.2 171.14,82.2 171.46,82.51 ; CN1951.52 295.22,96.8 293.99,95.57 288.91,95.57 287.56,94.22 287.56,89.9 288.7,88.76 v2(289.85,88.76)
COMBO_GPI: length 19.9
  TOP w0.254: R604.2 305.21,52.44 v2(304.96,52.69) C605.1 ; U501.47 299.6,63.61 v2(299.45,63.76)
  L6 w0.254: v2(304.96,52.69) 306.36,54.09 306.36,61.94 304.53,63.76 v2(299.45,63.76)
COMBO_JACK_DET: length 74.5
  TOP w0.102: R603.2 292.6,52.48 v2(292.64,52.44) 292.61,52.41 v1(291.93,52.41) 291.93,53.38 292.62,54.07 Q600.1
  L5 w0.102: JACK600.2 322.49,6.26 322.49,7.22 321.22,8.49 318.68,8.49 314.3,12.87 314.3,48.73 311.84,51.19 293.88,51.19 v2(292.64,52.44)
CPPWR_EN: length 343.7
  TOP w0.102: R356.1 258.91,104.99 259.31,104.59 v2(259.42,104.59) 260.04,104.59 260.34,104.89 262.05,104.89 U300.107 262.84,104.93 263.05,105.14 263.05,105.9 263.3,106.16 263.71,106.16 263.96,105.9 263.96,103.34 265.84,101.46 265.84,99.93 v2(266.35,99.43) ; v2(270.11,68.18) 270.84,67.46 R2593.2
  L5 w0.102: v2(266.35,99.43) 266.07,99.15 266.07,91.95 266.71,91.32 266.71,88.29 267.54,87.45 267.54,86.52 267.95,86.12 267.95,81.44 v2(269.02,80.38) ; v2(259.42,104.59) 258.88,105.13 258.88,115.3 259.17,115.59 259.17,118.73 260.84,120.4 260.84,121.4 260.33,121.91 260.33,127.42 v2(261.02,128.1)
  L6 w0.102: v2(107.59,130.58) 106.79,130.58 105.52,129.31 105.52,124.68 104.1,123.26 104.1,114.87 103.47,114.24 103.47,110.27 102.19,108.99 102.19,103.31 95.22,96.35 92.15,96.35 92.15,96.35 89.23,93.43 88.23,93.43 86.37,91.57 83.23,91.57 82.48,90.82 80.7,90.82 79.05,89.17 73.35,89.17 73.14,89.39 72.65,89.88 54.39,89.88 51.98,87.46 50.34,87.46 48.42,85.54 41.83,85.54 40.01,83.73 40.01,79.77 41.11,78.66 v3(41.11,78.41) ; v2(269.02,80.38) 269.02,79.13 268.31,78.42 268.31,70.65 267.06,69.4 267.06,67.8 267.55,67.31 269.24,67.31 v2(270.11,68.18)
  BOTTOM w0.102: v3(41.11,78.41) 41.11,78.49 41.73,79.1 U2511.8 ; v2(107.59,130.58) 108.19,131.19 162.91,131.19 163.2,131.47 190.43,131.47 190.64,131.27 192.08,129.82 193.63,129.82 195.27,131.46 202.83,131.46 206.41,127.87 237.01,127.87 239.2,130.06 244.86,130.06 245.78,129.14 259.98,129.14 v2(261.02,128.1)
CPU_PROCHOT#: length 21.3
  TOP w0.102: v2(227.9,85.61) 227.62,85.33 226.2,85.33 225.61,84.73 225.61,83.6 225.75,83.46 225.75,83.46 225.99,83.22 226.2,83.01 227.14,83.01 227.62,82.54 227.62,82.15 228,81.77 228,80.76 227.74,80.5 v1(226.6,80.5) C4514.1 ; C4514.1 225.5,80.76 224.99,81.27 223.9,81.27 Q4501.3 223.58,80.01 R4515.1 ; C4514.1 R4517.1
  BOTTOM w0.102: U6600.30 231.01,82.48 230.98,82.51 230.98,83.74 230.54,84.19 229.3,84.19 227.9,85.59 v2(227.9,85.61)
CPU_PROCHOT#_R: length 12.5
  TOP w0.102: v4(217.23,79.03) 218.7,80.5 v1(219.62,80.5) 222.24,80.5 R4515.2
  BOTTOM w0.076: U4555.K63 212.16,79.57 212.42,79.57 212.61,79.38 213.16,79.38 213.92,78.62 214.97,78.62
  BOTTOM w0.102: 214.97,78.62 215.31,78.62 216.2,79.51 216.25,79.51 216.75,79.51 v4(217.23,79.03)
CPU_TEST1: length 7.4
  BOTTOM w0.076: 195.74,72.61 195.75,72.62 195.75,73.1 194.85,74 194.79,74.16 194.79,74.27 194.84,74.39 194.85,74.42 194.85,74.61 194.81,74.76 194.71,74.91 194.39,75.19 U4555.C35
  BOTTOM w0.102: 195.74,72.61 195.74,71.61 v1(195.87,71.49) 195.95,71.4 195.95,70.6 195.06,69.71 R4775.1
CPU_TEST2: length 7
  BOTTOM w0.076: 195.55,72.7 195.55,73.06 194.68,73.93 194.68,73.97 194.62,74.13 194.62,74.23 194.61,74.26 194.62,74.3 194.65,74.38 194.66,74.39 194.68,74.45 194.68,74.59 194.66,74.68 194.45,74.89 194.24,74.89 193.83,75.31 U4555.C34
  BOTTOM w0.102: 195.55,72.7 195.55,71.86 195.36,71.66 195.36,70.85 v1(194.98,70.47) 194.26,70.47 R4791.1
CPU_TEST3: length 33.8
  TOP w0.102: v3(153,97.2) 153.4,96.8 R4800.1
  L6 w0.102: v2(178.29,90.57) 178.27,90.57 177.27,91.57 177.27,93.67 177.02,93.92 176.69,93.92 176.02,93.25 175.73,93.25 175.55,93.08 174.37,93.08 173.71,93.74 173.71,94.62 170.5,97.83 161.65,97.83 161.37,98.11 154.82,98.11 153.92,97.2 v3(153,97.2)
  BOTTOM w0.102: v2(178.29,90.57) 178.07,90.57 U4555.AK8
CPU_TEST4: length 35.6
  TOP w0.102: R4801.1 155.88,96.64 v1(155,97.52) 155,97.49 v2(153.43,99.06)
  L6 w0.102: v2(153.43,99.06) 153.51,98.98 161.5,98.98 161.94,98.54 170.39,98.54 174.66,94.27 177.04,94.27 177.46,93.85 177.46,91.65 178.15,90.97 v2(178.73,90.97)
  BOTTOM w0.102: v2(178.73,90.97) 177.86,90.97 U4555.AL8
CR_GPIO: length 2.8
  TOP w0.102: R802.1 297.29,71.87 v1(296.53,71.87) 296.38,71.87 295.67,71.16 U800.28
CR_PWREN#: length 161.6
  L3 w0.102: v2(258.99,78.06) 259.52,78.6 261.11,78.6 261.31,78.8 263.35,78.8 263.51,78.8 264.28,78.04 267.44,78.04 268.61,79.21 270.26,79.21 271.38,78.09 274.33,78.09 274.81,77.61 276.49,77.61 v2(277.27,76.82)
  L5 w0.102: v2(279.43,65.52) 279.43,65.64 280.17,66.38 280.17,67.51 281.41,68.75 281.41,73.53 281.41,73.83 280.01,75.23 278.86,75.23 v2(277.27,76.82) ; v2(258.99,78.06) 258.99,78.37 256.47,80.88 244.76,80.88 244.13,81.52 244.13,82.64 240.81,85.96 240.81,86.6 239.79,87.61 239.15,87.61 239.15,87.62 225.94,87.62 221.67,83.35 214.46,83.35 214.46,83.35 214.13,83.35 214.13,83.35 213.74,83.35 213.74,83.35 212.7,83.35 212.38,83.68 210.04,83.68 208.67,82.31 208.2,82.31 208.1,82.41 207.45,82.41 205.7,80.66 191.66,80.66 188.15,84.16 183.95,84.16 183.55,84.57 183.55,89.9 183.04,90.41 182.53,90.41 182.4,90.28 180.78,90.28 180.63,90.13 180.14,90.13 179.74,90.53 179.74,94.35 179.23,94.85 178.85,94.85 177.39,96.31 174.97,96.31 172.88,94.22 169.79,94.22 v2(169.32,93.75)
  BOTTOM w0.102: R4720.2 166.57,94.02 v1(166.78,93.81) 166.94,93.97 169.11,93.97 v2(169.32,93.75) 169.98,93.1 173.54,93.1 U4555.AP1 ; v2(279.43,65.52) 280.31,65.52 281.67,64.15 281.67,63.41 282.86,62.22 R811.1 283.83,61.13 Q800.1
CR_RST#: length 163.7
  TOP w0.102: D801.2 296.51,77.39 298.18,79.06 v2(298.18,79.51)
  L3 w0.102: v2(241.71,81.24) 241.97,80.99 248.35,80.99 250.87,78.47 255.71,78.47 256.04,78.8 261.03,78.8 261.23,79 263.26,79 263.6,79 264.36,78.24 267.29,78.24 268.56,79.51 270.42,79.51 271.61,78.32 274.53,78.32 275.01,77.84 277.15,77.84 279.18,79.87 279.18,80.63 279.69,81.14 283.75,81.14 v2(285.66,83.04)
  L5 w0.102: v3(167.11,81.9) 168.8,83.59 171.54,83.59 171.68,83.45 175.48,83.45 175.87,83.07 178.05,83.07 178.49,82.62 178.49,82.38 178.9,81.98 178.9,80.55 179.47,79.98 184.85,79.98 185.02,80.15 186.01,80.15 186.47,79.69 186.47,79.27 187.5,78.24 203.94,78.24 204.45,77.73 204.45,77.44 204.65,77.25 205.56,77.25 206.83,75.98 207.92,75.98 209.07,74.84 222.55,74.84 223.9,76.19 226.82,76.19 228.2,77.56 232.51,77.56 232.93,77.98 238.91,77.98 v2(238.92,77.97)
  L6 w0.102: v2(241.71,81.24) 238.92,78.45 v2(238.92,77.97)
  BOTTOM w0.076: U4555.U2 174.18,83.35 173.89,83.06 173.06,83.06 172.97,83.15 171.85,83.15 171.24,82.55 170.53,82.55
  BOTTOM w0.102: 170.53,82.55 167.76,82.55 v3(167.11,81.9) 166.71,81.9 165.77,80.96 165.52,80.7 164.74,80.7 164.29,80.25 R4707.2 ; v2(298.18,79.51) 295.79,79.51 290.86,84.44 287.05,84.44 v2(285.66,83.04)
CR_WAKE#: length 225.9
  TOP w0.102: v2(297.14,76.13) 296.98,76.13 296.29,75.45 296.29,74.66 295.18,73.55 295.18,72.89 U800.32 ; v2(165.01,87.87) 164.6,88.28 v1(164.6,98.03) 164.6,98.69 v2(164.12,99.17)
  L3 w0.102: v2(241.08,81.9) 241.08,81.21 241.57,80.72 248.04,80.72 250.8,77.96 255.43,77.96 258.22,75.17 259.11,75.17 259.67,75.73 259.67,77.84 260.18,78.34 261.14,78.34 261.4,78.6 263.43,78.6 264.19,77.84 267.54,77.84 268.69,78.98 270.14,78.98 271.25,77.86 274.02,77.86 274.73,77.15 v2(275.8,77.15)
  L5 w0.102: v2(241.08,81.9) 241.08,82.41 241.59,82.92 241.59,84.89 240.6,85.87 240.6,86.51 239.75,87.37 225.98,87.37 221.73,83.12 215.4,83.12 214.51,82.23 212.63,82.23 212.5,82.36 209.43,82.36 208.64,81.57 206.88,81.57 205.78,80.47 191.32,80.47 187.91,83.88 185.23,83.88 184.67,83.32 184,83.32 183.36,83.97 183.36,89.82 182.96,90.22 182.61,90.22 182.48,90.09 180.86,90.09 180.7,89.94 180.06,89.94 179.55,90.45 179.55,94.27 179.15,94.66 178.77,94.66 177.31,96.12 175.29,96.12 171.21,92.04 171.21,90.62 169.09,88.5 165.64,88.5 v2(165.01,87.87) ; v2(275.8,77.15) 276,77.35 276.66,77.35 277,77.69 278.53,77.69 279.29,76.93 281.26,76.93 284.46,80.13 284.46,81.19 287.72,84.45 289.35,84.45 291.6,82.2 292.74,82.2 297.14,77.81 v2(297.14,76.13)
  BOTTOM w0.076: U4555.AH2 173.73,88.89 173.09,88.89 172.98,89.01 171.5,89.01 170.78,88.29 170.61,88.29 170.43,88.11 169.92,88.11 169.36,88.67 169.22,88.67
  BOTTOM w0.102: R4825.1 163.61,98.28 164.12,98.79 v2(164.12,99.17) 163.35,99.17 162.85,99.68 157.26,99.68 155.63,98.05 155.63,94.68 157.36,92.95 158.35,92.95 R4737.1 158.9,92.39 160.61,92.39 161.2,91.81 161.2,91.45 161.78,90.86 165.01,90.86 165.11,90.76 166.59,90.76 167.76,89.59 167.82,89.53 167.82,88.96 168.11,88.67 169.22,88.67
