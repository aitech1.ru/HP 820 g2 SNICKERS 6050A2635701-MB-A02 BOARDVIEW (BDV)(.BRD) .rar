# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ<40>: length 77.6
  L6 w0.102: v2(207.06,100.2) 207.7,100.2 208.62,101.12 210.83,101.12 216.53,106.82 218.24,106.82 222.41,110.99 236.31,110.99 240.4,115.09 240.66,115.09 245.02,119.46 245.02,120.42 250.41,125.82 250.41,134.95 250.52,135.05 250.98,135.05 251.08,135.16 251.08,135.31 250.98,135.42 250.52,135.42 250.41,135.53 250.41,135.68 250.52,135.79 250.96,135.79 251.07,135.9 251.07,136.05 250.96,136.16 250.52,136.16 250.41,136.27 250.41,138.09 250.55,138.23 250.74,138.23 250.87,138.09 v3(250.87,138)
  BOTTOM w0.076: U4555.AY54 206.54,96.52 206.54,97.77 206.47,97.84 206.47,99.6 v2(207.06,100.2)
  BOTTOM w0.114: v3(250.87,138) 251.6,137.27 CN4100.39
M_A_DQ<41>: length 78.5
  L6 w0.102: v3(250.93,136.68) 250.93,136.81 251.08,136.96 251.3,136.96 251.45,136.81 251.45,134.77 251.35,134.66 250.86,134.66 250.77,134.57 250.77,134.38 250.86,134.29 251.35,134.29 251.45,134.18 251.45,134.03 251.35,133.92 250.89,133.92 250.78,133.81 250.78,133.66 250.89,133.55 251.34,133.55 251.45,133.44 251.45,133.23 251.34,133.12 250.91,133.12 250.77,132.98 250.77,132.01 250.77,132.01 250.88,131.9 251.33,131.9 251.44,131.79 251.44,131.64 251.33,131.53 250.88,131.53 250.77,131.42 250.77,131.27 250.88,131.16 251.34,131.16 251.45,131.06 251.45,130.9 251.34,130.8 250.88,130.8 250.77,130.69 250.77,125.67 245.38,120.28 245.38,119.31 240.8,114.74 240.66,114.74 236.56,110.64 222.56,110.64 218.39,106.46 216.67,106.46 209.96,99.75 207.22,99.75 v2(207.05,99.58)
  BOTTOM w0.076: U4555.AW54 206.84,96.16 206.84,96.84 206.75,96.93 206.71,96.97 206.71,97.84 206.63,97.91 206.63,99.16 v2(207.05,99.58)
  BOTTOM w0.114: CN4100.41 251,136.61 v3(250.93,136.68)
M_A_DQ<42>: length 78.3
  L6 w0.076: 209.41,103.93 209.38,103.93 207.34,101.89 206.5,101.89 v2(206.43,101.82)
  L6 w0.102: v3(247.61,138.06) 247.91,137.76 247.91,136.07 248.42,135.56 248.42,130 248.31,129.9 247.91,129.9 247.8,129.79 247.8,129.64 247.91,129.53 248.31,129.53 248.42,129.42 248.42,129.27 248.31,129.16 247.92,129.16 247.81,129.05 247.81,128.9 247.92,128.79 248.31,128.79 248.42,128.68 248.42,128.53 248.31,128.42 247.97,128.42 247.86,128.31 247.86,128.16 247.97,128.05 248.31,128.05 248.42,127.95 248.42,127.79 248.31,127.69 247.96,127.69 247.85,127.58 247.85,127.43 247.96,127.32 248.31,127.32 248.42,127.21 248.42,126.64 243.03,121.25 243.03,120.77 235.37,113.12 221.72,113.12 217.41,108.81 215.7,108.81 211.03,104.15 209.62,104.15 209.41,103.93
  BOTTOM w0.076: v2(206.43,101.82) 205.88,101.82 204.96,100.9 204.96,100.8 204.96,96.74 205.19,96.52 U4555.AY52
  BOTTOM w0.114: CN4100.51 248,137.67 v3(247.61,138.06)
M_A_DQ<43>: length 79.1
  L6 w0.102: v3(247.47,136.52) 247.35,136.4 247.35,135.25 247.46,135.14 247.93,135.14 248.04,135.04 248.04,134.88 247.93,134.78 247.46,134.78 247.35,134.67 247.35,134.52 247.46,134.41 247.95,134.41 248.06,134.3 248.06,134.15 247.95,134.04 247.46,134.04 247.35,133.93 247.35,133.78 247.46,133.67 247.95,133.67 248.06,133.56 248.06,133.41 247.95,133.3 247.46,133.3 247.35,133.2 247.35,133.04 247.46,132.93 247.95,132.93 248.06,132.83 248.06,132.67 247.95,132.57 247.46,132.57 247.35,132.46 247.35,132.31 247.46,132.2 247.95,132.2 248.06,132.09 248.06,131.94 247.95,131.83 247.46,131.83 247.35,131.72 247.35,131.57 247.46,131.46 247.95,131.46 248.06,131.35 248.06,131.2 247.95,131.09 247.46,131.09 247.35,130.98 247.35,130.8 247.46,130.68 247.75,130.68 247.86,130.58 247.86,130.42 247.75,130.31 247.51,130.31 247.35,130.16 247.35,126.08 242.67,121.4 242.67,120.92 235.22,113.47 221.57,113.47 217.27,109.17 215.55,109.17 210.88,104.5 209.69,104.5 207.91,102.72 v2(207.33,102.72)
  BOTTOM w0.076: v2(207.33,102.72) 206.3,102.72 204.8,101.22 204.8,96.58 204.87,96.51 204.9,96.45 204.95,96.35 204.95,96.35 204.97,96.29 204.97,96.08 205.19,95.87 U4555.AW52
  BOTTOM w0.114: CN4100.53 247.4,136.45 v3(247.47,136.52)
M_A_DQ<44>: length 79.1
  L6 w0.076: v2(207.04,98.33) 208.27,98.33 208.43,98.17 208.88,98.17
  L6 w0.102: 208.88,98.17 216.82,106.11 218.53,106.11 222.71,110.28 236.71,110.28 240.8,114.38 240.95,114.38 245.73,119.16 245.73,119.71 245.73,120.13 251.12,125.52 251.12,130.08 251.81,130.76 251.81,131.97 251.5,132.27 251.3,132.27 251.15,132.41 251.15,132.62 251.3,132.76 251.49,132.76 251.81,133.08 251.81,133.35 251.81,139.37 251.63,139.55 251.01,139.55 v3(250.83,139.37)
  BOTTOM w0.076: U4555.AV54 206.44,95.22 206.44,95.33 207,95.9 207,96.91 206.87,97.04 206.87,98.16 v2(207.04,98.33)
  BOTTOM w0.114: v3(250.83,139.37) 251.3,139.85 CN4100.40
M_A_DQ<45>: length 79.9
  L6 w0.076: 209.38,102.42 209.04,102.42 207.73,101.1 207.3,101.1 206.63,100.44 206.63,99.1 v2(205.62,98.08)
  L6 w0.102: v3(250.75,140.82) 250.75,141.04 250.65,141.14 250.16,141.14 250.06,141.04 250.06,125.96 244.66,120.57 244.66,119.6 240.51,115.45 240.01,115.45 236.05,111.48 222.4,111.48 218.09,107.18 216.38,107.18 211.63,102.42 209.38,102.42
  BOTTOM w0.076: U4555.AU54 205.78,94.56 205.56,94.78 205.56,95.57 205.59,95.63 205.62,95.71 205.65,95.76 205.65,95.97 205.62,96.02 205.58,96.13 205.58,96.26 205.62,96.36 205.62,96.36 205.65,96.41 205.65,96.91 205.31,97.25 205.31,97.77 v2(205.62,98.08)
  BOTTOM w0.114: v3(250.75,140.82) 250.7,140.87 CN4100.42
M_A_DQ<46>: length 79.5
  L6 w0.076: 209.38,103.56 209.24,103.56 207.41,101.73 207.04,101.73 206.68,101.37 v2(206.01,101.37)
  L6 w0.102: 209.38,103.56 209.62,103.79 211.18,103.79 215.85,108.46 217.56,108.46 221.87,112.76 235.52,112.76 243.38,120.63 243.38,121.1 248.77,126.5 248.77,135.7 248.26,136.22 248.26,139.19 248.79,139.72 248.79,139.86 248.5,140.16 248.36,140.16 v3(247.58,139.38)
  BOTTOM w0.076: v2(206.01,101.37) 205.69,101.37 205.13,100.81 205.13,97.2 205.48,96.84 205.48,96.45 205.41,96.29 205.41,96.09 205.43,96.04 205.44,96.04 205.48,95.95 205.48,95.93 205.48,95.8 205.46,95.75 205.43,95.7 205.3,95.56 205.19,95.22 U4555.AV52
  BOTTOM w0.114: CN4100.50 248.3,140.1 v3(247.58,139.38)
M_A_DQ<47>: length 80.3
  L6 w0.102: v3(247.51,140.83) 246.99,140.31 246.99,126.22 242.32,121.55 242.32,121.07 240.31,119.06 240.15,119.06 240.07,119.14 239.92,119.14 239.81,119.04 239.81,118.88 239.89,118.8 239.89,118.65 239.79,118.54 239.63,118.54 239.55,118.62 239.4,118.62 239.29,118.52 239.29,118.36 239.37,118.28 239.37,118.12 239.26,118.02 239.11,118.02 239.03,118.1 238.87,118.1 238.77,117.99 238.77,117.84 238.85,117.76 238.85,117.6 238.74,117.5 238.59,117.5 238.51,117.58 238.35,117.58 238.24,117.47 238.24,117.32 238.33,117.24 238.33,117.08 238.22,116.97 238.07,116.97 238.04,117.01 237.88,117.01 237.77,116.9 237.77,116.75 237.81,116.71 237.81,116.56 237.7,116.45 237.55,116.45 237.46,116.54 237.31,116.54 237.2,116.43 237.2,116.28 237.29,116.19 237.29,116.04 237.18,115.93 237.03,115.93 236.94,116.02 236.79,116.02 236.68,115.91 236.68,115.76 236.77,115.67 236.77,115.52 236.66,115.41 236.51,115.41 236.42,115.5 236.27,115.5 236.16,115.39 236.16,115.24 236.24,115.15 236.24,115 236.14,114.89 235.98,114.89 235.9,114.97 235.75,114.97 235.64,114.87 235.64,114.71 235.72,114.63 235.72,114.48 235.08,113.83 221.42,113.83 217.12,109.52 215.4,109.52 210.74,104.86 209.76,104.86 208.68,103.78 208.4,103.78 v2(208.21,103.59)
  BOTTOM w0.076: v2(208.21,103.59) 206.94,103.59 204.63,101.29 204.63,96.52 204.73,96.41 204.81,96.26 204.81,94.95 205.19,94.57 U4555.AU52
  BOTTOM w0.114: CN4100.52 247.7,141.01 v3(247.51,140.83)
M_A_DQ<48>: length 86
  L6 w0.076: v2(198.06,90.48) 198.44,90.86 198.44,93.89 198.85,94.3 200.48,94.3 200.99,94.81 200.99,95.83 201.18,96.02
  L6 w0.102: v3(242.63,138.79) 242.57,138.79 242.24,138.45 242.24,128.38 240.51,126.66 240.51,126.5 241.12,125.89 241.12,125.74 241.01,125.63 240.86,125.63 240.25,126.24 240.09,126.24 239.99,126.13 239.99,125.98 240.6,125.37 240.6,125.22 240.49,125.11 240.34,125.11 239.73,125.72 239.57,125.72 239.47,125.61 239.47,125.46 240.05,124.87 240.05,124.72 239.94,124.61 239.79,124.61 239.2,125.2 239.05,125.2 231.4,117.55 220.08,117.55 215.64,113.1 213.31,113.1 207.86,107.65 207.86,106.51 201.63,100.29 201.63,96.47 201.18,96.02
  BOTTOM w0.076: U4555.AK40 197.64,90.15 197.97,90.48 v2(198.06,90.48)
  BOTTOM w0.114: CN4100.70 242.3,139.12 v3(242.63,138.79)
M_A_DQ<49>: length 85.6
  L6 w0.076: 202.01,100.32 201.82,100.13 201.82,96.31 201.22,95.71 201.22,94.77 200.56,94.11 198.9,94.11 198.62,93.83 198.62,90.73 v2(198.97,90.37)
  L6 w0.102: v3(242.7,136.14) 242.7,136.06 243.2,135.55 243.33,135.43 243.33,133.26 243.22,133.15 243.07,133.15 242.96,133.26 242.96,135.21 242.85,135.32 242.7,135.32 242.59,135.21 242.59,128.24 241.78,127.43 241.78,125.86 240.03,124.11 238.47,124.11 238.31,123.95 238.31,123.8 238.95,123.16 238.95,123.01 238.84,122.9 238.69,122.9 238.05,123.54 237.9,123.54 237.79,123.43 237.79,123.28 238.43,122.64 238.43,122.49 238.32,122.38 238.17,122.38 237.53,123.02 237.37,123.02 231.55,117.19 220.23,117.19 215.78,112.75 213.46,112.75 208.21,107.5 208.21,106.52 202.01,100.32
  BOTTOM w0.076: v2(198.97,90.37) 198.7,90.37 198.48,90.15 U4555.AK42
  BOTTOM w0.114: v3(242.7,136.14) 242.6,136.04 CN4100.69
M_A_DQ<50>: length 83.3
  L6 w0.076: 208.1,104.76 207.94,104.61 207.79,104.61 203.36,100.17 203.36,97.11 202.62,96.37 202.62,94.45 202.21,94.04 202.21,92.79 201.99,92.57 201.54,92.57 201.2,92.23 200.56,92.23 v2(199.94,91.61)
  L6 w0.102: 208.1,104.76 214.45,111.11 216.46,111.11 220.77,115.42 233.94,115.42 244.96,126.44 244.96,135.01 245.11,135.15 245.11,138.13 244.65,138.58 244.65,139.5 244.8,139.65 245.02,139.65 245.17,139.5 245.17,138.89 v3(245.68,138.38)
  BOTTOM w0.076: U4555.AM43 199.43,91.45 199.59,91.61 v2(199.94,91.61)
  BOTTOM w0.114: CN4100.57 246.2,137.86 v3(245.68,138.38)
M_A_DQ<51>: length 82.8
  L6 w0.076: 208.35,104.51 208.26,104.41 207.86,104.41 203.62,100.18 203.62,96.91 202.79,96.07 202.79,94.38 202.38,93.97 202.38,92.64 202.11,92.37 201.58,92.37 200.93,91.72 v2(200.88,91.72)
  L6 w0.102: 208.35,104.51 214.6,110.75 216.61,110.75 220.91,115.06 234.09,115.06 245.33,126.3 245.33,127.77 245.67,128.11 245.67,128.27 245.56,128.37 245.43,128.37 245.32,128.48 245.32,128.63 245.43,128.74 245.56,128.74 245.67,128.85 245.67,129 245.56,129.11 245.48,129.11 245.33,129.26 245.33,129.34 245.46,129.48 245.62,129.48 245.73,129.59 245.73,129.74 245.62,129.85 245.42,129.85 245.32,129.95 245.32,130.17 245.42,130.27 245.66,130.27 245.76,130.38 245.76,130.53 245.66,130.64 245.43,130.64 245.32,130.75 245.32,130.9 245.43,131.01 245.66,131.01 245.76,131.11 245.76,131.27 245.66,131.37 245.43,131.37 245.32,131.48 245.32,131.63 245.43,131.74 245.66,131.74 245.76,131.85 245.76,132 245.66,132.11 245.44,132.11 245.33,132.22 245.33,132.37 245.44,132.48 245.66,132.48 245.76,132.59 245.76,132.74 245.66,132.85 245.43,132.85 245.33,132.96 245.33,133.11 245.43,133.22 245.66,133.22 245.76,133.32 245.76,133.33 245.76,133.52 245.66,133.63 245.43,133.63 245.32,133.73 245.32,133.89 245.43,133.99 245.66,133.99 245.76,134.1 245.76,134.26 245.66,134.36 245.41,134.36 245.32,134.45 245.32,134.64 245.41,134.73 245.67,134.73 245.76,134.83 245.76,135 245.67,135.1 245.56,135.1 245.46,135.19 245.46,135.37 245.56,135.47 245.66,135.47 245.76,135.58 245.76,135.73 245.66,135.84 245.55,135.84 245.46,135.92 245.46,136.12 245.55,136.2 245.66,136.2 245.76,136.31 245.76,136.92 v3(245.64,137.05)
  BOTTOM w0.076: U4555.AM45 200.68,91.72 v2(200.88,91.72)
  BOTTOM w0.114: v3(245.64,137.05) 245.6,137.01 CN4100.59
M_A_DQ<52>: length 83.2
  L6 w0.076: 208.57,104.39 208.43,104.25 207.93,104.25 203.87,100.19 203.87,94.79 203.17,94.09 203.17,92.93 202.3,92.06 201.7,92.06 201.47,91.84 201.47,90.66 201.24,90.42 v2(200.86,90.42)
  L6 w0.102: v3(245.74,139.7) 245.74,139.7 246.12,139.32 246.12,133.47 246.12,133.47 246.12,127.62 246.01,127.52 245.79,127.52 245.69,127.41 245.69,127.26 245.79,127.15 246.01,127.15 246.12,127.04 246.12,126.59 234.24,114.7 221.06,114.7 216.76,110.4 214.76,110.4 210.01,105.65 209.83,105.65 208.57,104.39
  BOTTOM w0.076: v2(200.86,90.42) 200.68,90.42 200.41,90.15 U4555.AK45
  BOTTOM w0.114: v3(245.74,139.7) 245.94,139.49 246.31,139.49 246.5,139.69 CN4100.56
M_A_DQ<53>: length 84.4
  L6 w0.102: v2(199.93,90.35) 200.26,90.02 202.05,90.02 202.38,90.35 202.38,91.87 203.07,92.55 203.86,92.55 204.3,92.99 204.3,93.93 204.72,94.34 204.72,100.69 208.03,104.01 208.56,104.01 209.8,105.26 210.12,105.26 214.91,110.04 216.9,110.04 221.21,114.35 234.38,114.35 246.47,126.44 246.47,140.57 246.03,141.02 v3(245.7,141.02)
  BOTTOM w0.114: v3(245.7,141.02) 245.69,141.02 245.69,141.03 245.9,141.24 CN4100.58 ; U4555.AK43 199.43,90.15 199.63,90.35 v2(199.93,90.35)
M_A_DQ<54>: length 84.6
  L6 w0.076: 200.66,96.16 200.66,94.72 200.41,94.48 198.18,94.48 197.68,93.98 197.68,92.17 v2(198.06,91.79)
  L6 w0.102: 200.66,96.16 200.66,99.99 201.46,100.8 201.79,100.8 207.5,106.5 207.5,107.8 213.17,113.46 215.49,113.46 219.93,117.9 231.25,117.9 241.88,128.53 241.88,139.05 241.33,139.6 241.33,140.92 241.67,141.26 243.39,141.26 243.6,141.05 243.6,140.3 243.44,140.15 v3(242.76,140.15)
  BOTTOM w0.076: U4555.AM40 197.67,91.45 198,91.79 v2(198.06,91.79)
  BOTTOM w0.114: CN4100.68 242.9,140.29 v3(242.76,140.15)
M_A_DQ<55>: length 84.2
  L6 w0.076: 202.1,100.05 201.98,99.93 201.98,96.24 201.38,95.64 201.38,94.7 200.36,93.68 200.36,92.96 200.09,92.69 199.92,92.69 199.05,91.82 199.05,91.82 v2(199,91.77)
  L6 w0.102: v3(242.7,137.47) 243.16,137.01 243.16,136.1 243.45,135.81 243.68,135.58 243.68,133.01 242.95,132.27 242.95,128.09 242.14,127.28 242.14,125.42 238.29,121.58 238.14,121.58 237.66,122.06 237.51,122.06 237.4,121.95 237.4,121.8 237.88,121.32 237.88,121.16 237.77,121.06 237.62,121.06 237.14,121.54 236.99,121.54 236.88,121.43 236.88,121.28 237.36,120.8 237.36,120.64 237.25,120.54 237.1,120.54 236.54,121.09 236.39,121.09 236.28,120.98 236.28,120.83 236.84,120.28 236.84,120.12 236.73,120.01 236.57,120.01 236.07,120.52 235.91,120.52 235.81,120.41 235.81,120.26 236.31,119.75 236.31,119.6 233.49,116.78 220.32,116.78 215.93,112.39 213.66,112.39 208.57,107.3 208.57,106.52 202.1,100.05
  BOTTOM w0.076: v2(199,91.77) 198.79,91.77 198.48,91.45 U4555.AM42
  BOTTOM w0.114: CN4100.67 243.2,136.97 v3(242.7,137.47)
M_A_DQ<56>: length 64.5
  L3 w0.076: v2(201.94,91.02) 202.23,91.31 202.23,91.98 203.18,92.92 203.18,93.68 203.51,94.02 203.94,94.02 204.47,94.55 204.47,96.52 203.87,97.12 203.87,97.43 204.29,97.85 204.29,102.09 204.73,102.52
  L3 w0.102: v3(203.07,139.44) 203.07,138.49 202.67,138.08 202.67,129.89 202.78,129.78 203.05,129.78 203.13,129.71 203.13,129.5 203.05,129.43 202.78,129.43 202.67,129.32 202.67,129.18 202.78,129.07 203.46,129.07 203.56,128.97 203.56,128.82 203.46,128.72 202.78,128.72 202.67,128.61 202.67,128.46 202.78,128.36 203.47,128.36 203.57,128.26 203.57,128.11 203.47,128 202.78,128 202.67,127.9 202.67,127.75 202.78,127.65 203.42,127.65 203.52,127.55 203.52,127.4 203.42,127.29 202.84,127.29 202.74,127.19 202.74,127.04 202.84,126.94 203.6,126.94 203.71,126.83 203.71,122.05 208.72,117.05 208.72,106.52 204.73,102.52
  BOTTOM w0.076: U4555.AM46 201.34,91.45 201.78,91.02 v2(201.94,91.02)
  BOTTOM w0.114: CN4100.194 202.7,139.81 v3(203.07,139.44)
M_A_DQ<57>: length 64
  L3 w0.076: 204.35,102.63 204.13,102.4 204.13,97.98 203.71,97.56 203.71,97.05 204.3,96.45 204.3,94.81 203.72,94.23 203.12,94.23 203.12,94.23 202.74,94.23 202.39,93.88 202.39,92.56 202.04,92.21 201.67,92.21 201.45,91.99 201.45,90.91 v2(201.91,90.45)
  L3 w0.102: v3(203.14,141) 203.14,141.3 203.04,141.4 202.42,141.4 202.32,141.3 202.32,140.51 202.42,140.4 202.58,140.4 202.68,140.3 202.68,140.15 202.58,140.05 202.42,140.05 202.32,139.94 202.32,139.8 202.42,139.69 202.54,139.69 202.64,139.59 202.64,139.44 202.54,139.34 202.42,139.34 202.32,139.23 202.32,139.08 202.42,138.98 202.62,138.98 202.72,138.88 202.72,138.72 202.62,138.63 202.42,138.63 202.32,138.52 202.32,126.02 202.51,125.83 202.66,125.83 203,126.17 203.15,126.17 203.25,126.06 203.25,125.91 202.91,125.57 202.91,122.35 208.36,116.9 208.36,106.64 204.35,102.63
  BOTTOM w0.076: U4555.AK46 201.31,90.15 201.61,90.45 v2(201.91,90.45)
  BOTTOM w0.114: v3(203.14,141) 203.3,141.16 CN4100.192
M_A_DQ<58>: length 61.8
  L3 w0.076: 208.9,104.44 208.72,104.26 208.72,103.5 206.14,100.93 206.14,97.16 205.61,96.63 205.61,92.93 204.8,92.12 204.49,92.12 204.04,91.67 v2(203.78,91.67)
  L3 w0.102: 208.9,104.44 210.66,106.2 210.66,117.85 205.66,122.86 205.66,139.48 205.65,139.48 205.65,139.67 205.31,140.01 205.31,141.15 205.39,141.23 205.61,141.23 205.71,141.13 205.71,140.24 206.45,139.51 v3(206.45,139.23)
  BOTTOM w0.076: U4555.AM49 203.51,91.67 v2(203.78,91.67)
  BOTTOM w0.114: v3(206.45,139.23) 206.9,139.68 CN4100.180
M_A_DQ<59>: length 60.9
  L3 w0.102: v2(203.76,90.27) 204.11,89.93 206.72,89.93 207.09,90.3 207.09,94.32 207.44,94.68 207.44,95.87 207.26,96.06 207.26,97.96 207.89,98.59 207.89,101.85 209.35,103.31 209.35,103.35 211.73,105.73 211.73,118.29 207.26,122.76 207.26,132.22 206.89,132.59 206.89,140.4 v3(206.4,140.89)
  BOTTOM w0.114: v3(206.4,140.89) 206.3,140.99 CN4100.182 ; v2(203.76,90.27) 203.39,90.27 203.27,90.15 U4555.AK49
M_A_DQ<60>: length 63.4
  L3 w0.076: v2(202.82,91.72) 202.82,91.96 203.33,92.47 203.96,92.47 204.32,92.83 204.32,93.94 204.8,94.42 204.8,97.56 204.63,97.72 204.63,101.54 205.17,102.07
  L3 w0.102: v3(203.1,137.65) 203.1,138.01 203.58,138.49 203.58,140.26 203.69,140.36 203.84,140.36 203.94,140.26 203.94,138.24 203.59,137.89 203.59,135.44 204.12,134.91 204.32,134.91 204.42,134.81 204.42,134.65 204.32,134.55 204.12,134.55 204.01,134.45 204.01,134.3 204.12,134.2 204.31,134.2 204.42,134.09 204.42,133.95 204.31,133.84 204.12,133.84 204.01,133.74 204.01,133.59 204.12,133.49 204.31,133.49 204.42,133.38 204.42,133.23 204.31,133.13 204.12,133.13 204.01,133.03 204.01,131.84 204.42,131.43 204.42,122.35 209.43,117.34 209.43,106.34 205.17,102.07
  BOTTOM w0.076: v2(202.82,91.72) 202.66,91.72 202.39,91.45 U4555.AM48
  BOTTOM w0.114: v3(203.1,137.65) 203.6,137.16 CN4100.191
M_A_DQ<61>: length 62.8
  L3 w0.076: v2(202.84,90.44) 202.4,90.88 202.4,91.86 203.17,92.63 203.89,92.63 204.12,92.86 204.12,93.97 204.63,94.49 204.63,97.43 204.46,97.61 204.46,101.79 205.09,102.43
  L3 w0.102: v3(203.1,136.12) 203.03,136.04 203.03,135.26 203.13,135.15 203.37,135.15 203.47,135.05 203.47,134.9 203.37,134.8 203.13,134.8 203.03,134.69 203.03,134.55 203.13,134.44 203.55,134.44 203.65,134.34 203.65,134.19 203.55,134.09 203.13,134.09 203.03,133.98 203.03,133.84 203.13,133.73 203.56,133.73 203.66,133.63 203.66,133.48 203.56,133.38 203.13,133.38 203.03,133.27 203.03,133.12 203.13,133.02 203.55,133.02 203.65,132.92 203.65,132.77 203.55,132.66 203.13,132.66 203.03,132.56 203.03,132.41 203.13,132.31 203.57,132.31 203.66,132.22 203.66,132.04 203.57,131.95 203.13,131.95 203.03,131.85 203.03,131.7 203.13,131.6 203.64,131.6 203.74,131.49 203.74,131.35 203.64,131.24 203.16,131.24 203.06,131.14 203.06,130.99 203.16,130.89 203.81,130.89 203.91,130.78 203.91,130.63 203.81,130.53 203.21,130.53 203.1,130.43 203.1,130.28 203.21,130.17 203.95,130.17 204.05,130.07 204.05,129.92 203.95,129.82 203.59,129.82 203.48,129.72 203.48,129.56 203.59,129.46 203.91,129.46 204.07,129.3 204.07,122.2 209.07,117.19 209.07,106.41 205.09,102.43
  BOTTOM w0.076: v2(202.84,90.44) 202.66,90.44 202.37,90.15 U4555.AK48
  BOTTOM w0.114: CN4100.193 203,136.01 v3(203.1,136.12)
M_A_DQ<62>: length 60.5
  L3 w0.076: 209.11,104.15 208.93,103.97 208.93,103.48 206.31,100.86 206.31,97.09 205.88,96.66 205.88,92.82 206.07,92.63 206.07,92.31 205.85,92.09 205.06,92.09 204.93,91.96 204.92,91.96 204.72,91.76 204.72,91.74 v2(204.72,91.74)
  L3 w0.102: v3(206.46,137.76) 206.01,137.31 206.01,132.03 206.11,131.93 206.43,131.93 206.53,131.82 206.53,131.68 206.43,131.57 206.11,131.57 206.01,131.47 206.01,131.32 206.11,131.22 206.43,131.22 206.53,131.11 206.53,130.96 206.43,130.86 206.11,130.86 206.01,130.76 206.01,130.61 206.11,130.5 206.43,130.5 206.53,130.4 206.53,130.25 206.43,130.15 206.11,130.15 206.01,130.05 206.01,129.9 206.11,129.79 206.43,129.79 206.53,129.69 206.53,129.54 206.43,129.44 206.11,129.44 206.01,129.33 206.01,129.19 206.11,129.08 206.43,129.08 206.53,128.98 206.53,128.83 206.43,128.73 206.11,128.73 206.01,128.62 206.01,128.48 206.11,128.37 206.43,128.37 206.53,128.27 206.53,128.12 206.43,128.02 206.11,128.02 206.01,127.91 206.01,126.47 206.01,123.01 211.02,118 211.02,106.06 209.11,104.15
  BOTTOM w0.076: v2(204.72,91.74) 204.71,91.74 204.58,91.74 204.3,91.45 U4555.AM51
  BOTTOM w0.114: CN4100.183 206,137.3 v3(206.46,137.76)
M_A_DQ<63>: length 59.9
  L3 w0.076: v2(204.69,90.48) 204.95,90.74 205.79,90.74 206.11,91.06 206.11,92.12 206.23,92.24 206.23,92.7 206.04,92.89 206.04,96.59 206.47,97.02 206.47,100.68 209.17,103.38 209.17,103.71 209.61,104.14
  L3 w0.102: 209.61,104.14 211.37,105.91 211.37,118.15 206.9,122.61 206.9,122.84 206.8,122.94 206.58,122.94 206.48,123.04 206.48,123.19 206.58,123.3 206.8,123.3 206.9,123.4 206.9,123.55 206.8,123.65 206.47,123.65 206.37,123.75 206.37,123.9 206.47,124.01 206.8,124.01 206.9,124.11 206.9,124.26 206.8,124.36 206.47,124.36 206.37,124.47 206.37,124.61 206.47,124.72 206.8,124.72 206.9,124.82 206.9,124.97 206.8,125.07 206.47,125.07 206.37,125.18 206.37,125.32 206.47,125.43 206.8,125.43 206.9,125.53 206.9,125.68 206.8,125.78 206.47,125.78 206.37,125.89 206.37,126.04 206.47,126.14 206.8,126.14 206.9,126.24 206.9,126.39 206.8,126.5 206.47,126.5 206.37,126.6 206.37,126.75 206.47,126.85 206.8,126.85 206.9,126.96 206.9,127.1 206.8,127.21 206.45,127.21 206.37,127.29 206.37,127.48 206.45,127.56 206.8,127.56 206.9,127.67 206.9,132.07 206.53,132.44 206.53,136.2 v3(206.44,136.29)
  BOTTOM w0.076: U4555.AK51 204.27,90.15 204.6,90.48 v2(204.69,90.48)
  BOTTOM w0.114: v3(206.44,136.29) 206.72,136.29 206.86,136.15 206.86,135.91 206.6,135.65 CN4100.181
M_A_DQS0_DN: length 67.3
  L3 w0.102: v2(217.28,90.27) 217.28,90.18 217.44,90.03 218.14,90.03 218.51,90.39 218.51,90.94 218.97,91.41 219.52,91.41 219.86,91.75 219.86,92.29 220.33,92.76 220.87,92.76 221.14,93.02 221.14,94.6 223.75,97.21 223.75,104.41 222.68,105.49 222.68,122.65 221.18,124.15 221.18,131.99 220.95,132.21 220.95,133.69 220.52,134.11 220.52,134.5 220.95,134.92 220.95,135.14 220.52,135.56 220.52,135.95 220.95,136.37 220.95,137.74 220.79,137.89 220.53,137.89 220.37,137.74 v3(220.37,137.41)
  BOTTOM w0.076: 214.23,89.52 213.52,89.52 213.41,89.41 212.95,89.41 212.9,89.46 212.1,89.46 212.01,89.42 211.94,89.38 211.74,89.38 211.58,89.46 211.45,89.46 211.4,89.44 211.17,89.44 211.02,89.58 210.76,89.84 U4555.AJ61
  BOTTOM w0.114: v2(217.28,90.27) 217.12,90.27 216.69,89.83 216.69,89.47 216.36,89.14 215.34,89.14 214.97,89.51 214.36,89.51 214.35,89.52 214.23,89.52 ; CN4100.135 220.4,135.25 220.23,135.42 220.23,136.09 219.57,136.74 219.57,137.46 219.97,137.86 220.19,137.86 220.37,137.68 v3(220.37,137.41)
M_A_DQS0_DP: length 67.3
  L3 w0.102: v3(216.41,90.17) 216.77,89.81 218.23,89.81 218.72,90.3 218.72,90.85 219.06,91.19 219.61,91.19 220.08,91.66 220.08,92.21 220.42,92.55 220.96,92.55 221.35,92.94 221.35,94.51 223.97,97.12 223.97,104.5 222.89,105.58 222.89,122.74 221.39,124.24 221.39,132.08 221.16,132.3 221.16,133.78 220.74,134.2 220.74,134.41 221.16,134.83 221.16,135.22 220.74,135.65 220.74,135.86 221.16,136.28 221.16,137.83 220.88,138.11 220.65,138.11 v2(220.42,138.34)
  BOTTOM w0.076: U4555.AJ62 211.19,89.67 211.25,89.6 211.36,89.6 211.41,89.62 211.62,89.62 211.71,89.58 211.77,89.55 211.9,89.55 211.96,89.58 212.07,89.63 212.97,89.63 213.02,89.58 213.34,89.58 213.45,89.69 214.14,89.69 214.18,89.73 214.23,89.73
  BOTTOM w0.114: v3(216.41,90.17) 216.46,90.12 216.46,89.56 216.27,89.37 215.43,89.37 215.06,89.74 214.29,89.74 214.27,89.73 214.23,89.73 ; CN4100.137 219.8,135.25 220,135.45 220,135.99 219.34,136.65 219.34,137.55 219.88,138.09 220.17,138.09 v2(220.42,138.34)
M_A_DQS1_DN: length 84.6
  L6 w0.102: v2(260.38,140.02) 260.38,139.58 260.2,139.41 259.79,139.41 259.54,139.17 259.54,134.92 258.66,134.03 258.66,129.21 257.94,128.49 257.94,121.53 255.59,119.18 255.59,118.75 249.97,113.13 249.97,112.54 248.41,110.98 248.15,110.98 244.19,107.03 243.63,107.03 240.81,104.2 232.36,104.2 228.54,100.38 226.42,100.38 219.24,93.21 217.02,93.21 216.85,93.37 214.72,93.37 214.13,92.79 v3(213.78,92.79)
  BOTTOM w0.076: 212.01,92.03 212.01,92.03 212.01,92.03 ; 212.01,92.03 212.07,92.06 212.69,92.06 212.81,91.94 213.35,91.94 213.93,92.52 213.93,92.64 v3(213.78,92.79) ; 212.01,92.03 211.92,91.99 211.9,91.98 211.77,91.98 211.75,91.99 211.67,92.03 211.62,92.05 211.27,92.05 211.19,92.14 U4555.AN62
  BOTTOM w0.114: v2(260.38,140.02) 260.38,139.61 260.21,139.44 259.94,139.44 259.71,139.67 259.71,140.68 260.09,141.06 260.09,141.53 260.3,141.74 CN4100.10
M_A_DQS1_DP: length 84.6
  L6 w0.076: 218.09,92.99 216.97,92.99 216.77,93.18 215.1,93.18 v2(214.64,92.73)
  L6 w0.102: v3(260.42,139.02) 260.42,139.03 260.26,139.2 259.88,139.2 259.76,139.08 259.76,134.83 258.88,133.94 258.88,129.12 258.15,128.4 258.15,121.44 255.81,119.09 255.81,118.66 250.19,113.04 250.19,112.45 248.5,110.77 248.24,110.77 244.28,106.81 243.72,106.81 240.9,103.98 232.45,103.98 228.63,100.17 226.51,100.17 219.33,92.99 218.09,92.99
  BOTTOM w0.076: U4555.AN61 210.54,92.13 210.65,92.02 211.02,92.02 211.16,91.89 211.58,91.89 211.6,91.88 211.74,91.81 211.94,91.81 212.08,91.88 212.1,91.89 212.62,91.89 212.74,91.77 213.42,91.77 214.38,92.73 v2(214.64,92.73)
  BOTTOM w0.114: CN4100.12 259.7,141.74 259.86,141.58 259.86,141.15 259.48,140.78 259.48,139.57 259.84,139.22 260.23,139.22 v3(260.42,139.02)
M_A_DQS2_DN: length 62.6
  L3 w0.102: v2(209.36,91.81) 209.48,91.93 209.88,91.93 210.92,92.96 210.92,94.42 213.42,96.92 218.08,96.92 219.87,98.71 219.87,102.98 218.33,104.52 218.33,121.29 216.83,122.79 216.83,127.74 216.27,128.3 216.27,134.45 215.95,134.77 215.95,138.83 215.44,139.33 215.07,139.33 v3(214.87,139.54)
  BOTTOM w0.114: CN4100.152 215.3,141.75 215.11,141.57 215.11,140.98 214.85,140.71 214.5,140.71 214.25,140.46 214.25,139.46 214.38,139.33 214.66,139.33 v3(214.87,139.54) ; v2(209.36,91.81) 209.3,91.81 208.94,91.45 U4555.AM58
M_A_DQS2_DP: length 62.5
  L3 w0.102: v2(214.84,138.83) 214.84,138.95 215.01,139.12 215.35,139.12 215.73,138.74 215.73,134.68 216.06,134.36 216.06,128.21 216.61,127.65 216.61,122.7 218.11,121.2 218.11,104.43 219.65,102.89 219.65,98.8 217.99,97.13 213.33,97.13 210.7,94.51 210.7,93.05 209.79,92.14 209.59,92.14 209.36,92.37 v3(209.36,92.47)
  BOTTOM w0.114: CN4100.154 214.7,141.75 214.89,141.57 214.89,141.07 214.76,140.94 214.41,140.94 214.02,140.55 214.02,139.37 214.29,139.1 214.57,139.1 v2(214.84,138.83) ; v3(209.36,92.47) 209.31,92.47 208.94,92.1 U4555.AN58
M_A_DQS3_DN: length 84.2
  L6 w0.076: v3(207.61,91.79) 207.41,92 207.25,92 207.04,92.21 207.04,93.31 206.93,93.42 206.93,94.07 207.15,94.28
  L6 w0.102: v2(254.86,138.3) 254.68,138.13 254.29,138.13 254,137.83 254,136.15 254.26,135.89 254.43,135.89 254.55,135.78 254.55,135.48 254.43,135.37 254.26,135.37 254,135.11 254,123.55 242.13,111.68 242.13,111.29 241.05,110.21 239.74,110.21 237.67,108.13 230.56,108.13 229.92,107.49 226.56,107.49 221.87,102.81 221.42,102.36 221.42,101.35 217.92,97.85 212.21,97.85 210.4,96.04 208.9,96.04 207.15,94.28
  BOTTOM w0.114: v3(207.61,91.79) 207.44,91.79 207.1,91.45 U4555.AM55 ; v2(254.86,138.3) 255.05,138.11 255.27,138.11 255.55,137.83 255.55,136.48 255.01,135.93 255.01,135.45 255.2,135.26 CN4100.27
M_A_DQS3_DP: length 84.1
  L6 w0.076: v2(207.59,92.49) 207.69,92.39 207.69,92.28 207.59,92.17 207.31,92.17 207.2,92.28 207.2,93.38 207.1,93.49 207.1,93.93 207.3,94.13
  L6 w0.102: 207.3,94.13 208.99,95.82 210.49,95.82 212.3,97.63 218.01,97.63 221.64,101.26 221.64,102.27 221.96,102.59 226.65,107.28 230.01,107.28 230.65,107.92 237.76,107.92 239.83,109.99 241.14,109.99 242.34,111.2 242.34,111.59 254.22,123.46 254.22,135.02 254.35,135.15 254.52,135.15 254.76,135.39 254.76,135.87 254.52,136.11 254.35,136.11 254.22,136.24 254.22,137.74 254.38,137.91 254.66,137.91 254.82,137.76 v3(254.82,137.4)
  BOTTOM w0.114: U4555.AN55 207.1,92.1 207.31,92.1 207.59,92.39 v2(207.59,92.49) ; CN4100.29 254.6,135.3 254.78,135.48 254.78,136.02 255.33,136.57 255.33,137.74 255.18,137.88 255.03,137.88 254.82,137.67 v3(254.82,137.4)
M_A_DQS4_DN: length 54.4
  L3 w0.102: v2(210.07,137.52) 210.07,137.79 210.26,137.97 210.56,137.97 210.76,137.77 210.76,122.63 214.24,119.15 214.24,105.3 210.66,101.72 210.66,101.18 209.77,100.29 209.77,99.5 209.41,99.13 208.81,99.13 v3(208.62,99.32)
  BOTTOM w0.076: v3(208.62,99.32) 208.62,99.17 208.87,98.92 208.9,98.89 209.02,98.89 209.24,98.66 209.24,97.96 209.07,97.79 209.07,97.36 209.07,97.23 208.85,97.01 208.85,97.01 208.68,96.84 208.68,96.45 208.69,96.43 208.73,96.35 208.73,96.35 208.76,96.29 208.76,96.09 208.68,95.93 208.68,95.8 208.73,95.7 208.76,95.64 208.76,95.44 208.68,95.27 208.62,95.21 208.53,95.12 208.38,95.12 208.3,95.05 208.3,94.89 U4555.AV57
  BOTTOM w0.114: v2(210.07,137.52) 210.07,137.94 209.94,138.08 209.66,138.08 209.48,137.9 209.48,136.68 210.01,136.15 210.01,135.48 210.2,135.29 CN4100.169
M_A_DQS4_DP: length 54.4
  L3 w0.102: v3(210.04,138.56) 210.42,138.19 210.65,138.19 210.98,137.86 210.98,122.72 214.46,119.24 214.46,105.21 210.88,101.63 210.88,101.09 209.99,100.2 209.99,99.41 209.5,98.92 208.83,98.92 v2(208.55,98.63)
  BOTTOM w0.076: U4555.AW57 208.3,95.54 208.3,95.36 208.37,95.29 208.46,95.29 208.54,95.37 208.59,95.47 208.59,95.61 208.52,95.76 208.52,95.97 208.54,96.02 208.58,96.11 208.59,96.13 208.59,96.26 208.56,96.31 208.52,96.41 208.52,96.91 208.78,97.18 208.9,97.3 208.9,97.86 209.07,98.03 209.07,98.59 208.95,98.72 208.64,98.72 v2(208.55,98.63)
  BOTTOM w0.114: CN4100.171 209.6,135.3 209.78,135.48 209.78,136.06 209.25,136.58 209.25,137.99 209.56,138.3 209.78,138.3 v3(210.04,138.56)
M_A_DQS5_DN: length 79.1
  L6 w0.076: v2(205.6,100.2) 205.6,100.15 205.88,99.87 206.08,99.87 206.24,100.03 206.24,100.6 207.13,101.5 207.56,101.5 209.26,103.2 209.64,103.2
  L6 w0.102: 209.64,103.2 211.33,103.2 216.06,107.94 217.78,107.94 222.08,112.24 235.73,112.24 240.03,116.54 240.53,116.54 243.9,119.92 243.9,120.89 249.3,126.28 249.3,135.92 248.78,136.43 248.78,137.76 249.07,138.05 249.32,138.05 v3(249.53,138.26)
  BOTTOM w0.076: U4555.AV53 205.87,94.89 205.87,95.12 206.25,95.51 206.25,95.93 206.26,95.95 206.27,95.98 206.3,96.04 206.32,96.09 206.32,96.29 206.3,96.35 206.26,96.42 206.25,96.45 206.25,97.18 206.28,97.22 206.28,97.39 206.28,97.45 206.28,97.55 206.28,97.7 206.24,97.75 206.24,99.7 206.24,99.7 206.24,99.79 206.04,99.98 205.82,99.98 v2(205.6,100.2)
  BOTTOM w0.114: v3(249.53,138.26) 249.8,137.99 250.01,137.99 250.31,137.7 250.31,136.47 249.61,135.77 249.61,135.46 249.8,135.27 CN4100.45
M_A_DQS5_DP: length 79
  L6 w0.076: v3(205.56,99.38) 205.88,99.7 206.15,99.7 206.4,99.96 206.4,100.53 207.2,101.33 207.63,101.33 209.31,103.01 209.64,103.01
  L6 w0.102: 209.64,103.01 211.44,103.01 216.15,107.72 217.87,107.72 222.17,112.03 235.82,112.03 240.12,116.33 240.62,116.33 244.12,119.83 244.12,120.8 249.51,126.19 249.51,136.01 249,136.52 249,137.67 249.16,137.83 249.41,137.83 249.41,137.83 249.53,137.71 v2(249.53,137.24)
  BOTTOM w0.076: U4555.AW53 205.87,95.54 206,95.54 206.09,95.63 206.09,95.97 206.12,96.05 206.16,96.13 206.16,96.26 206.11,96.36 206.11,96.37 206.09,96.4 206.09,96.4 206.09,96.41 206.09,97.25 206.12,97.28 206.12,97.39 206.12,97.45 206.12,97.55 206.12,97.63 206.07,97.68 206.07,99.72 205.97,99.82 205.55,99.82 205.47,99.73 205.47,99.47 v3(205.56,99.38)
  BOTTOM w0.114: CN4100.47 249.2,135.26 249.38,135.43 249.38,135.86 250.08,136.57 250.08,137.6 249.92,137.76 249.69,137.76 249.53,137.6 249.53,137.24 v2(249.53,137.24)
M_A_DQS6_DN: length 84.3
  L6 w0.076: v2(199.93,91) 199.56,91.37 199.56,91.77 199.78,91.99 199.95,91.99 200.41,92.46 201.1,92.46 201.44,92.79 201.44,93.84 201.87,94.28 202.02,94.28 202.39,94.65 202.39,99.63 202.54,99.78
  L6 w0.102: 202.54,99.78 209.33,106.57 209.33,107.02 213.96,111.66 216.24,111.66 220.54,115.96 233.72,115.96 244.42,126.66 244.42,135.23 244.56,135.37 244.56,136.01 244.32,136.25 244.12,136.25 243.99,136.38 243.99,136.7 244.12,136.83 244.33,136.83 244.56,137.05 244.56,137.6 244.33,137.83 243.6,137.83 243.38,138.04 243.38,139.13 243.6,139.35 243.87,139.35 244.11,139.11 v3(244.11,139.03)
  BOTTOM w0.114: v2(199.93,91) 199.63,91 U4555.AL43 ; CN4100.62 244.7,141.72 244.55,141.57 244.55,140.97 245.02,140.5 245.02,139.56 244.74,139.28 244.36,139.28 v3(244.11,139.03)
M_A_DQS6_DP: length 84.3
  L6 w0.076: 202.39,99.93 202.23,99.77 202.23,94.72 201.95,94.44 201.8,94.44 201.27,93.91 201.27,92.86 201.04,92.62 200.35,92.62 199.88,92.15 199.71,92.15 199.39,91.83 199.39,91.5 v3(199,91.1)
  L6 w0.102: 202.39,99.93 209.09,106.63 209.09,107.09 213.87,111.87 216.15,111.87 220.45,116.18 233.63,116.18 244.2,126.75 244.2,135.32 244.34,135.46 244.34,135.92 244.23,136.04 244.03,136.04 243.77,136.29 243.77,136.79 244.03,137.04 244.24,137.04 244.34,137.14 244.34,137.51 244.24,137.61 243.51,137.61 243.16,137.96 243.16,139.22 243.51,139.57 243.83,139.57 v2(244.11,139.84)
  BOTTOM w0.114: v2(244.11,139.84) 244.11,139.76 244.35,139.51 244.64,139.51 244.79,139.65 244.79,140.41 244.32,140.88 244.32,141.49 244.1,141.72 CN4100.64 ; U4555.AL42 198.78,91.1 v3(199,91.1)
M_A_DQS7_DN: length 62.2
  L3 w0.076: v2(202.78,91.13) 203.07,91.13 203.23,91.3 203.23,91.9 203.58,92.24 204.05,92.24 204.33,92.52 204.64,92.52 205.15,93.03 205.15,93.36
  L3 w0.102: v3(204.45,139.11) 204.45,139.35 204.55,139.45 204.83,139.45 204.93,139.35 204.93,138.05 204.78,137.9 204.37,137.9 204.1,137.62 204.1,137.23 204.37,136.96 204.78,136.96 204.93,136.81 204.93,136.6 204.78,136.45 204.37,136.45 204.1,136.18 204.1,135.79 204.37,135.51 204.78,135.51 204.93,135.36 204.93,122.56 209.94,117.55 209.94,106.41 204.92,101.39 204.92,97.88 205.04,97.76 205.04,96.79 205.15,96.68 205.15,93.36
  BOTTOM w0.114: v3(204.45,139.11) 204.59,139.24 205.06,139.24 205.26,139.44 205.26,140.69 205.04,140.91 205.04,142.67 CN4100.186 ; v2(202.78,91.13) 202.78,90.93 202.65,90.8 202.39,90.8 U4555.AL48
M_A_DQS7_DP: length 62.2
  L3 w0.076: 205.37,93.36 205.37,93.01 204.71,92.35 204.4,92.35 204.12,92.07 203.65,92.07 203.4,91.83 203.4,91.15 203.57,90.98 v3(203.76,90.98)
  L3 w0.102: v2(204.46,139.86) 204.65,139.67 204.92,139.67 205.15,139.44 205.15,137.96 204.87,137.68 204.46,137.68 204.31,137.53 204.31,137.32 204.46,137.18 204.87,137.18 205.15,136.9 205.15,136.51 204.87,136.24 204.46,136.24 204.31,136.09 204.31,135.88 204.46,135.73 204.87,135.73 205.15,135.45 205.15,122.65 210.15,117.64 210.15,106.32 205.14,101.3 205.14,97.97 205.25,97.85 205.25,96.88 205.37,96.77 205.37,93.36
  BOTTOM w0.114: CN4100.188 204.5,141.75 204.71,141.54 204.71,141.53 204.81,141.44 204.81,141.44 204.81,140.82 205.03,140.6 205.03,139.54 204.97,139.47 204.71,139.47 204.46,139.72 v2(204.46,139.86) ; v3(203.76,90.98) 203.48,90.98 203.29,90.8 U4555.AL49
M_A_RAS#: length 74.4
  L6 w0.076: v2(193.93,97.19) 193.75,97.19 193.55,97.39 193.55,99.25 193.38,99.41 193.38,103.14 193.47,103.22
  L6 w0.165: v3(228.03,140.75) 228.03,141.12 228.13,141.22 229.14,141.22 229.24,141.32 229.24,141.8 229.14,141.9 227.48,141.9 227.28,141.7 227.28,139.12 227.1,138.94 227.1,135.87 222.31,131.08 210.78,131.08 200.75,121.05 200.75,120.82 201.13,120.44 201.13,120.21 200.97,120.05 200.73,120.05 200.36,120.42 200.13,120.42 199.96,120.26 199.96,120.03 200.34,119.65 200.34,119.42 194.09,113.17 194.09,103.84 193.47,103.22
  BOTTOM w0.076: v2(193.93,97.19) 193.93,97.03 193.56,96.66 193.56,96.52 U4555.AY34
  BOTTOM w0.178: v3(228.03,140.75) 227.9,140.88 CN4100.110
M_A_WE#: length 73.8
  L6 w0.076: 193.33,104 193.31,104 193.22,103.9 193.22,99.34 193.38,99.18 193.38,96.77 v2(193.97,96.19)
  L6 w0.165: 193.33,104 193.55,104.23 193.55,113.41 198.75,118.61 198.75,118.84 198.38,119.21 198.38,119.44 198.55,119.6 198.78,119.6 199.15,119.23 199.38,119.23 199.54,119.4 199.54,119.63 199.18,120 199.18,120.23 210.56,131.62 222.09,131.62 226.55,136.07 226.55,136.44 226.39,136.6 226.08,136.6 225.91,136.77 225.91,137 226.08,137.16 226.39,137.16 226.55,137.33 226.55,137.56 226.39,137.72 226.08,137.72 225.91,137.88 225.91,138.12 226.08,138.28 226.39,138.28 226.55,138.44 226.55,138.65 226.35,138.85 225.5,138.85 v3(225.24,138.59)
  BOTTOM w0.076: U4555.AW34 193.56,95.87 193.56,95.91 193.84,96.19 v2(193.97,96.19)
  BOTTOM w0.178: v3(225.24,138.59) 227,136.83 CN4100.113
M_B_A<0>: length 82.6
  L3 w0.076: 199.16,103.4 199.17,103.39 199.17,102.8 198.61,102.25 198.61,100.68 197.9,99.96 197.9,94.61 198.45,94.05 198.45,93.47 v2(198.06,93.08)
  L3 w0.165: v3(155.25,139.53) 154.7,138.98 154.7,136.67 155.18,136.19 155.18,134.88 159.48,130.59 180.85,130.59 199.16,112.28 199.16,103.4
  BOTTOM w0.076: U4555.AP40 197.99,93.08 v2(198.06,93.08)
  BOTTOM w0.178: CN4125.98 154.5,140.28 v3(155.25,139.53)
M_B_A<1>: length 83.1
  L3 w0.076: v2(198.06,93.73) 198.06,94.21 197.64,94.63 197.64,99.77 197.13,100.29 197.13,101.21 197.21,101.29 197.32,101.29 197.41,101.21 197.41,100.42 197.49,100.34 197.6,100.34 197.69,100.42 197.69,101.45 197.77,101.53 197.88,101.53 197.97,101.45 197.97,100.6 198.05,100.51 198.16,100.51 198.24,100.6 198.24,102.11 198.63,102.5 198.63,102.78
  L3 w0.165: v3(154.37,136.25) 154.65,135.97 154.65,134.66 155.28,134.04 155.28,133.32 158.54,130.06 180.63,130.06 198.63,112.06 198.63,102.78
  BOTTOM w0.076: U4555.AR40 197.99,93.73 v2(198.06,93.73)
  BOTTOM w0.178: CN4125.97 154.8,135.87 155.12,136.2 155.12,136.41 154.79,136.74 154.58,136.74 154.37,136.53 v3(154.37,136.25)
M_B_A<2>: length 86
  L3 w0.076: 200.8,105.64 200.91,105.53 200.91,104.08 198.94,102.11 198.94,100.54 198.25,99.85 198.25,94.76 198.72,94.29 198.86,94.15 199.13,94.15 199.45,93.83 199.45,93.26 199.26,93.07 v2(199.05,93.07)
  L3 w0.165: 200.8,105.64 200.23,106.21 200.23,112.72 181.29,131.66 159.92,131.66 156.25,135.33 156.25,138.47 156.01,138.71 156.01,141.75 155.86,141.91 155.38,141.91 155.22,141.75 v3(155.22,141.01)
  BOTTOM w0.076: U4555.AP42 198.48,92.75 198.8,93.07 v2(199.05,93.07)
  BOTTOM w0.178: v3(155.22,141.01) 155.1,141.13 CN4125.96
M_B_A<3>: length 84.7
  L3 w0.076: v2(199.03,93.69) 199.03,93.71 198.59,94.15 198.08,94.65 198.08,99.91 198.78,100.61 198.78,102.18 200.53,103.94 200.53,104.62 200.45,104.7 200.34,104.7 200.26,104.62 200.26,104.15 200.19,104.09 199.84,104.09 199.7,104.23
  L3 w0.165: v3(155.29,138.16) 155.51,138.16 155.72,137.96 155.72,137.69 155.56,137.53 155.41,137.53 155.26,137.38 155.26,137.06 155.39,136.93 155.59,136.93 155.72,136.8 155.72,135.11 159.7,131.13 181.07,131.13 199.7,112.5 199.7,104.23
  BOTTOM w0.076: U4555.AR42 198.48,93.4 198.77,93.69 199.03,93.69 v2(199.03,93.69)
  BOTTOM w0.178: v3(155.29,138.16) 155.73,138.16 156.03,137.86 156.03,136.3 155.4,135.66 CN4125.95
M_B_A<4>: length 89.9
  L3 w0.076: 201.3,106.11 201.3,105.9 201.3,105.9 201.3,104 199.31,102.01 199.31,95.22 199.48,95.05 v2(200.88,93.65)
  L3 w0.165: v3(156.83,139.48) 157.32,139 157.32,135.77 159.8,133.29 182.75,133.29 183.11,132.93 183.11,131.35 183.27,131.19 183.49,131.19 184.18,131.89 184.4,131.89 184.56,131.73 184.56,131.51 183.86,130.82 183.86,130.6 184.02,130.44 184.24,130.44 184.94,131.14 185.16,131.14 185.31,130.98 185.31,130.76 184.62,130.06 184.62,129.84 184.77,129.69 184.99,129.69 185.69,130.38 185.91,130.38 186.07,130.22 186.07,130 185.37,129.31 185.37,129.09 201.3,113.16 201.3,106.11
  BOTTOM w0.076: v2(200.88,93.65) 200.66,93.65 200.41,93.4 U4555.AR45
  BOTTOM w0.178: CN4125.92 156.3,140.01 v3(156.83,139.48)
M_B_A<5>: length 88.5
  L3 w0.076: 201.04,105.91 201.13,105.82 201.13,104.07 199.11,102.04 199.11,95.09 199.31,94.88 200.33,93.87 200.33,93.55 200.73,93.16 v2(200.88,93)
  L3 w0.165: 201.04,105.91 200.76,106.18 200.76,112.94 181.51,132.19 180.07,132.19 179.91,132.35 179.91,132.58 179.75,132.73 179.53,132.73 179.38,132.58 179.38,132.35 179.22,132.19 178.26,132.19 178.1,132.35 178.1,132.53 177.93,132.69 177.7,132.69 177.53,132.53 177.53,132.35 177.37,132.19 177.11,132.19 176.96,132.35 176.96,132.53 176.79,132.69 176.55,132.69 176.39,132.53 176.39,132.35 176.23,132.19 172.43,132.19 172.27,132.35 172.27,132.57 172.11,132.73 171.89,132.73 171.73,132.57 171.73,132.35 171.57,132.19 171.34,132.19 171.18,132.35 171.18,132.57 171.02,132.73 170.8,132.73 170.64,132.57 170.64,132.35 170.48,132.19 168.31,132.19 168.15,132.35 168.15,132.58 167.99,132.74 167.76,132.74 167.6,132.58 167.6,132.35 167.44,132.19 167.21,132.19 167.05,132.35 167.05,132.58 166.89,132.74 166.67,132.74 166.51,132.58 166.51,132.35 166.35,132.19 166.12,132.19 165.96,132.35 165.96,132.58 165.8,132.74 165.57,132.74 165.41,132.58 165.41,132.35 165.25,132.19 164.45,132.19 164.29,132.35 164.29,132.55 164.13,132.71 163.91,132.71 163.75,132.55 163.75,132.35 163.59,132.19 163.36,132.19 163.2,132.35 163.2,132.55 163.04,132.71 162.81,132.71 162.65,132.55 162.65,132.35 162.49,132.19 161.67,132.19 161.51,132.35 161.51,132.58 161.35,132.74 161.13,132.74 160.97,132.58 160.97,132.35 160.81,132.19 160.14,132.19 156.78,135.55 v3(156.78,137.3)
  BOTTOM w0.076: v2(200.88,93) 200.66,93 200.41,92.75 U4555.AP45
  BOTTOM w0.178: v3(156.78,137.3) 157.08,137.3 157.24,137.13 157.24,136.67 156.6,136.03 CN4125.91
M_B_A<6>: length 92.2
  L3 w0.076: v2(199.92,97.92) 199.48,98.37 199.48,101.92 202.11,104.56 202.11,105.64 202.05,105.7
  L3 w0.165: v3(156.9,141) 156.9,141.89 156.33,142.46 155.27,142.46 155.01,142.72 155.01,143.95 155.17,144.1 155.41,144.1 155.56,143.95 155.56,143.19 155.72,143.03 155.95,143.03 156.11,143.19 156.11,144 156.26,144.15 156.5,144.15 156.65,144 156.65,143.19 157.43,142.4 157.43,141.65 157.44,141.65 157.44,139.84 157.85,139.42 157.85,135.99 160.02,133.82 183.4,133.82 186.79,130.43 186.79,128.42 201.83,113.38 201.83,105.92 202.05,105.7
  BOTTOM w0.076: U4555.AW46 201.43,95.87 201.08,96.22 201.08,96.74 199.92,97.9 v2(199.92,97.92)
  BOTTOM w0.178: CN4125.90 156.9,141 v3(156.9,141)
M_B_A<7>: length 93.9
  L3 w0.076: v2(199.92,99.12) 199.92,102.13 202.36,104.58 202.36,104.69
  L3 w0.165: 202.36,104.69 202.36,113.6 187.32,128.65 187.32,130.65 183.62,134.35 183.18,134.35 160.24,134.35 158.38,136.21 158.38,139.64 157.97,140.06 157.97,143.18 157.82,143.33 157.34,143.33 157.18,143.48 157.18,143.74 157.33,143.89 159.58,143.89 159.73,143.73 159.73,143.48 159.58,143.32 158.73,143.32 158.58,143.17 158.58,142.94 158.73,142.79 159.63,142.79 159.78,142.63 159.78,142.41 159.63,142.25 158.78,142.25 158.63,142.1 158.63,141.8 158.78,141.64 159.18,141.64 159.33,141.49 159.33,140.8 159.18,140.65 v3(158.83,140.65)
  BOTTOM w0.076: v2(199.92,99.12) 200.08,99.12 200.5,98.69 200.5,97.55 201.43,96.62 201.43,96.52 U4555.AY46
  BOTTOM w0.178: v3(158.83,140.65) 158.58,140.65 158.1,141.13 CN4125.86
M_B_A<8>: length 90.8
  L3 w0.076: v2(201.15,97.46) 200.55,97.46 200.35,97.65 200.35,102.16 202.9,104.71 202.9,104.83
  L3 w0.165: v3(159.01,136.77) 159.01,136.34 160.46,134.89 183.84,134.89 187.85,130.87 188.38,130.34 188.38,129.68 187.85,129.15 187.85,128.87 188.09,128.63 188.31,128.63 189.07,129.39 189.29,129.39 189.45,129.23 189.45,129.01 188.69,128.25 188.69,128.03 188.85,127.87 189.07,127.87 189.82,128.63 190.05,128.63 190.2,128.48 190.2,128.25 189.44,127.5 189.44,127.28 190.45,126.27 190.68,126.27 191.45,127.04 191.67,127.04 191.83,126.89 191.83,126.67 191.05,125.89 191.05,125.67 191.21,125.51 191.43,125.51 192.21,126.29 192.43,126.29 192.58,126.13 192.58,125.91 191.81,125.14 191.81,124.91 191.96,124.76 192.18,124.76 192.96,125.54 193.18,125.54 193.34,125.38 193.34,125.16 192.56,124.38 192.56,124.16 202.9,113.83 202.9,104.83
  BOTTOM w0.076: U4555.AY47 202.26,96.52 201.32,97.46 v2(201.15,97.46)
  BOTTOM w0.178: v3(159.01,136.77) 158.16,136.77 157.2,135.81 CN4125.89
M_B_A<9>: length 94
  L3 w0.076: 204.5,105.52 204.5,105.36 202.57,103.44 202.57,102.3 201.53,101.26 201.53,97.3 201.45,97.22 201.45,95.3 201.85,94.9 v2(201.85,94.88)
  L3 w0.165: v3(160.33,137.95) 161.39,136.9 163.82,136.9 166.8,139.88 166.8,140.57 167.87,141.64 173.53,141.64 173.69,141.49 173.69,140.38 173.84,140.22 174.06,140.22 174.22,140.38 174.22,141.49 174.38,141.64 174.6,141.64 174.75,141.49 174.75,140.38 174.91,140.22 175.13,140.22 175.29,140.38 175.29,141.49 175.44,141.64 184.83,141.64 185.37,141.11 185.37,136.85 195.13,127.09 195.13,123.86 204.5,114.49 204.5,105.52
  BOTTOM w0.076: U4555.AU46 201.38,94.57 201.61,94.57 201.85,94.8 v2(201.85,94.88)
  BOTTOM w0.178: CN4125.85 158.4,135.65 158.95,136.2 159.24,136.2 159.58,136.54 159.58,137.46 160.07,137.95 v3(160.33,137.95)
M_B_A<10>: length 98.1
  L3 w0.076: v2(195.62,90.25) 195.16,90.71 195.16,91.39 195.21,91.44 195.21,94.25 194.83,94.63 194.83,101.21 194.93,101.31
  L3 w0.165: 194.93,101.31 195.43,101.81 195.88,102.26 195.88,110.91 179.49,127.3 157.4,127.3 153.95,130.75 153.73,130.75 153.56,130.58 153.56,130.37 156.16,127.77 156.16,127.55 155.99,127.38 155.77,127.38 152.38,130.78 151.89,130.78 151.66,131 151.43,131 151.06,130.63 150.85,130.63 150.68,130.8 150.68,131.02 151.11,131.46 151.11,131.66 150.97,131.8 150.76,131.8 150.51,131.55 150.2,131.55 150.04,131.71 150.04,131.93 150.27,132.16 150.27,132.39 150.15,132.51 150.15,135.42 150.56,135.82 150.56,137.91 v3(150.39,138.08)
  BOTTOM w0.076: v2(195.62,90.25) 195.53,90.15 195.12,90.15 U4555.AK36
  BOTTOM w0.178: CN4125.107 151.8,137.65 151.36,138.08 v3(150.39,138.08)
M_B_A<11>: length 93.6
  L3 w0.076: v2(201.06,98.63) 201.06,98.64 200.68,99.02 200.68,102.24 203.43,104.99 203.43,105.06
  L3 w0.165: v3(159.04,138.7) 159.04,138.86 159.55,139.37 159.55,139.49 159.29,139.74 159.29,139.98 159.46,140.15 159.7,140.15 160.09,139.76 161.19,139.76 161.29,139.66 161.29,139.27 161.19,139.17 160.17,139.17 159.8,138.8 159.8,138.34 159.64,138.18 159.59,138.18 159.43,138.02 159.43,137.8 159.59,137.64 159.64,137.64 159.8,137.48 159.8,136.3 160.68,135.42 184.06,135.42 190.53,128.95 190.75,128.95 191.12,129.33 191.35,129.33 191.5,129.17 191.5,128.95 191.13,128.58 191.13,128.35 191.28,128.2 191.5,128.2 191.88,128.57 192.1,128.57 192.26,128.42 192.26,128.2 191.88,127.82 191.88,127.6 192.04,127.44 192.26,127.44 192.63,127.82 192.85,127.82 193.01,127.66 193.01,127.44 192.64,127.07 192.64,126.85 192.79,126.69 193.01,126.69 193.39,127.07 193.61,127.07 193.77,126.91 193.77,126.69 193.39,126.31 193.39,126.09 193.89,125.59 193.89,123.58 203.43,114.05 203.43,105.06
  BOTTOM w0.076: v2(201.06,98.63) 201.23,98.63 201.88,97.98 201.88,97.4 202.07,97.21 202.22,97.21 202.55,96.88 202.55,95.51 U4555.AV47
  BOTTOM w0.178: v3(159.04,138.7) 159.33,138.98 159.33,140.99 158.7,141.62 CN4125.84
M_B_A<12>: length 89.3
  L3 w0.076: v2(201.09,99.86) 201.06,99.89 201.06,102.2 203.96,105.11 203.96,105.29
  L3 w0.165: 203.96,105.29 203.96,114.27 194.59,123.64 194.59,126.87 191.04,130.42 190.81,130.42 190.42,130.04 190.2,130.04 190.04,130.2 190.04,130.42 190.42,130.81 190.42,131.04 190.26,131.2 190.04,131.2 189.65,130.81 189.43,130.81 189.27,130.97 189.27,131.2 189.65,131.58 189.65,131.81 189.49,131.97 189.27,131.97 188.88,131.58 188.65,131.58 188.49,131.74 188.49,131.97 188.88,132.36 188.88,132.58 188.72,132.74 188.49,132.74 188.11,132.35 187.88,132.35 187.72,132.52 187.72,132.74 188.11,133.13 188.11,133.35 187.95,133.51 187.72,133.51 187.33,133.13 187.11,133.13 186.95,133.29 186.95,133.51 187.33,133.9 187.33,134.13 187.17,134.29 186.95,134.29 186.56,133.9 186.33,133.9 186.17,134.06 186.17,134.29 186.56,134.67 186.56,134.9 186.4,135.06 186.17,135.06 185.79,134.67 185.56,134.67 185.4,134.83 185.4,135.06 185.79,135.45 185.79,135.67 185.63,135.83 185.4,135.83 185.02,135.45 184.79,135.45 184.28,135.95 160.9,135.95 v3(160.38,136.47)
  BOTTOM w0.076: U4555.AU47 202.31,94.57 202.31,94.63 202.72,95.04 202.72,96.95 202.27,97.4 202.27,98.77 201.18,99.85 201.1,99.85 v2(201.09,99.86)
  BOTTOM w0.178: CN4125.83 159,135.44 159.19,135.63 159.54,135.63 v3(160.38,136.47)
M_B_A<13>: length 97.9
  L3 w0.076: 193.16,105.83 193.16,91.92 193.22,91.85 193.22,90.92 v2(193.73,90.42)
  L3 w0.165: v3(147.34,136.66) 147.34,136.12 147.19,135.96 146.93,135.96 146.78,135.81 146.78,135.57 146.93,135.42 147.18,135.42 147.33,135.27 147.33,135.02 147.18,134.87 146.94,134.87 146.79,134.72 146.79,134.48 146.94,134.33 147.21,134.33 147.34,134.19 147.34,133.87 147.21,133.73 146.93,133.73 146.78,133.58 146.78,125.27 147.4,124.64 147.62,124.64 147.79,124.81 147.79,125.02 147.33,125.49 147.33,125.7 147.5,125.87 147.71,125.87 148.95,124.64 149.16,124.64 149.34,124.81 149.34,125.02 147.32,127.04 147.32,127.26 147.49,127.43 147.71,127.43 150.5,124.64 178.38,124.64 193.06,109.96 193.06,105.92 193.16,105.83
  BOTTOM w0.076: v2(193.73,90.42) 193.52,90.42 193.26,90.15 U4555.AK33
  BOTTOM w0.178: CN4125.119 148.2,135.81 v3(147.34,136.66)
M_B_A<14>: length 96.4
  L3 w0.076: v2(201.83,93.61) 201.83,93.92 202.31,94.39 203.19,94.39 203.19,94.39 203.65,94.39 204.01,94.75 204.01,96.42 203.49,96.94 203.49,102.45 207.44,106.41 207.44,106.63
  L3 w0.165: 207.44,106.63 207.44,106.63 207.44,115.71 198.07,125.08 198.07,129.14 190.93,136.28 190.93,140.65 185.99,145.6 165.96,145.6 164.83,144.47 163.25,144.47 162.46,143.68 162.24,143.68 162.12,143.79 161.9,143.79 161.74,143.63 161.74,143.41 161.85,143.29 161.85,143.07 161.69,142.91 161.47,142.91 161.21,143.16 161,143.16 160.84,143 160.84,142.76 161.08,142.52 161.08,142.29 160.15,141.37 v3(160.15,140.96)
  BOTTOM w0.076: v2(201.83,93.61) 201.54,93.61 201.34,93.41 U4555.AR46
  BOTTOM w0.178: v3(160.15,140.96) 159.9,141.21 CN4125.80
M_B_A<15>: length 96.4
  L3 w0.076: v3(201.83,92.95) 201.45,93.33 201.45,93.83 202.18,94.56 203.26,94.56 203.26,94.56 203.58,94.56 203.84,94.82 203.84,96.36 203.28,96.91 203.28,102.08 203.29,102.08 203.29,102.77 203.5,102.98
  L3 w0.165: v2(160.92,141.11) 161.44,141.63 162.65,141.63 162.92,141.9 162.92,142.13 162.46,142.58 162.46,142.81 162.62,142.97 162.85,142.97 163.31,142.51 163.54,142.51 163.68,142.65 163.68,142.92 163.24,143.36 163.24,143.58 163.4,143.74 163.62,143.74 163.87,143.5 164.29,143.5 164.67,143.87 165.02,143.87 166.21,145.07 185.77,145.07 190.4,140.43 190.4,136.5 190.4,136.06 197.54,128.92 197.54,124.86 206.91,115.49 206.91,106.39 206.47,105.95 203.68,103.16 203.5,102.98
  BOTTOM w0.076: v3(201.83,92.95) 201.53,92.95 U4555.AP46
  BOTTOM w0.178: v2(160.92,141.11) 160.92,141.11 160.5,141.53 CN4125.78
