# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_THRM_DMINUS: length 158.1
  TOP w0.102: C5010.2 198.2,132.66 v2(198.53,132.32)
  L3 w0.102: v3(112.81,93.63) 115.27,96.1 115.27,103.65 113.52,105.4 113.52,141.79 119.41,147.69 131.98,147.69 132.62,147.05 155.61,147.05 157.13,148.58 167.29,148.58 167.67,148.96 176.25,148.96 176.52,149.24 182.73,149.24 184.14,147.83 185.54,147.83 190.25,143.11 195.23,143.11 199.3,139.05 199.3,135.75 198.53,134.99 v2(198.53,132.32)
  BOTTOM w0.102: v3(112.81,93.63) 112.73,93.63 112.09,93 U5000.3 ; Q5000.2 197.78,133.07 v2(198.53,132.32)
GPU_THRM_DPLUS: length 160.7
  TOP w0.102: v3(197.26,132.32) 197.34,132.4 C5010.1
  L3 w0.102: v3(197.26,132.32) 197.26,134.1 199.09,135.93 199.09,138.87 195.44,142.53 190.33,142.53 185.38,147.48 183.99,147.48 182.61,148.85 176.64,148.85 176.38,148.6 168.08,148.6 167.67,148.19 157.26,148.19 155.73,146.67 132.37,146.67 131.75,147.28 119.52,147.28 114.59,142.35 114.59,107.43 113.8,106.64 113.8,105.62 115.63,103.79 115.63,95.46 v2(113.57,93.41)
  BOTTOM w0.102: v2(113.57,93.41) 113.39,93.23 112.96,93.23 112.08,92.35 U5000.2 ; v3(197.26,132.32) 194.85,132.32 193.6,131.07 Q5000.3 191.89,132.03 Q5000.1
H_BPM0_XDP#: length 39.8
  TOP w0.102: CN4920.21 238.67,81.02 238.8,80.88 239.22,80.88 239.58,81.24 v2(239.71,81.24)
  L5 w0.102: v2(239.71,81.24) 239.71,81.95 238.73,82.93 234.54,82.93 234.04,82.43 233.04,82.43 230.65,84.82 226.14,84.82 222.82,81.5 222.82,79.04 222.08,78.29 219.67,78.29 218.49,79.47 216.89,79.47 v2(216.45,79.02)
  BOTTOM w0.076: U4555.J60 210.56,79.2 213.11,79.2 213.87,78.45 215.87,78.45 v2(216.45,79.02)
H_BPM1_XDP#: length 39.1
  TOP w0.102: v2(239.02,81.37) 238.86,81.52 CN4920.23
  L6 w0.102: v2(210.51,78.45) 211.98,76.98 211.98,76.49 212.67,75.8 214.38,75.8 215.37,76.79 225.36,76.79 226.09,77.53 226.09,78.09 226.47,78.47 227.27,78.47 228.95,76.8 235.57,76.8 235.74,76.97 235.74,77.38 235.31,77.81 235,77.81 234.92,77.89 234.92,79.71 235.31,80.1 236.48,80.1 237.75,81.37 v2(239.02,81.37)
  BOTTOM w0.076: U4555.H60 210.51,78.33 v2(210.51,78.45)
H_BPM2_XDP#: length 4.3
  TOP w0.076: TP4552.1 213.82,77.37 v2(213.82,77.66)
  BOTTOM w0.076: U4555.H61 210.86,78.03 211.12,77.78 212.6,77.78 213.07,77.3 213.46,77.3 v2(213.82,77.66)
H_BPM3_XDP#: length 4.2
  TOP w0.076: TP4553.1 214.79,77.33 v4(214.43,77.69)
  BOTTOM w0.076: v4(214.43,77.69) 214.06,78.06 212.83,78.06 212.66,78.23 212.53,78.36 211.81,78.36 211.51,78.07 U4555.H62
H_BPM4_XDP#: length 1.3
  TOP w0.076: v2(209.12,79.3) 209.07,79.25 TP4554.1
  BOTTOM w0.076: U4555.K59 209.33,79.3 v2(209.12,79.3)
H_BPM5_XDP#: length 2.8
  TOP w0.076: v2(213.25,77.68) 212.51,76.95 TP4555.1
  BOTTOM w0.076: U4555.H63 212.16,78.07 212.59,78.07 212.7,77.96 212.98,77.68 v2(213.25,77.68)
H_BPM6_XDP#: length 1.6
  TOP w0.076: TP4556.1 209.83,80 v2(209.9,79.92)
  BOTTOM w0.076: v2(209.9,79.92) 209.9,79.84 U4555.K60
H_BPM7_XDP#: length 1.4
  TOP w0.076: TP4557.1 211.14,78.94 v2(211.14,78.44)
  BOTTOM w0.076: U4555.J61 211.14,78.58 v2(211.14,78.44)
H_PECI: length 89.1
  TOP w0.102: R328.2 269.22,114.33 268.76,113.87 268.76,112.39 v2(269.53,111.62)
  L3 w0.102: v2(214.31,80.24) 213.81,79.74 212.83,79.74 212.43,80.14 212.43,82.79 213.06,83.42 214.64,83.42 215.77,84.56 218.95,84.56 221.08,84.56 223.76,87.23 224.57,87.23 225.08,87.74 228.99,87.74 229.27,87.47 231.49,87.47 233.98,89.96 235.88,89.96 236.3,90.38 247.93,90.38 249.03,91.47 255.35,91.47 256.69,90.12 260.35,90.12 262.29,92.06 262.29,96.48 265.41,99.61 265.41,100.81 267.55,102.95 267.55,105.81 269.75,108.02 269.75,111.4 v2(269.53,111.62)
  BOTTOM w0.076: U4555.N62 211.81,80.77 212.07,80.77 212.07,80.78 212.49,80.78 212.5,80.79 212.5,80.79 213.76,80.79
  BOTTOM w0.102: 213.76,80.79 v2(214.31,80.24)
H_PRDY#: length 28.9
  TOP w0.102: v3(225.18,78.27) 227.78,75.67 234.55,75.67 235.9,77.02 CN4920.5
  L5 w0.102: v4(218.06,79) 219.2,77.86 223.07,77.86 223.68,78.47 224.97,78.47 v3(225.18,78.27)
  BOTTOM w0.076: v4(218.06,79) 217.32,78.27 212.88,78.27 212.7,78.44 212.62,78.53 211.81,78.53 211.51,78.82 U4555.J62
H_PREQ#: length 28.5
  TOP w0.102: v2(224.42,77.46) 224.42,77.1 v1(224.82,76.69) 226.27,76.69 227.5,75.46 234.84,75.46 235.9,76.52 CN4920.3
  L5 w0.102: v2(224.42,77.46) 224.21,77.66 218.7,77.66 217.76,78.6 216.16,78.6 215.75,79 v2(214.13,79)
  BOTTOM w0.102: U4555.K62 211.51,79.57 211.82,79.87 212.67,79.87 212.79,79.75 213.38,79.75 v2(214.13,79)
H_PWRGD: length 7.8
  BOTTOM w0.076: U4555.C61 210.54,75.12 210.52,75.1 210.52,74.41 210.59,74.34 210.59,73.75 210.79,73.55
  BOTTOM w0.102: R4527.2 v1(215.42,72.25) 214.58,73.09 211.25,73.09 210.79,73.55
H_TCK: length 47.2
  TOP w0.102: R4822.2 238.62,90.02 CN4920.57 235.38,90.02 234.98,90.02 v2(234.51,89.55) ; R4509.2 v1(221.65,72.74) 220.81,72.74 218.14,75.4 217.02,75.4 v2(216.24,76.19)
  L3 w0.102: v2(234.51,89.55) 234.51,87.98 233.81,87.28 233.03,87.28 230.54,84.8 226.02,84.8 223.12,81.9 220.72,81.9 219.11,80.29 219.11,78.57 217.51,76.97 217.02,76.97 v2(216.24,76.19)
  L6 w0.102: v2(216.24,76.19) 215.45,76.19 214,74.74 211.97,74.74 v2(210.6,76.11)
  BOTTOM w0.076: v2(210.6,76.11) 210.6,76.15 U4555.E60
H_TDI: length 41.7
  TOP w0.102: R4508.1 222.9,77.85 v1(221.65,77.85) 221.4,78.09 217.3,78.09 v4(216.87,77.67) ; v2(224.52,87.89) 224.97,88.34 224.97,88.73 225.77,89.54 225.77,89.84 226.79,90.85 227.63,90.85 228.45,91.66 Q4921.1
  L3 w0.102: v2(224.52,87.89) 223.9,87.89 220.93,84.92 215.42,84.92 214.78,84.28 213.02,84.28 212.69,84.28 212.12,83.71 212.12,80.05 212.66,79.51 215.03,79.51 v4(216.87,77.67)
  BOTTOM w0.102: v4(216.87,77.67) 216.04,76.83 213.02,76.83 212.52,77.32 212.16,77.32 U4555.F63
H_TDO: length 40.4
  TOP w0.102: v2(223.96,88.7) 223.96,89.79 v1(224.44,90.28) 225.83,91.66 Q4920.1 ; v4(216.25,77.64) 216.97,78.35 221.15,78.35 221.53,78.74 R4920.1
  L3 w0.102: v4(216.25,77.64) 215.5,78.39 212.63,78.39 211.87,79.16 211.87,83.81 212.56,84.5 214.64,84.5 215.27,85.12 220.83,85.12 223.96,88.25 v2(223.96,88.7)
  BOTTOM w0.076: 212.99,77.14 212.51,77.61 211.81,77.61 211.51,77.32 U4555.F62
  BOTTOM w0.102: v4(216.25,77.64) 215.74,77.12 213,77.12 212.99,77.14
H_TMS: length 47.9
  TOP w0.102: R4507.1 222.23,75.47 220.63,77.07 216.57,77.07 215.3,75.8 v3(215.3,75.3) ; v2(224.57,88.73) 225.53,89.69 225.53,89.97 226.61,91.05 227.38,91.05 227.81,91.49 227.81,92.77 227.62,92.96 Q4921.4
  L3 w0.102: v3(215.3,75.3) 215.3,77.76 214.85,78.2 212.44,78.2 211.61,79.03 211.61,84.31 212.63,85.33 214.89,85.33 215.66,86.1 216.31,86.1 216.32,86.09 220.46,86.09 223.48,89.11 224.22,89.11 224.57,88.77 v2(224.57,88.73)
  BOTTOM w0.076: 212.91,75.81 212.69,75.81 212.29,76.21 211.82,76.21 211.8,76.23 211.17,76.23 U4555.E61
  BOTTOM w0.102: v3(215.3,75.3) 214.79,75.81 212.91,75.81
H_TRST#: length 49.3
  TOP w0.102: Q4920.4 224.65,93.49 R4526.1 224.19,93.97 v2(224.06,93.84) 224.03,93.86 222.74,93.86 v1(222.05,93.18) 218.42,89.55 212.84,89.55 212.49,89.9 211.19,89.9 208.95,87.66 208.95,87.36 206.53,84.95 206.53,79.11 207.04,78.6 208.19,78.6 208.67,78.12 208.67,77.51 209.2,76.97 v2(209.88,76.97)
  BOTTOM w0.102: v2(224.06,93.84) 221.73,96.17 213.92,96.17 212.5,94.75 212.5,94.37 212.3,94.17 211.9,94.17 211.51,94.55 U4555.AU62 ; U4555.E59 209.88,76.85 v2(209.88,76.97)
HDA_SDO_R: length 31.7
  TOP w0.114: Q4754.3 157.75,109.84 Q4756.3 162.51,109.84 R4874.2 162.82,109.73 v2(162.82,110.52)
  L6 w0.114: v3(178.42,97.41) 177.26,97.41 176.99,97.68 176.53,97.68 174.89,99.32 174,99.32 172.73,100.6 172.73,101.61 170.64,103.7 169.24,103.7 162.82,110.11 v2(162.82,110.52)
  BOTTOM w0.076: v3(178.42,97.41) 178.57,97.25 178.7,97.13 178.87,96.96 178.87,96.35 179.06,96.16 179.38,96.16 179.45,96.08 179.45,95.65 179.53,95.56 179.53,94.9 179.87,94.57 U4555.AU11
HDD_HALTLED: length 66.4
  TOP w0.102: CN200.17 107.55,90.02 107.55,89.55 106.51,88.5 104.68,88.5 103.03,86.85 103.03,85.99 103.54,85.48 v2(103.54,84.95)
  L3 w0.102: v2(103.54,84.95) 103.54,84.45 103.91,84.08 111.89,84.08 114.07,81.89 132.59,81.89 136.27,78.22 137.07,78.22 140.29,74.99 149.18,74.99 150.02,74.15 v3(151.42,74.15)
  BOTTOM w0.102: v3(151.42,74.15) 151.8,74.53 R4867.1
HDD_HALTLED_R: length 24.7
  L5 w0.102: v2(152.79,79.94) 154.47,81.62 155.16,81.62 155.54,82 160.51,82 160.53,82.03 163.07,82.03 163.91,81.18 170.08,81.18 v3(170.74,80.53)
  BOTTOM w0.076: U4555.N2 174.19,81.11 173.89,81.4 173.05,81.4 172.94,81.51 172.56,81.51 172.27,81.23 172.27,81.11 171.68,80.53 v3(170.74,80.53)
  BOTTOM w0.102: R4867.2 152.31,80.42 v2(152.79,79.94)
HDD_SM_HALTLED: length 23.9
  TOP w0.102: Q9032.5 R9037.1 75.17,124.57 v3(75.47,124.87) 75.17,125.17 R9035.2 ; CN9000.17 v2(79.5,106.92)
  L6 w0.102: v3(75.47,124.87) 75.47,123.81 77.5,121.78 77.5,108.92 v2(79.5,106.92)
HDD_STP#: length 71
  TOP w0.102: v4(39.78,154.8) 40.09,155.1 D9030.3 ; Q9032.2 71.36,123.94 ; 71.36,123.94 71.36,123.46 71.53,123.29 Q9032.3 ; 71.36,123.94 71.36,125.41 v3(71.66,125.72) 72.55,126.6 R9036.2
  L6 w0.102: v4(39.78,154.8) 40.55,154.04 54.64,154.04 71.15,137.53 74.45,137.53 77.68,134.3 77.68,129.96 74.58,126.86 72.8,126.86 v3(71.66,125.72)
HP_AMP_PD#: length 61.2
  TOP w0.102: D501.3 294.01,62.25 v2(294.01,61.66)
  TOP w0.254: U551.6 310.69,58.55 v2(310.27,58.13) ; U550.6 310.36,72.77 R570.1 310.85,71.46 v2(310.85,71.28)
  L3 w0.102: v2(280.32,54.9) 283.49,54.9 284.35,55.76 286.72,55.76 290.63,59.68 292.15,59.68 292.77,60.29 292.77,61.38 293.1,61.71 293.96,61.71 v2(294.01,61.66)
  L3 w0.254: v2(294.01,61.66) 294.44,62.09 297.97,62.09 298.48,61.58 298.48,57.14 298.86,56.75 303.33,56.75 304.48,57.9 306.48,57.9 307.12,57.26 309.53,57.26 310.27,58 v2(310.27,58.13) 310.27,58.79 309.73,59.32 309.73,61.91 310.42,62.6 310.42,66.46 309.79,67.09 309.79,70.85 310.22,71.28 v2(310.85,71.28)
  BOTTOM w0.102: R503.1 280.45,52.48 280.45,54.77 v2(280.32,54.9)
HP_OUT_AMP_L1: length 53.6
  TOP w0.381: L550.2 311.38,52.66 C575.1 310.97,52.86 v2(310.55,52.44)
  L6 w0.254: v2(310.55,52.44) 315.12,52.44 315.73,51.83 315.73,14.62 318.11,12.23 318.11,11.87 v2(318.09,11.84)
  BOTTOM w0.254: JACK600.4 319.94,12.6 319.18,11.84 C602.1 v2(318.09,11.84)
HP_OUT_AMP_R1: length 56.6
  TOP w0.381: L551.2 308.47,54.07 C574.1 308.47,52.86 308.77,52.56 v2(308.77,52.44)
  L6 w0.254: v2(317.02,12.05) 315.09,13.98 315.09,48.99 312.15,51.93 309.28,51.93 v2(308.77,52.44)
  BOTTOM w0.254: JACK600.1 321.11,6.76 C601.1 317.74,6.76 317.02,7.48 v1(317.02,10.27) v2(317.02,12.05)
HP_OUT_L1: length 6.3
  TOP w0.254: C572.2 306.78,63.36 v2(307.63,63.36) ; U501.31 304.94,60.26 v2(305.11,60.08)
  L3 w0.254: v2(307.63,63.36) 307.37,63.1 307.37,62.29 305.16,60.08 v2(305.11,60.08)
HP_OUT_R1: length 2.4
  TOP w0.254: U501.32 304.33,60.68 305.35,60.68 305.71,60.32 305.71,60.15 C573.2
HPOUT_DET: length 2.6
  TOP w0.254: R515.2 292.51,57.14 v1(291.88,56.5) 292.33,56.05 Q600.3
HUB_XTAL_IN: length 9.4
  TOP w0.102: U2550.62 267.92,57.05 267.34,56.47 267.34,55.84 267.49,55.69 267.51,55.69 267.75,55.44 267.75,54.94 267.75,54.94 R2500.2 266.95,54.13 266.35,54.13 C2566.2 266.35,54.24 265.49,55.1 263.56,55.1 262.71,54.25 X2500.3
HUB_XTAL_OUT: length 6.5
  TOP w0.102: U2550.61 267.91,57.55 267.24,56.88 v1(266.99,56.88) 266.99,55.74 267.24,55.48 R2500.1 267.07,55.28 266.73,54.93 C2550.2 266.24,54.93 265.69,55.48 265.25,55.48 X2500.1
I2C_CLK: length 263.8
  TOP w0.114: v2(151.9,71.17) 152.03,71.3 152.03,78.54 151.67,78.9 151.67,82.28 154.95,85.56 v3(154.95,85.9)
  L3 w0.102: v2(301.35,79.46) 302.03,80.14 302.03,87.99 304.17,90.13 304.17,100.29 304.5,100.62 304.5,107.36 306.02,108.87 306.02,110.65 306.99,111.62 317.41,111.62 318.45,112.66 318.45,118.78 318.22,119.01 318.22,119.87 319.49,121.14 321.32,121.14 322.36,122.18 323.18,122.18 CN3601.32 ; v2(286.24,58.99) 286.42,58.81 286.42,57.9 285.2,56.68 283.93,56.68 283.04,55.79 279.25,55.79 277.96,54.49 276.74,54.49 275.77,55.46 267.01,55.46 265.36,53.8 260.39,53.8 258.55,55.64 257.99,55.64 257.69,55.33 257.69,54.52 256.56,53.39 243.48,53.39 240.57,56.3 232.03,56.3 230.29,54.56 224.15,54.56 222.99,53.4 181.69,53.4 174.72,60.37 174.72,65.07 173.01,66.79 173.01,69.71 171.61,71.11 166.67,71.11 165.35,72.43 159.72,72.43 157.65,70.36 152.71,70.36 v2(151.9,71.17)
  L5 w0.114: v2(286.24,58.99) 287,58.99 287.43,59.42 293.63,59.42 295.66,61.45 295.66,67.8 297.47,69.61 297.47,72.76 301.19,76.48 301.19,79.3 v2(301.35,79.46)
  BOTTOM w0.114: R4835.2 154.75,86.09 v3(154.95,85.9)
I2C_DATA: length 260.3
  TOP w0.114: v3(150.22,83.47) 150.04,83.29 150.04,79.6 150.46,79.17 150.47,79.17 150.93,78.71 150.93,78.71 151.14,78.49 151.14,78.49 151.29,78.34 151.29,75.48 150.86,75.04 150.86,72.1 v2(151.31,71.64)
  L3 w0.102: v2(300.74,79.49) 301.63,80.38 301.63,88.1 303.82,90.28 303.82,107.17 305.48,108.84 305.48,110.87 306.71,112.1 317.17,112.1 317.99,112.92 317.99,118.64 317.85,118.78 317.85,120.32 319.95,122.41 321.18,122.41 321.47,122.7 CN3601.33 ; v2(151.31,71.64) 152.41,71.64 153.07,70.98 157.64,70.98 158.08,71.41 159.45,72.78 165.5,72.78 166.82,71.46 171.76,71.46 173.36,69.86 173.36,66.94 174.42,65.88 174.42,65.87 175.08,65.22 175.08,60.52 181.84,53.76 222.76,53.76 223.96,54.95 230.18,54.95 231.69,56.46 231.69,56.46 231.88,56.65 240.72,56.65 243.5,53.87 255.62,53.87 256.52,54.77 256.52,55.69 257.36,56.53 260.65,56.53 260.93,56.8 267.09,56.8 267.58,56.31 276.88,56.31 277.83,57.26 279.08,57.26 279.46,56.88 281.74,56.88 282.07,57.21 283.55,57.21 285.38,59.04 v2(285.66,59.04)
  L5 w0.114: v2(285.66,59.04) 286.11,59.5 286.72,59.5 287.1,59.88 293.07,59.88 295.21,62.02 295.21,72.56 296.93,74.28 298.3,74.28 300.27,76.24 300.27,79.01 v2(300.74,79.49)
  BOTTOM w0.114: R4836.2 149.38,83.47 v3(150.22,83.47)
ICCINSERTN: length 36.4
  TOP w0.102: v2(69.12,114.16) 73.44,114.16 75.06,115.78 U9000.19 75.06,118.83 v1(75.09,118.86)
  BOTTOM w0.102: CN9001.9 54.61,122.61 52.68,122.61 51.34,121.27 51.34,117.59 53.63,115.3 67.98,115.3 v2(69.12,114.16)
ICS: length 8.6
  TOP w0.254: R6913.1 284,132.7 284.89,133.59 v1(285.27,133.59) 285.53,133.59 286.14,132.97 286.14,131.7 286.59,131.26 C6049.1 286.67,131.18 287.31,130.54 288.02,130.54 288.32,130.24 288.32,129.07 U6000.7
IM_5S_CLK: length 243
  TOP w0.114: v2(101.25,88.89) 102.9,88.89 103.55,89.53 CN200.9 ; R385.1 281.51,92.7 280.58,92.7 v3(279.81,93.46) 279.18,94.09 279.18,95.36 278.74,95.8 278.74,97.14 278.55,97.33 U300.35
  L5 w0.114: v2(101.25,88.89) 101.63,88.51 108.78,88.51 110.94,86.35 111.72,86.35 113.97,84.09 113.97,82.96 115.98,80.95 124.47,80.95 125.85,79.58 129.11,79.58 132.47,76.22 132.47,75.62 132.61,75.48 132.61,70.91 135.36,68.16 139.33,68.16 142.55,64.93 163.13,64.93 164.93,63.13 166.65,63.13 167.32,62.47 170.72,62.47 177.39,55.8 180.46,55.8 180.8,55.46 187.9,55.46 188.22,55.78 194.23,55.78 195.01,54.99 222.37,54.99 223.57,56.19 230.61,56.19 231.51,57.09 239.54,57.09 241.59,55.04 249.77,55.04 250.36,54.45 255.37,54.45 256.04,55.12 256.04,55.45 256.04,55.56 256.04,55.86 257.22,57.03 260.77,57.03 261.39,57.66 265.07,57.66 265.89,58.47 265.89,61.1 266.54,61.75 266.54,62.77 266.96,63.19 268.05,64.28 268.05,65.59 268.46,66 269.7,66 270.11,66.41 272.45,66.41 274.05,68.01 v2(274.71,68.01)
  BOTTOM w0.114: v3(279.81,93.46) 278.65,92.3 278.65,87.56 273.11,82.02 273.11,72.25 272.45,71.59 272.45,70.27 v2(274.71,68.01)
IM_5S_CLK_SM: length 55.2
  TOP w0.114: CN9021.3 73.81,149.85 75.98,147.69 v3(75.98,143.24) ; CN9000.9 75.5,106.57 v2(74.96,106.03)
  L3 w0.102: v2(74.96,106.03) 75.47,106.54 75.47,115.81 80.17,120.51 80.17,135.62 78.52,137.27 78.52,142.35 77.63,143.24 v3(75.98,143.24)
IM_5S_DATA: length 234.4
  TOP w0.114: v2(102.39,84.64) 101.78,85.25 101.78,87.13 104.05,89.4 CN200.10 ; U300.32 276.13,94.93 v2(276.13,92.99) R386.1
  L5 w0.114: v2(270.42,65.96) 269.62,65.16 269.62,60.75 267.61,58.74 267.07,58.74 265.37,57.05 261.49,57.05 261.09,56.65 257.36,56.65 256.41,55.71 256.41,55.6 256.41,55.6 256.41,55.28 256.41,54.97 255.53,54.08 249.71,54.08 249.13,54.67 241.45,54.67 239.5,56.62 231.88,56.62 231.02,55.76 223.81,55.76 223.78,55.73 223.36,55.32 223.36,55.31 222.58,54.54 194.95,54.54 194.08,55.41 188.37,55.41 188.19,55.23 188.05,55.09 180.65,55.09 180.36,55.39 177.28,55.39 170.62,62.04 162.84,62.04 160.79,64.1 153.3,64.1 152.69,63.49 139.47,63.49 132.24,70.72 132.24,75.09 131.35,75.98 131.35,76.79 128.94,79.21 125.46,79.21 124.82,79.85 124.81,79.85 124.2,80.46 115.95,80.46 111.61,84.8 107.79,84.8 107.49,84.8 106.75,84.06 102.98,84.06 v2(102.39,84.64)
  BOTTOM w0.114: v2(276.13,92.99) 276.38,92.74 276.38,89.39 276.89,88.89 276.89,86.35 272.38,81.84 272.38,72.38 271.81,71.81 v1(271.81,69.84) 271.81,67.86 270.42,66.47 v2(270.42,65.96)
IM_5S_DATA_SM: length 54.4
  TOP w0.114: CN9021.4 73.43,149.35 74.71,148.07 v3(74.71,143.75) ; CN9000.10 v2(76,106.79)
  L3 w0.102: v3(74.71,143.75) 74.96,144 78.39,144 79.28,143.11 79.28,137.53 80.93,135.88 80.93,120.25 77.5,116.83 77.5,108.29 v2(76,106.79)
INTLWAKE#: length 35.4
  TOP w0.102: v2(151.75,97.11) 151.83,97.11 152.28,96.66 152.28,93.03 153.38,91.93 R4717.2 153.32,91.85 153.32,91 R4934.1
  L6 w0.102: v2(175.95,92.18) 175.74,92.18 175.1,92.82 174.36,92.82 173.3,93.88 173.3,94.77 170.44,97.63 161.56,97.63 161.29,97.9 154.95,97.9 153.68,96.63 152.22,96.63 v2(151.75,97.11)
  BOTTOM w0.076: v2(175.95,92.18) 176.22,92.18 U4555.AN5
INTRUDER#: length 170.1
  TOP w0.102: v3(148.75,100.95) 149.64,100.06 149.64,96.16 150.2,95.6 150.2,93.49 149.77,93.06 149.77,89.62 149.59,89.44 149.59,86.01 148.76,85.19 148.76,78.33 v2(150.27,76.82)
  L5 w0.102: v2(150.27,76.82) 152.23,78.78 155.23,78.78 155.69,78.31 159.08,78.31 159.19,78.19 161.35,78.19 163.1,76.44 165.89,76.44 167.09,77.63 169.16,77.63 170.98,75.8 173.07,75.8 175.09,73.79 177.93,73.79 178.86,74.72 181.99,74.72 183.61,74.72 184.56,73.77 185.67,73.77 186.05,74.15 195,74.15 203.2,74.15 203.72,73.63 206.13,73.63 207.26,72.5 216.8,72.5 217.25,72.04 223.25,72.04 224.49,73.29 227.79,73.29 229.62,75.12 235.33,75.12 235.87,74.58 243.82,74.58 243.97,74.74 245.32,74.74 v2(245.39,74.67)
  L6 w0.102: v2(155.48,103.11) 150.55,103.11 148.75,101.31 v3(148.75,100.95)
  BOTTOM w0.076: U4555.AU6 176.87,94.57 176.58,94.86 176.58,95.64 176.62,95.68 176.62,96.91 176.43,97.1 176.43,97.17
  BOTTOM w0.102: 176.43,97.17 176.42,97.18 176.42,97.76 175.39,98.79 172.75,98.79 172.14,99.4 171.05,99.4 170.32,100.13 170.32,100.33 166.78,103.87 166.41,103.87 164.89,105.4 162.34,105.4 161.45,104.51 156.88,104.51 v2(155.48,103.11) ; v3(148.75,100.95) 148.75,100.32 148.37,99.93 Q4831.3 145.83,99.93 145.36,100.4 R4833.2 ; R1405.2 244.84,75.21 v2(245.39,74.67)
INTVRMEN_R: length 9.2
  BOTTOM w0.076: 177.41,97.93 177.7,97.65 177.7,97.09 177.95,96.84 177.95,95.51 177.7,95.25 U4555.AV7
  BOTTOM w0.102: 173.68,101.97 R4842.2 173.68,101.29 v1(174.66,100.32) 175.03,100.32 176.27,99.07 177.1,98.25 177.41,97.93
  BOTTOM w0.114: R4876.2 173.68,101.97
INV_PWM: length 105.4
  TOP w0.102: v2(114.13,119.47) 114.92,120.25 C3015.1
  L5 w0.102: v2(114.13,119.47) 114.64,118.96 114.64,116.32 117.06,113.9 117.06,96.74 119.33,94.47 123.3,94.47 124.03,93.74 124.89,93.74 127.43,91.2 132.39,91.2 134.79,88.79 135.21,88.37 135.21,88.08 135.21,88.08 135.21,87.78 135.21,87.78 135.21,85.89 143.85,77.25 145.07,77.25 148.23,74.09 150.84,74.09 152.08,72.86 153.73,72.86 153.98,73.11 157.97,73.11 158.68,72.4 176.17,72.4 v3(176.84,71.73)
  BOTTOM w0.076: U4555.B8 178.36,74.47 178.36,73.45 176.82,71.9 176.82,71.75 v3(176.84,71.73)
  BOTTOM w0.127: v2(114.13,119.47) 114.84,118.76 114.84,117.59 114.5,117.25 112.98,117.25 CN3000.18
ISCT_LED#: length 28.9
  TOP w0.102: v3(283.07,96.91) 282.97,97.01 R319.1 ; Q113.1 286.23,114.3 286.23,110.67 285.02,109.46 285.02,105.7 283.88,104.56 v2(283.88,104.38) ; v2(280.47,91.98) 280.47,91.45 280.19,91.17 280.19,90.74 R323.1
  L3 w0.102: v2(283.88,104.38) 283.62,104.13 283.62,97.47 v3(283.07,96.91) 281.97,95.81 281.97,93.46 280.47,91.96 v2(280.47,91.98)
ISO_PREP#: length 194.2
  TOP w0.102: v2(312.36,115.68) 313.09,115.68 v1(313.85,114.92) 317.02,111.75 317.02,110.22 316.47,109.66 316.47,108.99 316.01,108.53 316.01,108.06 315.87,107.92 Q486.1 315.56,107.92 315.29,107.66 C486.1 315.24,106.87 v2(315.24,106.28)
  TOP w0.114: v2(166.28,108.57) 167.89,106.96 167.89,105.05 168.81,104.13 168.81,102.97 168.81,96.41 v2(169.86,95.36)
  L3 w0.102: v2(312.36,115.68) 312.36,115.94 311.21,117.08 302.98,117.08 301.88,118.17 299.32,118.17 297.69,116.55 v2(297.59,116.55)
  BOTTOM w0.076: 169.22,95.72 R4857.2 169.48,95.74 v2(169.86,95.36)
  BOTTOM w0.102: v2(315.24,106.28) 315.49,106.04 319.72,106.04 320.39,106.7 CN3601.47 ; v2(297.59,116.55) 297.11,116.55 295.56,118.1 294.29,118.1 292.89,116.7 289.85,116.7 286.26,113.12 276.89,113.12 276.13,113.88 266.52,113.88 266.04,114.36 265.25,114.36 264.96,114.65 264.96,114.99 262.88,117.08 259.5,117.08 258.3,118.29 252.68,118.29 251.94,117.55 250.54,117.55 243.51,117.55 243.09,117.13 242.68,116.72 212.18,116.72 211.2,115.73 208.19,115.73 171.17,115.73 166.28,110.84 v2(166.28,108.57) ; R4700.1 168.39,94.89 169.22,95.72
JTAG_RST#: length 203.4
  TOP w0.102: U300.49 278.85,102.93 v1(279.57,102.21) 281.08,102.21 281.96,103.09 v2(281.96,103.27) R371.1 ; v2(142.27,80.45) 142.68,80.86 142.68,82.81 143.85,83.98 143.85,95.82 144.96,96.94 144.96,102.37 143.8,103.54 143.8,105.68 v2(144.31,106.2)
  L5 w0.102: v2(281.96,103.27) 281.96,103.31 280.26,105.01 274.23,105.01 271.27,107.97 267.94,107.97 263.94,111.97 263.94,112.63 263.23,113.35 263.23,121.63 262.59,122.27 v2(262.59,123.81)
  BOTTOM w0.102: R335.1 142.85,79.87 v2(142.27,80.45) ; v2(144.31,106.2) 144.31,108.46 152.54,116.69 156.86,116.69 157.07,116.9 170.17,130 189.82,130 190.24,129.57 191.47,128.34 193.66,128.34 194.25,128.34 194.25,128.34 195.78,129.87 201.7,129.87 205.32,126.25 206.26,126.25 227.18,126.25 228.3,126.25 228.89,126.25 228.89,126.25 234.13,126.25 234.42,126.25 234.42,126.25 236,126.25 238.31,126.25 240.29,128.23 244.02,128.23 245.19,127.06 258.54,127.06 261.79,123.81 v2(262.59,123.81)
KBC_ECPH_CLK: length 168.6
  TOP w0.114: v2(254.29,98.92) 256.2,97.01 260.12,97.01 260.44,97.33 U300.126 ; R4829.1 154.26,92.91 v2(155.05,92.11)
  L3 w0.102: v2(250.48,121.78) 250.48,122.54 250.73,122.79 251.24,122.79 251.9,122.13 251.9,111.16 253.63,109.43 253.63,100.74 253.91,100.46 253.91,99.3 v2(254.29,98.92)
  L5 w0.114: v2(155.05,92.11) 151.87,88.92 149.31,88.92 v2(146.12,85.74)
  BOTTOM w0.114: v2(250.48,121.78) 250.34,121.92 241.7,121.92 240.84,121.05 209.12,121.05 208.02,119.96 167.38,119.96 157.84,110.42 154.67,110.42 153.85,109.6 153.85,93.32 v2(155.05,92.11) ; Q4753.6 146.11,85.73 v2(146.12,85.74)
KBC_ECPH_DATA: length 160.2
  TOP w0.114: U300.125 259.87,97.73 259.64,97.5 v1(259.37,97.5) 256.45,97.5 254.46,99.48 R4838.1 254.46,100.61 v3(255.3,101.46) ; v2(146.76,84.82) 145.91,84.82 144.21,86.52 144.21,95.67 145.32,96.79 145.32,102.52 144.52,103.33 144.3,103.54 v2(144.3,105.14)
  L6 w0.114: v2(144.3,105.14) 144.3,105.52 145.64,106.86 158.46,106.86 v2(160.31,105.01)
  BOTTOM w0.114: v2(160.31,105.01) 159.93,105.4 159.93,108.19 161.18,109.45 163.51,109.45 163.62,109.33 163.62,109.33 167.05,105.9 167.42,105.9 169.78,103.54 171.6,103.54 171.93,103.87 173.66,103.87 174.04,104.25 175.67,104.25 176.31,104.89 177.71,104.89 178.09,104.51 181.64,104.51 182.81,105.67 236.78,105.67 237.46,104.99 253.92,104.99 254.41,104.51 255.81,104.51 256.34,103.98 256.34,101.73 256.06,101.46 v3(255.3,101.46) ; v2(146.76,84.82) 146.75,84.82 146.75,84.82 147.14,84.42 Q4753.3
KBC_PROCHOT: length 62.6
  TOP w0.102: U300.90 266.08,111.25 265.53,111.8 v2(265.53,111.83) ; v2(229.78,90.18) 229.37,89.77 226.99,89.77 v1(226.61,89.39) 226.42,89.39 225.53,88.5 225.53,88.11 225.53,87.82 224.23,86.52 R4516.1 Q4501.1
  L3 w0.102: v2(229.78,90.18) 230.31,90.18 233.08,92.95 238.2,92.95 239.8,94.54 241.09,94.54 243.19,92.44 247.02,92.44 247.22,92.65 248.44,93.86 253.85,93.86 256.06,96.08 256.06,98.16 256.7,98.79 256.7,101.45 257.09,101.84 257.75,101.84 263.21,107.3 263.21,109.51 v2(265.53,111.83)
KBC_PWR_ON: length 255.7
  TOP w0.102: v2(217.58,144.51) 217.58,145.91 214.54,148.96 209.84,148.96 209.58,148.7 ; R352.2 257.21,109.59 v2(257.08,109.71) ; v2(199.04,142.89) 199.96,142.89 201.33,144.26 201.33,145.27 203.11,147.05 206.03,147.05 206.41,147.43 Q7350.2 206.41,148.45 206.92,148.96 209.33,148.96 209.58,148.7 ; 209.58,148.7 209.58,147.86 R7021.1
  TOP w0.254: R7019.1 118.02,97.01 v2(117.89,97.14)
  L3 w0.102: v2(155.61,101.71) 154.21,101.71 152.81,100.32 146.84,100.32 141.89,105.27 124.62,105.27 v2(117.63,112.25) ; v2(217.58,144.51) 219.26,146.19 228.36,146.19 229.63,144.92 238.69,144.92 240.46,146.7 246.39,146.7 247.56,145.53 247.56,144.13 247.96,143.72 255.84,143.72 255.96,143.6 257.77,141.79 257.77,141.5 257.77,132.88 251.24,126.35 251.24,123.43 252.25,122.41 252.25,111.36 253.91,109.71 v2(257.08,109.71)
  L5 w0.102: v2(155.61,101.71) 156.12,102.22 156.12,108.82 158.78,111.49 164.65,111.49 165.34,110.81 v3(165.34,110.55) ; v2(117.89,97.14) 118.02,97.27 118.02,97.9 117.51,98.41 117.51,112.13 v2(117.63,112.25)
  L6 w0.102: v2(199.04,142.89) 196.53,142.89 195.87,142.23 165.39,142.23 164.37,141.21 164.37,113.13 165.34,112.17 v3(165.34,110.55)
KBL_DET#: length 198.1
  TOP w0.102: v2(275.27,71.38) 275.27,72.38 v1(275.6,72.71) 278.92,76.03 v2(278.92,78.98) ; v2(298.91,81.8) 298.91,81.9 299.85,82.84 299.85,83.8 299.6,84.06 CN301.6 ; v2(169.45,65.11) 169.45,65.9 168.79,66.56 168.79,67.68 168.43,68.03 168.43,70.47 171.28,73.31 171.28,76.44 170.52,77.2 170.52,78.42 169.64,79.29 169.64,83.75 170.43,84.53 v2(170.56,84.53)
  L5 w0.102: v2(275.27,71.38) 275.27,70.34 274.16,69.23 273.27,69.23 271.52,67.48 269.86,67.48 269.53,67.14 268.05,67.14 266.91,66 266.91,64.66 265.46,63.21 265.46,62.8 265.02,62.35 264.01,62.35 259.63,57.98 252.09,57.98 251.72,57.61 250.97,56.85 250.69,56.58 242.27,56.58 240.86,57.98 230.97,57.98 230.35,57.36 223.5,57.36 221.98,55.84 196.56,55.84 195.39,57.01 177.55,57.01 v2(169.45,65.11)
  BOTTOM w0.076: 170.56,84.61 170.95,85 171.51,85 171.74,84.78 172.5,84.78 172.58,84.85 173.54,84.85 U4555.Y1 ; 170.56,84.61 v2(170.56,84.53) ; 170.56,84.61 170.56,84.65 170.13,85.08 169.55,85.08 169.5,85.03 169.22,85.03
  BOTTOM w0.102: v2(298.91,81.8) 298.76,81.8 298.38,81.42 296.68,81.42 292.01,86.09 285.3,86.09 283.27,84.06 281.08,84.06 278.44,81.42 278.44,79.36 278.82,78.98 v2(278.92,78.98) ; 169.22,85.03 165.56,85.03 165.23,85.36 161.44,85.36 160.69,86.11 160.69,86.73 160.41,87.01 158.96,87.01 R4729.2
KSCAN_3S_IN<0>: length 106.4
  TOP w0.102: v3(286.19,86.54) 285.89,86.84 D302.1 ; CN300.26 284.15,85.59 284,85.74 284,86.52 v2(284.08,86.6) ; v4(323.6,152.93) SW154.1
  L6 w0.102: v4(323.6,152.93) 323.22,152.93 322.36,153.78 319.24,153.78 314.03,148.57 314.03,134.33 317.94,130.42 317.94,125.89 316.46,124.42 315.37,124.42 311.69,120.74 311.69,120.51 310.54,119.36 310.21,119.36 310.21,119.36 304.34,119.36 302.95,117.96 297.09,117.96 295.23,116.1 293.13,116.1 291.27,114.24 291.27,113.56 286.21,108.5 286.21,105.73 286.54,105.4 286.54,102.47 286.21,102.14 286.21,100.95 285.23,99.96 285.23,91.52 287.43,89.32 287.43,87.79 v3(286.19,86.54)
  BOTTOM w0.102: v2(284.08,86.6) 284.13,86.54 v3(286.19,86.54)
KSCAN_3S_IN<1>: length 102.3
  TOP w0.102: SW152.1 v2(309.78,151.67) ; D302.5 286.54,89.19 v2(287.03,88.71) ; CN300.23 281.75,85.58 281.06,86.27 280.85,86.27 v1(280.68,86.45) 280.52,86.6 v2(280.52,87.13)
  L6 w0.102: v2(309.78,151.67) 313.82,147.63 313.82,134.23 317.72,130.33 317.72,125.96 316.38,124.62 315.17,124.62 311.24,120.69 311.24,120.5 310.29,119.56 303.07,119.56 302.11,118.6 295.07,118.6 290.9,114.43 290.9,113.68 286.01,108.79 286.01,105.64 286.29,105.36 286.29,103.52 284.77,102 284.77,91.68 287.03,89.42 v2(287.03,88.71) 285.68,87.36 280.75,87.36 v2(280.52,87.13)
KSCAN_3S_IN<2>: length 3.3
  TOP w0.102: D304.1 281.07,87.38 v1(281.95,86.5) 282.55,85.89 CN300.24
KSCAN_3S_IN<3>: length 10.3
  TOP w0.102: CN300.22 280.95,85.49 279.99,86.45 v1(279.99,87.84) 279.36,88.48 279.36,89.27 279.71,89.62 280.26,89.62 280.42,89.79 280.42,90.94 280.8,91.32 281.24,91.32 281.72,90.84 D304.5
KSCAN_3S_IN<4>: length 2.8
  TOP w0.102: D303.1 283.48,87.74 283.48,86.71 v1(283.27,86.5) 283.35,86.41 CN300.25
KSCAN_3S_IN<5>: length 14.8
  TOP w0.102: v3(274.61,86.74) 274.55,86.67 CN300.14 ; D303.5 284.13,89.9 283.5,90.54 283.5,91.27 v2(283.6,91.37)
  L3 w0.102: v3(274.61,86.74) 276.27,86.74 280.7,91.17 283.39,91.17 v2(283.6,91.37)
KSCAN_3S_IN<6>: length 16.5
  TOP w0.102: v3(284.13,92.16) 284.8,92.16 D301.1 ; v2(273.56,86.73) 273.75,86.55 CN300.13
  L3 w0.102: v3(284.13,92.16) 283.62,92.16 282.89,91.43 280.58,91.43 276.38,87.23 274.45,87.23 273.95,86.73 v2(273.56,86.73)
KSCAN_3S_IN<8>: length 4
  TOP w0.102: D302.2 286.54,87.23 286.8,86.98 287.19,86.98 v1(287.69,86.48) 287.44,86.48 286.55,85.59 CN300.29
KSCAN_3S_IN<9>: length 23.3
  TOP w0.102: CN300.9 270.55,85.74 270.92,86.12 270.92,86.47 271.66,87.21 v3(271.76,87.21) ; D302.4 287.19,89.58 287.19,89.86 286.87,90.18 285.43,90.18 v2(284.75,90.86)
  L3 w0.102: v2(284.75,90.86) 284.75,90.66 283.25,89.16 281.36,89.16 280.27,88.07 279.13,88.07 276.16,85.1 272.42,85.1 271.58,85.94 271.58,87.03 v3(271.76,87.21)
KSCAN_3S_IN<10>: length 9.4
  TOP w0.102: v3(279.99,89.11) 280.6,88.5 281.26,88.5 281.72,88.05 D304.2 ; v2(284.46,86.05) 284.95,85.55 CN300.27
  BOTTOM w0.102: v3(279.99,89.11) 283.06,86.05 v2(284.46,86.05)
KSCAN_3S_IN<11>: length 16.1
  TOP w0.102: v3(282.33,90.76) 282.37,90.72 D304.4 ; CN300.10 271.35,86.14 271.81,86.6 272.32,86.6 v2(272.68,86.24)
  L3 w0.102: v2(272.68,86.24) 273.36,85.56 275.53,85.56 280.03,90.05 281.62,90.05 v3(282.33,90.76)
KSCAN_3S_IN<12>: length 3.4
  TOP w0.102: D303.2 284.13,87.31 v1(284.9,86.54) 285.75,85.69 CN300.28
KSCAN_3S_IN<13>: length 17.3
  TOP w0.102: D303.4 284.78,89.58 284.78,89.58 284.78,90.05 v3(284.06,90.76) ; v2(272.02,86.14) 272.15,86.01 CN300.11
  L3 w0.102: v2(272.02,86.14) 272.85,85.3 275.82,85.3 278.97,88.45 280.19,88.45 281.26,89.52 282.82,89.52 v3(284.06,90.76)
KSCAN_3S_IN<14>: length 7.6
  TOP w0.102: D301.2 287.62,90.58 288.45,89.75 v1(288.45,88.76) 288.7,88.5 288.7,86.35 288.26,85.9 287.56,85.9 287.35,85.69 CN300.30
L_BKLT_EN: length 103.5
  TOP w0.102: v2(114.08,116) 113.7,116 v1(113.19,115.49) 113,115.3 110.01,115.3 109.01,116.3 R3009.1 R3008.1
  L5 w0.102: v4(178.13,72.16) 178,72.16 177.15,71.31 176.42,71.31 175.68,72.04 175.24,72.04 175.21,72.08 174.87,72.08 174.83,72.04 174.78,72.04 158.3,72.04 157.69,72.65 154.18,72.65 154.03,72.5 151.72,72.5 150.58,73.65 147.92,73.65 144.66,76.9 143.67,76.9 134.86,85.71 134.86,87.93 134.86,88.22 134.65,88.43 134.65,88.43 132.26,90.82 127.16,90.82 124.72,93.25 123.04,93.25 122.18,94.12 119.18,94.12 116.59,96.7 116.59,113.49 v2(114.08,116)
  BOTTOM w0.076: U4555.A9 178.99,73.3 178.44,72.76 178.44,72.48 v4(178.13,72.16)
LAN_DIS#: length 179.6
  TOP w0.076: 175.14,94.58 175.58,94.14 176.12,94.14 176.38,93.89 176.38,92.07 v2(176.84,91.6)
  TOP w0.102: v2(282.01,102.56) 282.05,102.6 287.03,102.6 288.22,103.79 R405.1 288.7,104.38 290.35,106.03 v3(290.74,106.03) 291.37,106.66 U400.3 ; 175.14,94.58 175.04,94.68 175.04,95.62 173.74,96.91 173.74,100.04 174.38,100.67 174.38,105.34 v2(174.59,105.56) ; v2(295.14,114.41) 295.36,114.63 R488.1
  L3 w0.102: v2(295.14,114.41) 295.14,106.25 294.29,105.4 291.37,105.4 v3(290.74,106.03)
  L5 w0.102: v2(282.01,102.56) 282.48,103.03 282.48,104.3 281.39,105.4 274.6,105.4 272.45,107.55 v2(272.45,107.55)
  L6 w0.076: v2(176.84,91.6) 176.42,91.17 175.5,91.17 175.05,91.62 174.53,91.62 172.56,93.59
  L6 w0.102: v3(159.8,96.89) 159.97,97.05 165.09,97.05 166.33,95.82 170.12,95.82 172.35,93.59 172.56,93.59
  BOTTOM w0.076: v2(176.84,91.6) 176.99,91.6 177.27,91.31 U4555.AM7
  BOTTOM w0.102: v2(174.59,105.56) 174.59,107.62 176.03,109.06 181.59,109.06 182.74,109.06 238.67,109.06 238.93,109.32 240.31,109.32 240.53,109.1 247.5,109.1 247.7,109.3 258.48,109.3 258.66,109.47 261.91,109.47 262.82,108.57 264.7,108.57 266.99,106.28 269.65,106.28 270.92,107.55 v2(272.45,107.55) ; v3(159.8,96.89) 159.01,96.1 R4721.2
LANLINK_STATUS: length 208.3
  TOP w0.102: v2(317.02,113.14) v1(318.93,111.24) 322.23,111.24 322.69,111.7 CN3601.11 ; v2(165.12,92) 165.37,92.25 165.37,99.28 166.66,100.57 166.66,103.72 164.75,105.63 164.75,110.5 v2(164.65,110.6) ; Q487.3 298.42,116.36 v2(297.59,117.18)
  L3 w0.102: v2(297.59,117.18) 297.59,117.84 298.37,118.62 298.69,118.62 299.94,119.87 302.55,119.87 302.85,119.58 310.46,119.58 316.9,113.14 v2(317.02,113.14)
  BOTTOM w0.076: 171.35,90.61 171.4,90.56 173.66,90.56 173.83,90.72 173.83,90.9 174.06,91.14 174.58,91.14 174.84,90.89 U4555.AL3
  BOTTOM w0.102: v2(164.65,110.6) 164.65,111.31 169.78,116.44 208.48,116.44 210.9,116.44 211.89,117.43 242.38,117.43 243.22,118.26 250.84,118.26 251.65,118.26 252.39,119 258.59,119 259.8,117.79 263.9,117.79 265.92,115.77 265.92,114.98 266.66,114.23 276.41,114.23 277.12,113.52 286.17,113.52 291.12,118.48 296.3,118.48 v2(297.59,117.18) ; 171.35,90.61 170.99,90.97 167.19,90.97 166.72,91.44 166.37,91.44 165.81,92 v2(165.12,92) 164.43,92 163.98,92.45 R4734.2
LED_3S_LANACT#: length 86
  TOP w0.102: D486.1 311.09,102.11 v2(311.06,102.07) ; CN3601.12 322.43,112.2 321.98,111.75 319.56,111.75 317.91,113.4 317.91,117.43 317,118.35 316.11,118.35 314.97,117.21 v1(314.1,117.21) 310.8,117.21 308.92,119.09 308.15,119.09 307.92,119.32 307.92,120.34 307.63,120.64 306.48,120.64 305.72,119.87 304.14,119.87 v2(303.41,119.14) ; v2(294.67,116.7) 294.67,116.11 R403.1
  L3 w0.102: CN3601.12 321.8,112.2 321.44,111.85 319.28,111.85 314.33,106.89 v2(314.33,105.42) 313.62,105.42 311.98,103.78 311.98,102.8 311.24,102.07 v2(311.06,102.07)
  L5 w0.102: JACK485.B1 315.63,85.57 315.63,95.06 v2(316.14,95.57)
  L6 w0.102: v2(303.41,119.14) 302.49,118.22 296.2,118.22 v2(294.67,116.7)
  BOTTOM w0.102: v2(316.14,95.57) 315.45,95.57 313.14,97.87 313.14,103.37 314.33,104.56 v2(314.33,105.42)
LED_3S_LANLINK#: length 10.4
  TOP w0.102: U400.26 294.57,113.67 294.8,113.9 295.64,113.9 R402.2 295.77,114.59 Q487.2 297.14,115.96 297.14,117.66 296.83,117.97 294.5,117.97 R489.2 293.82,117.5 v1(293.25,118.07)
LED_3S_LANLINK#_R: length 94.1
  TOP w0.102: v2(310.5,85.79) 310.66,85.95 D485.1 314.32,85.95 v1(314.33,85.96) 314.36,85.96 v2(315.75,84.57) ; v2(297.59,115.91) 297.14,115.45 297.14,114.67 296.62,114.16 R402.1
  L3 w0.102: v2(300.77,80.15) 301.2,80.58 301.2,88.43 303.23,90.46 303.23,107.35 303.97,108.09 303.97,110.63 306.89,113.55 311.23,113.55 311.89,114.21 311.89,115.76 310.95,116.7 302.85,116.7 301.73,117.82 299.6,117.82 297.69,115.91 v2(297.59,115.91)
  L6 w0.102: v2(300.77,80.15) 300.77,80.2 304.45,83.88 309.66,83.88 310.5,84.72 v2(310.5,85.79)
  BOTTOM w0.102: JACK485.A1 317.51,93.71 315.63,93.71 315.12,93.2 315.12,85.2 v2(315.75,84.57)
LED_3S_SATA#: length 101.7
  TOP w0.102: 167.29,80.64 166.63,81.3 166.63,82.8 167.04,83.2 v2(167,83.2) ; 167.29,80.64 v1(167.29,80.63) ; 167.29,80.64 167.35,80.58 167.35,76.44 166.78,75.87 166.78,73.72 v2(167.67,72.83) ; CN200.18 108.05,89.31 106.86,88.12 105.7,88.12 103.79,86.22 103.79,85.52 104.05,85.26 v2(104.05,84.57)
  L3 w0.102: v2(167.67,72.83) 167.22,72.38 166.93,72.38 165.54,73.77 158.78,73.77 158.15,73.14 154.85,73.14 152.69,75.3 142.78,75.3 142.4,75.68 140.37,75.68 138.45,77.6 137.97,77.6 137.15,78.42 136.35,78.42 132.68,82.1 114.15,82.1 111.97,84.28 104.33,84.28 v2(104.05,84.57)
  BOTTOM w0.076: 170.33,83.32 170.58,83.32 170.66,83.4 171.58,83.4 171.83,83.65 174.58,83.65 U4555.U3
  BOTTOM w0.102: R4816.2 164.06,81.47 165.6,81.47 167,82.87 v2(167,83.2) 167.12,83.32 170.33,83.32
LED_3S_SM_SATA#: length 28
  TOP w0.102: CN9000.18 80,106.82 v2(80.53,106.28) ; Q9032.1 v3(73.02,125.75)
  L6 w0.102: v3(73.02,125.75) 73.69,125.08 74.71,125.08 75.22,125.59 75.98,125.59 79.15,122.41 79.15,108.19 80.53,106.81 v2(80.53,106.28)
LED_PWRSTBY#: length 348.4
  TOP w0.102: v2(262.16,87.36) 261.91,87.36 261.76,87.5 U302.6 261.76,88.8 262.05,89.09 262.05,90.02 262.49,90.45 R303.1 262.49,90.51 261.66,90.51 R361.2 ; v2(317.35,123.68) 317.35,123.68 317.35,123.67 317.7,123.32 v1(317.7,122.46) 322.46,117.7 CN3601.23 ; CN200.21 109.55,90.49 109.13,90.92 109.13,91.33 108.8,91.65 v2(108.01,91.65) ; CN290.2 105.85,129.14 v2(106.61,128.38) 107.22,128.38 TP291.1
  L5 w0.102: v2(106.61,128.38) 106.61,125.64 108.03,124.22 108.03,94.02 107.3,93.28 107.3,92.24 107.88,91.65 v2(108.01,91.65) 109.18,91.65 112.82,88.01 112.82,87.15 116.67,83.3 130.09,83.3 135.41,77.98 135.41,71.9 136.54,70.77 143.55,70.77 145.13,69.2 147.9,69.2 148.57,68.53 160.67,68.53 161.56,67.64 163.42,67.64 164.83,69.05 167.56,69.05 168.14,69.63 172.05,69.63 172.06,69.63 173.51,69.63 174.24,68.9 176.29,68.9 176.66,68.52 177.74,68.52 180.12,70.9 180.96,70.9 181.27,70.59 181.27,69.7 183.25,67.72 184.68,67.72 184.94,67.98 191.09,67.98 191.83,68.72 197.87,68.72 198.61,67.98 202.88,67.98 203.41,67.45 212.78,67.45 213.83,68.5 222.95,68.5 225.85,71.41 232.72,71.41 234.22,72.91 239.4,72.91 240.77,71.54 240.77,65.96 241.77,64.96 244.71,64.96 245.48,65.73 246.09,65.73 247.87,67.51 247.87,67.91 248.27,68.31 249.38,68.31 250.28,69.21 252.47,69.21 254.55,71.28 258.62,71.28 260.79,73.45 260.79,74.42 261.87,75.51 261.87,78.06 261.87,78.82 262.95,79.9 262.95,86.57 v2(262.16,87.36)
  L6 w0.102: v2(317.35,123.68) 317.21,123.81 315.5,123.81 312.78,121.09 312.41,121.09 311.94,120.63 311.94,120.25 310.75,119.06 304.49,119.06 302.87,117.44 299.73,117.44 297.52,115.22 292.93,115.22 291.66,113.95 291.66,113.32 288.14,109.8 288.14,107.07 287.53,106.46 287.53,100.8 285.94,99.2 285.94,91.82 288.22,89.54 288.22,86.94 286.38,85.1 281.41,85.1 279.91,86.6 279.53,86.6 278.21,85.28 265.66,85.28 263.57,87.36 v2(262.16,87.36)
LED_PWRSTBY#_PB: length 21.7
  TOP w0.102: CN9100.5 277.72,34.85 v4(277.21,34.85)
  L6 w0.102: v4(277.21,34.85) 276.76,34.4 270.42,34.4 268.31,32.3 266.61,32.3 263.43,29.12 v4(262.8,29.12)
  BOTTOM w0.102: D9100.1 264.35,26.88 v1(262.8,28.44) v4(262.8,29.12)
LED_SM_PWRSTBY#: length 107
  TOP w0.102: CN9000.21 81.5,108.89 v3(81.31,109.08) ; D9031.1 v2(30.21,156.12)
  L6 w0.102: v2(30.21,156.12) 30.21,151.93 32.42,149.72 32.42,117.33 37.37,112.38 61.25,112.38 64.04,109.59 68.49,109.59 69.88,108.19 69.88,104.89 70.77,104 81.31,104 82.33,105.01 82.33,108.06 v3(81.31,109.08)
LED_WWAN_LINK#: length 159.5
  L5 w0.102: v2(256.27,72.88) 254.49,72.88 251.7,70.09 248.75,70.09 247.2,68.54 247.2,67.97 247.2,67.76 245.78,66.34 245.1,66.34 244.33,65.57 242.03,65.57 241.38,66.21 241.38,71.79 239.66,73.52 233.96,73.52 232.47,72.02 225.6,72.02 224.8,71.22 222.7,69.12 213.59,69.12 212.53,68.06 203.74,68.06 202.83,68.97 198.76,68.97 197.9,69.84 191.54,69.84 191.29,69.59 183.74,69.59 181.85,71.47 179.55,71.47 177.87,69.8 176.32,69.8 176.15,69.63 174.39,69.63 173.78,70.24 167.74,70.24 167.3,69.8 164.64,69.8 164.17,69.33 148.87,69.33 148.17,70.03 146.07,70.03 144.24,71.85 144.24,73.15 144.08,73.31 142.2,73.31 140.21,71.33 137.63,71.33 137.37,71.59 136.52,71.59 135.64,72.46 135.64,78.04 v3(128.11,85.56)
  BOTTOM w0.102: Q112.2 127.36,85.1 R113.1 127.71,85.16 v3(128.11,85.56) ; v2(256.27,72.88) 256.15,73 CN1400.10
LID_SW#_3: length 232.1
  TOP w0.102: v2(275.11,109.08) 275.21,108.98 U300.64 278.16,108.98 278.31,109.13 278.31,109.74 281.08,112.51 R314.1 ; D3000.3 106.59,119.11 106.59,120 108.11,121.52 TP293.1 107.86,126.35 105.75,128.46 104.35,128.46 103.85,128.96 CN290.4 v2(103.85,132.03) 104.3,132.48 104.3,139.43 109.01,144.15 Q115.1
  L5 w0.102: v2(264.03,130.27) 265.49,128.81 265.49,117.88 267.82,115.54 267.82,115.25 267.82,113.32 269.02,112.13 269.78,112.13 270.54,111.37 271.45,111.37 273.74,109.08 v2(275.11,109.08)
  BOTTOM w0.102: v2(264.03,130.27) 261.71,130.27 260.97,129.53 246.03,129.53 245.14,130.41 238.92,130.41 236.76,128.26 206.53,128.26 202.98,131.81 195.12,131.81 194.6,131.29 194.6,131.29 193.48,130.17 192.23,130.17 190.57,131.83 163.06,131.83 162.77,131.54 104.29,131.54 103.85,131.98 v2(103.85,132.03)
LID_SW#_3_PB: length 7.5
  TOP w0.102: CN9100.3 281.87,32.85 282.54,33.51 v4(284.51,33.51)
  BOTTOM w0.102: v4(284.51,33.51) 283.06,33.51 U9100.2
LIMIT_SIGNAL: length 366.3
  TOP w0.102: v2(308.52,139.81) 308.82,139.51 311.02,139.51 D6015.2 ; v2(60.1,90.54) 55.91,90.54 v1(55.79,90.41) R6918.1
  L6 w0.102: v2(60.1,90.54) 60.41,90.23 72.88,90.23 73.58,89.53 78.91,89.53 80.55,91.17 82.33,91.17 83.09,91.93 86.23,91.93 87.72,93.42 88.08,93.79 89.09,93.79 92,96.7 92.3,96.7 95.08,96.7 100.98,102.61 100.98,108.28 103.12,110.41 103.12,114.39 103.69,114.96 103.69,123.36 105.17,124.83 105.17,151.79 116.04,162.67 168.97,162.67 175.3,156.35 184.14,156.35 189.75,161.96 243.24,161.96 246.08,159.11 246.08,150.22 247.1,149.2 253.96,149.2 255.84,147.32 263.16,147.32 266.09,144.39 274.71,144.39 282.72,136.38 283.94,136.38 285.26,135.06 296.65,135.06 300.28,138.69 307.39,138.69 v2(308.52,139.81)
  BOTTOM w0.102: CN3601.46 322.63,129.77 320.96,129.77 318.67,132.07 315.96,132.07 308.52,139.51 v2(308.52,139.81) 313.5,144.8 JACK6000.2
LIMIT_SIGNAL_100R: length 295.8
  TOP w0.102: R6918.2 v1(55.79,87.87) 55.91,87.87 56.55,88.5 v2(56.55,88.76) 57.12,89.33 Q6902.2 ; R6998.1 290.02,98.88 R6910.1 289.17,97.98 v2(287.31,96.12)
  L5 w0.102: v2(287.31,96.12) 286.04,96.12 283.75,98.41 283,98.41 281.47,99.94 273.08,99.94 270.02,102.99 269.95,102.99 263.37,109.58 263.37,109.58 261.65,111.29 261.65,111.92 260.55,113.03 260.55,118.6 261.91,119.96 261.91,125.99 v2(261.02,126.88)
  L6 w0.102: v2(56.55,88.76) 57.04,89.25 72.34,89.25 73.04,88.54 79.44,88.54 81.13,90.23 82.75,90.23 83.5,90.98 86.62,90.98 88.51,92.87 89.47,92.87 92.38,95.79 92.72,95.79 95.46,95.79 95.99,96.32 102.82,103.15 102.82,107.17 104.77,109.12 104.77,122.86 107.71,125.8 107.71,129.31 v2(108.17,129.77)
  BOTTOM w0.102: v2(261.02,126.88) 259.52,128.38 245.52,128.38 244.63,129.27 239.68,129.27 237.65,127.24 206.03,127.24 202.47,130.8 195.4,130.8 193.86,129.26 191.85,129.26 191.53,129.59 190.2,130.92 163.43,130.92 163.14,130.63 111.09,130.63 110.23,129.77 v2(108.17,129.77)
LINE_IN_DET: length 2.2
  TOP w0.254: R528.2 298.41,55.39 v1(298.41,54.62) 298.13,54.62 297.41,53.9 Q528.6
LINE_IN_SENSE: length 85.7
  TOP w0.254: R529.2 295.48,54.51 v2(296.07,55.1) 296.2,55.1 296.7,55.61 Q528.2
  L5 w0.102: v2(296.07,55.1) 297.47,55.1 297.8,54.77 301.57,54.77 302.25,55.46 306.1,55.46 306.51,55.87 307.75,55.87 308.92,57.03 310.19,57.03 311.93,58.78 311.93,60.68 315.42,64.17 315.42,75.73 314.18,76.97 314.18,77.48 v2(314.74,78.04)
  L6 w0.102: CN3601.14 323.06,113.2 322.49,112.62 322.49,108.7 320.02,106.23 317.75,106.23 313.57,102.06 313.57,84.24 311.56,82.23 311.56,78.57 312.1,78.04 v2(314.74,78.04)
LINE_OUT_DET: length 8
  TOP w0.102: Q528.3 296.05,55.72 295.69,55.36 295.18,55.36 294.55,54.72 294.55,53.45 295.05,52.94 v1(295.05,52.56) 295.31,52.31 297.76,52.31 R531.2
LINE_OUT_SENSE: length 87.1
  TOP w0.254: v2(296.96,54.52) 296.7,54.26 Q528.5 296.7,53.71 297.38,53.03 R530.1
  L5 w0.102: v3(314.74,77.35) 315.78,76.31 315.78,63.89 312.29,60.4 312.29,58.62 310.34,56.68 309.07,56.68 307.9,55.51 306.66,55.51 306.25,55.1 302.4,55.1 301.71,54.42 297.06,54.42 v2(296.96,54.52)
  L6 w0.102: v3(314.74,77.35) 312.12,77.35 311.06,78.42 311.06,82.54 313.11,84.59 313.11,102.19 317.51,106.59 319.87,106.59 322.13,108.84 322.13,113.29 322.53,113.7 CN3601.15
LPC_3S_AD<0>: length 316.9
  TOP w0.076: v2(181.78,94.89) 181.32,94.43 180.14,94.43 179.76,94.8 179.76,95.46 179.1,96.12 177.84,96.12 177.2,96.77 177.2,97.77 176.01,98.96 176.01,103.45 177.77,105.21 v4(177.77,105.7)
  TOP w0.102: U300.46 276.34,101.73 v2(276.2,101.59) ; v2(136.68,108.32) 137.07,108.32 141.03,112.28 175.04,112.28 177.77,109.55 177.77,109.14 v4(177.77,105.7)
  L5 w0.102: v2(137.83,72.76) 137.57,73.01 137.57,78.86 131.73,84.7 131.73,86.22 130.23,87.72 126.8,87.72 124.03,90.49 119.64,90.49 116.29,93.84 116.21,93.84 115.17,94.88 115.17,106.67 113.95,107.89 v2(113.95,107.94) 115.13,109.11 115.13,112.15 115.13,112.15 115.13,112.31 115.13,112.48 112.76,114.85 112.76,127.17 108.5,131.43 108.5,132.31 108.5,137.39 v2(107.22,138.67)
  L6 w0.102: v2(113.95,107.94) 114.04,107.85 114.86,107.85 116.18,109.17 126.94,109.17 128.8,107.31 135.68,107.31 v2(136.68,108.32)
  BOTTOM w0.076: v2(181.78,94.89) 181.69,94.89 181.37,94.57 U4555.AU14
  BOTTOM w0.102: v2(276.2,101.59) 275.27,101.59 273.75,103.11 266.1,103.11 265.21,102.22 263.05,102.22 262.29,102.98 262.29,104 261.14,105.14 260.33,105.14 259.86,105.61 243.85,105.61 243.69,105.46 237.51,105.46 236.93,106.04 181.83,106.04 180.68,104.89 178.59,104.89 v4(177.77,105.7) ; U3500.26 126.4,152.52 126.95,153.06 126.95,155.69 125.65,156.98 120.68,156.98 120.01,156.31 120.01,154.58 119.32,153.88 117.47,153.88 112.78,149.19 v1(112.78,147.69) 112.78,146.78 107.84,141.83 107.84,139.29 v2(107.22,138.67) ; v2(137.83,72.76) 137.57,73.01 137.57,74.04 137.32,74.3 CN375.8
LPC_3S_AD<1>: length 313.6
  TOP w0.076: v2(181.03,96.19) 180.65,95.81 180.04,95.81 179.4,96.45 177.98,96.45 177.53,96.9 177.53,97.91 176.34,99.09 176.34,102.89 178.59,105.14 v4(178.59,105.72)
  TOP w0.102: v2(274.49,103.11) 275.38,102.22 276.26,102.22 276.57,102.53 U300.48 ; v2(136.58,109.21) 137.07,109.21 140.55,112.69 175.21,112.69 178.89,109.01 178.89,106.02 v4(178.59,105.72)
  L5 w0.102: v2(139.08,72.37) 138.96,72.25 137.67,72.25 137.34,72.57 137.34,78.8 131.35,84.79 131.35,86.09 129.95,87.49 128.87,87.49 128.87,87.49 126.67,87.49 124.03,90.13 119.6,90.13 119.3,90.43 117.38,90.43 116.47,91.35 116.47,93.2 114.33,95.34 114.33,105.27 113.54,106.06 113.54,108.19 v2(113.94,108.59) 114.93,109.57 114.93,112.23 114.93,112.4 112.55,114.77 112.55,127.08 108.3,131.34 108.3,132.39 108.3,136.83 v2(107.22,137.91)
  L6 w0.102: v2(113.94,108.59) 114.95,108.59 115.81,109.44 127.05,109.44 128.89,107.6 134.98,107.6 v2(136.58,109.21)
  BOTTOM w0.076: v2(181.03,96.19) 180.98,96.19 180.66,95.87 U4555.AW12
  BOTTOM w0.102: v2(139.08,72.37) 140.01,73.3 CN375.9 ; U3500.23 124.45,152.86 125.13,153.54 125.13,155.68 124.16,156.65 120.94,156.65 120.43,156.14 120.43,154.42 119.56,153.55 117.69,153.55 114,149.87 v1(114,148.45) 114,147.48 108.24,141.72 108.24,138.92 v2(107.22,137.91) ; v2(274.49,103.11) 274.23,103.36 265.97,103.36 265.34,102.73 264.07,102.73 261.4,105.4 260.38,105.4 259.96,105.82 243.77,105.82 243.61,105.66 238.39,105.66 237.59,105.66 237.01,106.24 181.53,106.24 180.44,105.14 179.18,105.14 v4(178.59,105.72)
LPC_3S_AD<2>: length 299
  TOP w0.076: v4(180.02,105.8) 176.67,102.45 176.67,99.23 177.86,98.05 177.86,97.04 178.11,96.79 179.78,96.79 v2(180.28,97.29)
  TOP w0.102: v4(180.02,105.8) 180.02,108.46 175.38,113.09 139.9,113.09 137.1,110.3 v2(136.43,110.3) ; v2(275.22,103.05) 275.67,102.6 276,102.6 276.73,103.33 U300.50
  L5 w0.102: v2(136.81,73.26) 136.51,73.56 136.51,79.01 130.72,84.81 130.72,85.96 129.7,86.98 126.55,86.98 124.08,89.45 119.2,89.45 118.79,89.85 117.06,89.85 115.81,91.1 115.81,92.7 112.17,96.34 112.17,108.25 v2(113.99,110.06) 114.01,110.06 114.44,110.49 114.44,112.31 112.15,114.6 112.15,126.92 107.89,131.17 107.89,132.56 107.89,135.71 v2(107.22,136.38)
  L6 w0.102: v2(113.99,110.06) 127.17,110.06 129.08,108.15 134.11,108.15 136.25,110.3 v2(136.43,110.3)
  BOTTOM w0.076: U4555.AY12 180.66,96.52 180.66,96.92 v2(180.28,97.29)
  BOTTOM w0.102: v2(275.22,103.05) 275.22,103.05 274.94,103.33 274.65,103.62 265.84,103.62 265.21,102.98 264.19,102.98 261.53,105.65 260.42,105.65 260.05,106.02 243.68,106.02 243.53,105.86 237.67,105.86 237.1,106.44 180.66,106.44 v4(180.02,105.8) ; v2(107.22,136.38) 109,138.16 109,141.72 116.31,149.03 v1(116.31,150.35) 116.31,151.1 118.11,152.89 122.19,152.89 122.5,152.58 U3500.20 ; v2(136.81,73.26) 136.78,73.3 CN375.10
LPC_3S_AD<3>: length 303.2
  TOP w0.076: v4(179.36,106.41) 179.36,105.52 176.51,102.67 176.51,99.16 177.69,97.98 177.69,96.97 178.05,96.62 179.86,96.62 v2(180.28,96.19)
  TOP w0.102: v2(278.85,103.92) 278.86,103.92 278.66,103.73 U300.51 ; v2(135.67,110.35) 136.18,109.84 137.19,109.84 140.24,112.89 175.29,112.89 179.36,108.83 v4(179.36,106.41)
  L5 w0.102: v2(139.1,71.74) 138.84,71.99 137.45,71.99 136.25,73.19 136.25,78.92 130.46,84.71 130.46,85.84 129.6,86.7 126.42,86.7 123.96,89.17 119.14,89.17 118.69,89.62 117,89.62 115.6,91.02 115.6,92.62 111.92,96.3 111.92,109.34 v2(114.01,111.43) 111.94,113.5 111.94,126.83 107.63,131.15 107.63,135.21 v2(107.22,135.62)
  L6 w0.102: v2(135.67,110.35) 133.77,108.45 129.17,108.45 127.21,110.41 115.03,110.41 v2(114.01,111.43)
  BOTTOM w0.076: v2(180.28,96.19) 180.23,96.19 179.91,95.87 U4555.AW11
  BOTTOM w0.102: U3500.17 120.55,152.44 120.35,152.64 118.27,152.64 117.38,151.75 v1(117.38,151.24) 117.38,149.72 109.38,141.72 109.38,137.78 v2(107.22,135.62) ; v2(139.1,71.74) 139.66,72.3 CN375.11 ; v4(179.36,106.41) 179.79,106.85 237.27,106.85 237.84,106.27 243.36,106.27 243.54,106.45 258.96,106.45 259.2,106.69 261.15,106.69 264.35,103.49 264.95,103.49 265.59,104.13 274.64,104.13 275.04,104.52 278.25,104.52 v2(278.85,103.92)
LPC_3S_FRAME#: length 308.6
  TOP w0.076: v4(178.47,106.41) 178.19,106.13 178.19,105.24 176.18,103.23 176.18,99.03 177.36,97.84 177.36,96.84 177.91,96.29 179.24,96.29 180.29,95.25 v2(180.29,94.91)
  TOP w0.102: v2(275.83,103.02) 275.83,103.12 276.83,104.13 U300.52 ; v4(178.47,106.41) 178.47,109.14 175.13,112.48 140.73,112.48 137.04,108.8 136.41,108.8 136,109.21 v2(136,109.38)
  L5 w0.102: v2(136.94,75.16) 136.94,78.92 130.97,84.89 130.97,86.09 129.78,87.28 126.53,87.28 124.16,89.65 124.15,89.65 123.97,89.84 119.24,89.84 118.93,90.16 117.25,90.16 116.26,91.15 116.26,93.12 113.7,95.68 113.7,100.19 112.43,101.46 112.43,107.66 v2(114.01,109.25) 114.72,109.96 114.72,112.31 112.35,114.69 112.35,127 108.09,131.26 108.09,132.48 108.09,136.27 v2(107.22,137.15)
  L6 w0.102: v2(136,109.38) 136,109.28 134.57,107.85 129.03,107.85 127.17,109.71 115.33,109.71 114.87,109.25 v2(114.01,109.25)
  BOTTOM w0.076: v2(180.29,94.91) 180.39,94.91 U4555.AV12
  BOTTOM w0.102: U3500.22 123.8,152.6 124.93,153.72 124.93,155.38 123.98,156.32 121.06,156.32 120.81,156.07 120.81,154.29 119.74,153.22 117.9,153.22 115.09,150.42 v1(115.09,149.46) 115.09,148.19 108.62,141.72 108.62,138.54 v2(107.22,137.15) ; v4(178.47,106.41) 178.59,106.41 179.01,105.99 179.57,105.99 180.22,106.64 237.18,106.64 237.76,106.07 243.44,106.07 243.62,106.25 259.13,106.25 259.37,106.49 261.07,106.49 264.34,103.21 265.06,103.21 265.72,103.87 274.98,103.87 v2(275.83,103.02) ; CN375.4 136.31,76.3 136.94,75.68 v2(136.94,75.16)
