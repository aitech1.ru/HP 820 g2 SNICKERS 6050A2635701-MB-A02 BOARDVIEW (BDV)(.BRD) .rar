# Allegro board SNICKERS 6050A2635701-MB-A02 BOARDVIEW (BDV)(.BRD) .brd (continued)
## Nets (continued)
P5V0S_SM: C9002.1(A) C9003.1(A) C9006.1(A) CN9000.27 CN9000.28 R9048.2(B) U9000.4(SMIO_5VPWR) U9000.13(5VINPUT)
P15V0A: C6159.1(A) D6151.1(A1) R7101.1(A) R7151.1(A) R7354.2(B)
PVBAT: C6699.1(A) C7455.2(B) C7456.2(B) C7467.2(B) C7468.2(B) C7472.2(B) C7473.2(B) C7490.2(B) C7491.2(B) C7495.2(B) C7594.1(A) C7595.1(A) C7599.1(A) C7601.1(A) C7602.1(A) C7603.1(A) C7641.1(A) C7642.1(A) CN3000.1 CN3000.2 CN3000.3 D7606.2 D7607.2 D7608.2 PAD6010.1 PAD6110.1 PAD6160.1 PAD6210.1 PAD6310.1 PAD6610.1 R372.1(A) R6000.2 R6027.1(A) R6657.1(A) R7114.2(B)
PVBAT_CHG: C6010.1(A) C6011.1(A) C7457.2(B) C7458.2(B) C7650.1(A) PAD6010.2 Q6000.5(D3) Q6000.6(D2) Q6000.7(D1) Q6000.8(D0)
PVBAT_CPU: C6610.1(A) C6611.1(A) C7643.1(A) PAD6610.2 U6610.5
PVCCIO_OUT: C6641.1(A) R6640.1(A) R6641.1(A) R7012.2(B)
PVCCIO_OUT_R: R4568.1(A) U4555.A59(VCCIO_OUT)
VCC1_POR#_3: CN375.16 R325.1(A) R342.1(A) U300.77(VCC1_NRST/GPIO131)
VCCIOA_OUT: R4544.1(A) U4555.E20(VCCIOA_OUT)
VCCSENSE: R4521.2(B) U4555.E63(VCC_SENSE) U6600.24
VCCST_PWRGD: Q4926.6(D1) R4923.2(B) R4926.1(A) U4555.B59(VCCST_PWRGD)
VCCST_PWRGD_XDP: CN4920.39(PWRGOOD_HOOK0) R4926.2(B)
VSSSENSE: R4522.1(A) U4555.E62(VSS_SENSE) U6600.23
8051_RX_CAPS_LED#: CN375.14 R324.1(A) R360.1(A) U300.114(LED1/GPIO155) U302.3(A2)
8051_TX_LED_PWRSTBY#: CN375.13 R322.1(A) R361.1(A) U300.115(LED2/GPIO156) U302.1(A1)
A_3S_ICHSPKR: R513.1(A) R4880.2(B) U4555.V2(SPKR/GPIO81)
A_LINEINL: C514.1(A) U501.19(MIC1-L)
A_LINEINL_DOCK: CN3601.17 R505.2(B)
A_LINEINR: C526.1(A) U501.20(MIC1-R)
A_LINEINR_DOCK: CN3601.18 R504.2(B)
A_MIC: C612.1(A) R532.2(B) R612.1(A) U610.1(1OUT)
A_SD#: D500.1 D501.1 R509.1(A) R533.1(A) R1006.1(A) U300.91(GPIO020/I2C2_CLK0)
ACCEL_INT: Q1003.3(D) R4781.2(B) R4866.1(A)
ACCEL_INT_D: Q1003.2(S) U1000.11(INT1)
ADP_A_ID: R300.1(A) R6904.1(A) R6909.2(B)
ADP_DET: R6022.2(B) R6024.1(A) U300.31(GPIO127/PECI_RDY) U6000.5(ACPRES)
ADP_EN: Q6009.4(S2) R317.1(A) U300.63(GPIO035)
ADP_ID_CHK: Q6998.1(G) R6999.1(A) U300.78(GPIO141/PWM3/LED3)
ADP_PRES: R6933.2(B) R6935.1(A) U300.74(GPIO130) U6903.4
ADP_PRES_OUT: R4743.2(B) U300.99(GPIO160/BC_DAT) U4555.AJ8(ACPRESENT/GPIO31)
AMP_PD: Q501.1(G) R501.2(B) U501.7
APWROK: R4722.2(B) R4723.2(B) U4555.AB5(APWROK)
AZ_R3S_BITCLK: C523.1(A) R4910.1(A) U501.6(BIT-CLK)
AZ_R3S_RST#: R511.1(A) R4901.1(A) U501.11(RESET#)
AZ_R3S_SDIN0: R514.2(B) U4555.AY10(HDA_SDI0/I2S0_RXD)
AZ_R3S_SDOUT: C7478.2(B) R4869.1(A) U501.5(SDATA-OUT)
AZ_R3S_SYNC: R4903.1(A) U501.10(SYNC)
BAT_AMBERLED#: CN200.19 R318.1(A) U300.113(LED0/GPIO154)
BAT_GRNLED#: CN200.20 R4863.1(A) U300.120(GPIO133/PWM0)
BAT_SM_AMBERLED#: CN9000.19 D9032.3(-)
BAT_SM_GRNLED#: CN9000.20 D9032.2
BATLOW#: Q302.3(D) R4744.2(B) U300.124(GPIO066) U4555.AN4(BATLOW/GPIO72*)
BKLT_EN: CN3000.19 D3000.1(A2) R3009.2(B)
BRD_ID1: R4571.2(B) R4572.2(B) U4555.P1(BMBUSY/GPIO76*)
BRD_ID2: R4573.2(B) R4574.2(B) U4555.U6(PIRQA/GPIO77*)
BRD_ID3: R4575.2(B) R4576.2(B) U4555.P4(PIRQB/GPIO78*)
BRD_ID4: R4577.2(B) R4578.2(B) U4555.N4(PIRQC/GPIO79*)
BT_OFF: Q1302.2(G1) U4555.AG4(SUS_STAT/GPIO61*)
BT_OFF#: CN1300.54 Q1302.3(D2) Q1302.6(D1) R1306.2(B)
BUF_PLT_RST#: CN375.6 CN1300.52 CN1951.50(PERST#/NC) D801.1 Q4754.1(G) R1410.1(A) R3507.1(A) R4713.1(A) R4921.2(B) U3500.16 U4700.4(Y1)
C_DN: CN3601.52 JACK485.5 U470.17
C_DP: CN3601.51 JACK485.4 U470.18
CAMERA_ON: CN3000.11 R4770.2(B) U4555.L4(GPIO53)
CAPS_LED#: R341.1(A) R360.2(B) R393.1(A) U302.4(Y2)
CATERR_N: TP4502.1 U4555.K61(CATERR*)
CFG<0>: CN4920.9(OBSDATD_A0) U4555.AC60(CFG0)
CFG<1>: CN4920.11(OBSDATD_A1) U4555.AC62(CFG1)
CFG<2>: CN4920.15(OBSDATD_A2) U4555.AC63(CFG2)
CFG<3>: CN4920.17(OBSDATD_A4) R4939.2(B) U4555.AA63(CFG3)
CFG<4>: CN4920.27(OBSDATA_B0) R4523.1(A) U4555.AA60(CFG4)
CFG<5>: CN4920.29(OBSDATA_B1) U4555.Y62(CFG5)
CFG<6>: CN4920.33(OBSDATA_B2) U4555.Y61(CFG6)
CFG<7>: CN4920.35(OBSDATA_B3) U4555.Y60(CFG7)
CFG<8>: CN4920.10(OBSDATA_C0) U4555.V62(CFG8)
CFG<9>: CN4920.12(OBSDATA_C1) R4534.1(A) U4555.V61(CFG9)
CFG<10>: CN4920.16(OBSDATA_C2) U4555.V60(CFG10)
CFG<11>: CN4920.18(OBSDATA_C3) U4555.U60(CFG11)
CFG<12>: CN4920.28(OBSDATA_D0) U4555.T63(CFG12)
CFG<13>: CN4920.30(OBSDATA_D1) U4555.T62(CFG13)
CFG<14>: CN4920.34(OBSDATA_D2) U4555.T61(CFG14)
CFG<15>: CN4920.36(OBSDATA_D3) U4555.T60(CFG15)
CFG<16>: CN4920.6(OBSFN_C1) U4555.AA62(CFG16)
CFG<17>: CN4920.4(OBSFN_C0) U4555.AA61(CFG17)
CFG<18>: CN4920.24(OBSFN_D1) U4555.U63(CFG18)
CFG<19>: CN4920.22(OBSFN_D0) U4555.U62(CFG19)
CHR_ILIM: C6032.1(A) Q6901.3(C) R6914.1(A) U6000.10(ILIM)
CHRG_ADP_DET: R373.1(A) U300.1(GPIO036)
CL_CLK1: CN1300.42 U4555.AF2(CL_CLK)
CL_DATA1: CN1300.40 U4555.AD2(CL_DATA)
CL_RST#1: CN1300.38 U4555.AF4(CL_RST*)
CLK_KBC_SIO: R4774.2(B) U4555.AN15(CLKOUT_LPC_0)
CLK_PCIE2_DN: U800.6(REFCLKN) U4555.B41(CLKOUT_PCIE_N1)
CLK_PCIE2_DP: U800.5(REFCLKP) U4555.A41(CLKOUT_PCIE_P1)
CLK_PCIE3_DN: U400.45 U4555.C41(CLKOUT_PCIE_N2)
CLK_PCIE3_DP: U400.44 U4555.B42(CLKOUT_PCIE_P2)
CLK_PCIE4_DN: CN1300.49 U4555.B38(CLKOUT_PCIE_N3)
CLK_PCIE4_DP: CN1300.47 U4555.C37(CLKOUT_PCIE_P3)
CLK_PCIE6_DN: CN1951.53(REFCLKN) U4555.B37(CLKOUT_PCIE_N5)
CLK_PCIE6_DP: CN1951.55(REFCLKP) U4555.A37(CLKOUT_PCIE_P5)
CLK_PCIE_XDP_DN: R4938.2(B) U4555.B35(CLKOUT_ITPXDP*)
CLK_PCIE_XDP_DN_R: CN4920.42(ITPCLK#_HOOK5) R4938.1(A)
CLK_PCIE_XDP_DP: R4937.2(B) U4555.A35(CLKOUT_ITPXDP_P)
CLK_PCIE_XDP_DP_R: CN4920.40(ITPCLK_HOOK4) R4937.1(A)
CLK_R3S_DEBUG: CN375.2 R4996.1(A)
CLK_R3S_KBPCI: C7476.2(B) R4774.1(A) U300.54(PCI_CLK/GPIO117)
CLK_R3S_TPM: C3501.1(A) R4997.1(A) U3500.21
CLK_TPM_DEBUG: R4996.2(B) R4997.2(B) U4555.AP15(CLKOUT_LPC_1)
CLKREQ_PCIE2_N: Q802.3(D) R4711.2(B) U4555.Y5(PCIECLKRQ1/GPIO19*)
CLKREQ_PCIE3_N: R4798.2(B) U400.48 U4555.AD1(PCIECLKRQ2/GPIO20*)
CLKREQ_PCIE4_N: Q1301.3(D) R1310.1(A) R4705.2(B) U4555.N1(PCIECLKRQ3/GPIO21*)
CLKREQ_PCIE4_R_N: CN1300.53 Q1301.2(S) R1304.2(B) R1310.2(B)
CLKREQ_PCIE5_N: R4712.2(B) U4555.U5(PCIECLKRQ4/GPIO22*)
CLKREQ_PCIE6_N: CN1951.52(CLKREQ#/NC) R4715.2(B) U4555.T2(PCIECLKRQ5/GPIO23*)
COMBO_GPI: C605.1(A) R604.2(B) U501.47
COMBO_JACK_DET: JACK600.2 Q600.1(G) R603.2(B)
CPPWR_EN: R356.1(A) R2593.2(B) U300.107(GPIO030) U2511.8
CPU_PROCHOT#: C4514.1(A) Q4501.3(D) R4515.1(A) R4517.1(A) U6600.30
CPU_PROCHOT#_R: R4515.2(B) U4555.K63(PROCHOT*)
CPU_TEST1: R4775.1(A) U4555.C35(TESTLOW_C35)
CPU_TEST2: R4791.1(A) U4555.C34(TESTLOW_C34)
CPU_TEST3: R4800.1(A) U4555.AK8(TESTLOW_AK8)
CPU_TEST4: R4801.1(A) U4555.AL8(TESTLOW_AL8)
CR_GPIO: R802.1(A) U800.28(GPIO)
CR_PWREN#: Q800.1(G) R811.1(A) R4720.2(B) U4555.AP1(GPIO57)
CR_RST#: D801.2 R4707.2(B) U4555.U2(PCIECLKRQ0/GPIO18*)
CR_WAKE#: R4737.1(A) R4825.1(A) U800.32(WAKE#) U4555.AH2(OC2/GPIO42*)
CRT_B: C3053.1(A) L3053.1(INA) R3053.1(A) U3065.26
CRT_DDCCLK: CN3050.15 R3060.2(B) U3065.20
CRT_DDCDATA: CN3050.12 R3059.2(B) U3065.22
CRT_G: C3052.1(A) L3052.1(INA) R3052.1(A) U3065.28
CRT_HSYNC: R3066.2(B) U3065.25
CRT_HSYNC_R: C3059.1(A) CN3050.13 R3066.1(A)
CRT_R: C3051.1(A) L3051.1(INA) R3051.1(A) U3065.31
CRT_VSYNC: R3069.2(B) U3065.24
CRT_VSYNC_R: C3060.1(A) CN3050.14 R3069.1(A)
CURRENT_ADC: C6900.1(A) R316.1(A) R6913.2(B) R6990.2(B)
D_DN: CN3601.49 JACK485.8 U470.13(TX4-)
D_DP: CN3601.48 JACK485.7 U470.14(TX4+)
DC_TEST_A3_B3: U4555.A3(DAISY_CHAIN_NCTF_A3) U4555.B2(DAISY_CHAIN_NCTF_B2) U4555.B3(DAISY_CHAIN_NCTF_B3)
DC_TEST_A61_B61: U4555.A61(DAISY_CHAIN_NCTF_A61) U4555.B61(DAISY_CHAIN_NCTF_B61)
DC_TEST_AY2_AW2: U4555.AW1(DAISY_CHAIN_NCTF_AW1) U4555.AW2(DAISY_CHAIN_NCTF_AW2) U4555.AY2(DAISY_CHAIN_NCTF_AY2)
DC_TEST_AY3_AW3: U4555.AW3(DAISY_CHAIN_NCTF_AW3) U4555.AY3(DAISY_CHAIN_NCTF_AY3)
DC_TEST_AY61_AW61: U4555.AW61(DAISY_CHAIN_NCTF_AW61) U4555.AY61(DAISY_CHAIN_NCTF_AY61)
DC_TEST_AY62_AW62: U4555.AW62(DAISY_CHAIN_NCTF_AW62) U4555.AW63(DAISY_CHAIN_NCTF_AW63) U4555.AY62(DAISY_CHAIN_NCTF_AY62)
DC_TEST_B62_B63: U4555.A62(DAISY_CHAIN_NCTF_A62) U4555.B62(DAISY_CHAIN_NCTF_B62) U4555.B63(DAISY_CHAIN_NCTF_B63)
DC_TEST_C1_C2: U4555.C1(DAISY_CHAIN_NCTF_C1) U4555.C2(DAISY_CHAIN_NCTF_C2)
DDR3_DRAMRST#: CN4100.30(RESET#) CN4125.30(RESET#) R4550.2(B) R4553.2(B)
DDR3_DRAMRST#_CPU: R4550.1(A) U4555.AV15(SM_DRAMRST*)
DDR_PG_CTRL: R4121.1(A) U4555.AV61(SM_PG_CNTL1)
DDR_VTT_PG_CTRL: Q4100.1(G) Q4101.3(D) R4114.2(B) R4115.1(A) R7119.1(A)
DDR_WR_VREF01: C4121.1(A) R4105.2(B) U4555.AR51(SM_VREF_DQ0)
DDR_WR_VREF02: C4122.1(A) R4112.2(B) U4555.AP51(SM_VREF_DQ1)
DETECT1#: CN3601.1 CN3601.92
DEVSLP0: CN1951.38(DEVSLP) R4767.2(B) U4555.P2(DEVSLP0/GPIO33)
DEVSLP1: CN1700.P3 R4726.2(B) U4555.L2(DEVSLP1/GPIO38)
DGPU_HOLD_RST#: R4751.2(B) U4555.P3(GPIO50)
DGPU_PRSNT#: R4709.2(B) R4919.1(A) U4555.Y3(GPIO49)
DGPU_PWR_EN#: R4929.2(B) U4555.L3(GPIO54)
DGPU_PWROK: R4907.2(B) U4555.T3(GPIO17)
DMIC_CLK: C7654.1(A) CN3000.16 R516.2(B)
DMIC_CLK_DB: CN600.1 MIC600.3 MIC601.3
DMIC_DAT: CN3000.15 U501.4(GPIO1/DMIC-DATA12)
DMIC_DATA_DB: CN600.2 MIC600.4 MIC601.4
DOCK_ID1: CN3601.37 Q5301.1(G) Q5401.1(G) R4728.2(B) U4555.G2(UART1_TXD/GPIO1)
DP_DEMUX_SW: Q5301.3(D) R5318.2(B) U5301.18(SW)
DP_UTIL: TP4500.1 U4555.A43(EDP_DISP_UTIL)
DPB0_C_DN: C5302.2(B) U5301.7(IN_D0N)
DPB0_C_DP: C5301.2(B) U5301.6(IN_D0P)
DPB0_DN: C5302.1(A) U4555.C54(DDI1_TXN0)
DPB0_DOCK_DN: CN3601.76 U5301.39(OUT2_D0N)
DPB0_DOCK_DP: CN3601.75 U5301.40(OUT2_D0P)
DPB0_DP: C5301.1(A) U4555.C55(DDI1_TXP0)
DPB0_PORT_C_DN: C3301.2(B) CN3300.3
DPB0_PORT_C_DP: C3300.2(B) CN3300.1
DPB0_PORT_DN: C3301.1(A) U5301.49(OUT1_D0N)
DPB0_PORT_DP: C3300.1(A) U5301.50(OUT1_D0P)
DPB1_C_DN: C5304.2(B) U5301.10(IN_D1N)
DPB1_C_DP: C5303.2(B) U5301.9(IN_D1P)
DPB1_DN: C5304.1(A) U4555.B58(DDI1_TXN1)
DPB1_DOCK_DN: CN3601.79 U5301.36(OUT2_D1N)
DPB1_DOCK_DP: CN3601.78 U5301.37(OUT2_D1P)
DPB1_DP: C5303.1(A) U4555.C58(DDI1_TXP1)
DPB1_PORT_C_DN: C3306.2(B) CN3300.6
DPB1_PORT_C_DP: C3307.2(B) CN3300.4
DPB1_PORT_DN: C3306.1(A) U5301.46(OUT1_D1N)
DPB1_PORT_DP: C3307.1(A) U5301.47(OUT1_D1P)
DPB2_C_DN: C5306.2(B) U5301.13(IN_D2N)
DPB2_C_DP: C5305.2(B) U5301.12(IN_D2P)
DPB2_DN: C5306.1(A) U4555.B55(DDI1_TXN2)
DPB2_DOCK_DN: CN3601.82 U5301.34(OUT2_D2N)
DPB2_DOCK_DP: CN3601.81 U5301.35(OUT2_D2P)
DPB2_DP: C5305.1(A) U4555.A55(DDI1_TXP2)
DPB2_PORT_C_DN: C3303.2(B) CN3300.9
DPB2_PORT_C_DP: C3302.2(B) CN3300.7
DPB2_PORT_DN: C3303.1(A) U5301.44(OUT1_D2N)
DPB2_PORT_DP: C3302.1(A) U5301.45(OUT1_D2P)
DPB3_C_DN: C5308.2(B) U5301.16(IN_D3N)
DPB3_C_DP: C5307.2(B) U5301.15(IN_D3P)
DPB3_DN: C5308.1(A) U4555.A57(DDI1_TXN3)
DPB3_DOCK_DN: CN3601.85 U5301.31(OUT2_D3N)
DPB3_DOCK_DP: CN3601.84 U5301.32(OUT2_D3P)
DPB3_DP: C5307.1(A) U4555.B57(DDI1_TXP3)
DPB3_PORT_C_DN: C3304.2(B) CN3300.12
DPB3_PORT_C_DP: C3305.2(B) CN3300.10
DPB3_PORT_DN: C3304.1(A) U5301.41(OUT1_D3N)
DPB3_PORT_DP: C3305.1(A) U5301.42(OUT1_D3P)
DPB_AUX_C_DN: C5399.2(B) U5301.25(IN_AUXN)
DPB_AUX_C_DP: C5398.2(B) U5301.24(IN_AUXP)
DPB_AUX_DN: C5399.1(A) U4555.C5(DDPB_AUXN)
DPB_AUX_DP: C5398.1(A) U4555.B5(DDPB_AUXP)
DPB_DDCCLK: R4786.1(A) U4555.B9(DDPB_CTRLCLK) U5301.22(IN_DDC_SCL)
DPB_DDCDATA: R4787.1(A) U4555.C9(DDPB_CTRLDATA) U5301.23(IN_DDC_SDA)
DPB_DOCK_CA_DET: CN3601.13 U5301.33(OUT2_CA_DET)
DPB_DOCK_CLK_AUX_DP: CN3601.36 CN3601.39 R5316.1(A) R5320.1(A) U5301.28(OUT2_AUXP_SCL)
DPB_DOCK_DATA_AUX_DN: CN3601.35 CN3601.38 R5317.1(A) R5319.1(A) U5301.29(OUT2_AUXN_SDA)
DPB_DOCK_HPD: CN3601.34 U5301.38(OUT2_HPD)
DPB_HPD: R4758.1(A) U4555.C8(DDPB_HPD) U5301.3(IN_HPD)
DPB_IN_CA_DET: TP5300.1 U5301.4(IN_CA_DET)
DPB_PORT_CA_DET: CN3300.13 R3304.1(A) U5301.43(OUT1_CA_DET)
DPB_PORT_CLK_AUX_DP: CN3300.15 R3303.1(A) U5301.26(OUT1_AUXP_SCL)
DPB_PORT_DATA_AUX_DN: CN3300.17 R3301.2(B) U5301.27(OUT1_AUXN_SDA)
DPB_PORT_HPD: CN3300.18 U5301.48(OUT1_HPD)
DPC0_C_DN: C5402.2(B) U5401.7(IN_D0N)
DPC0_C_DP: C5401.2(B) U5401.6(IN_D0P)
DPC0_DN: C5402.1(A) U4555.C51(DDI2_TXN0)
DPC0_DOCK_DN: CN3601.64 U5401.39(OUT2_D0N)
DPC0_DOCK_DP: CN3601.63 U5401.40(OUT2_D0P)
DPC0_DP: C5401.1(A) U4555.C50(DDI2_TXP0)
DPC0_PORT_C_DN: C3079.2(B) U3065.7
DPC0_PORT_C_DP: C3078.2(B) U3065.6
DPC0_PORT_DN: C3079.1(A) U5401.49(OUT1_D0N)
DPC0_PORT_DP: C3078.1(A) U5401.50(OUT1_D0P)
DPC1_C_DN: C5404.2(B) U5401.10(IN_D1N)
DPC1_C_DP: C5403.2(B) U5401.9(IN_D1P)
DPC1_DN: C5404.1(A) U4555.C53(DDI2_TXN1)
DPC1_DOCK_DN: CN3601.67 U5401.36(OUT2_D1N)
DPC1_DOCK_DP: CN3601.66 U5401.37(OUT2_D1P)
DPC1_DP: C5403.1(A) U4555.B54(DDI2_TXP1)
DPC1_PORT_C_DN: C3081.2(B) U3065.10
DPC1_PORT_C_DP: C3080.2(B) U3065.9
DPC1_PORT_DN: C3081.1(A) U5401.46(OUT1_D1N)
DPC1_PORT_DP: C3080.1(A) U5401.47(OUT1_D1P)
DPC_AUX_C_DN: C5499.2(B) U5401.25(IN_AUXN)
DPC_AUX_C_DP: C5498.2(B) U5401.24(IN_AUXP)
DPC_AUX_DN: C5499.1(A) U4555.B6(DDPC_AUXN)
DPC_AUX_DP: C5498.1(A) U4555.A6(DDPC_AUXP)
DPC_DDCCLK: R4788.1(A) U4555.D9(DDPC_CTRLCLK) U5401.22(IN_DDC_SCL)
DPC_DDCDATA: R4789.1(A) U4555.D11(DDPC_CTRLDATA) U5401.23(IN_DDC_SDA)
DPC_DOCK_CA_DET: R5421.1(A) R5422.1(A) U5401.33(OUT2_CA_DET)
DPC_DOCK_CLK_AUX_DP: CN3601.30 R5423.1(A) R5425.2(B) U5401.28(OUT2_AUXP_SCL)
DPC_DOCK_DATA_AUX_DN: CN3601.29 R5424.1(A) R5426.2(B) U5401.29(OUT2_AUXN_SDA)
DPC_DOCK_HPD: CN3601.24 U5401.38(OUT2_HPD)
DPC_HPD: R4759.1(A) U4555.A8(DDPC_HPD) U5401.3(IN_HPD)
DPC_IN_CA_DET: TP5400.1 U5401.4(IN_CA_DET)
DPC_PORT_CA_DET: R5419.1(A) R5420.1(A) U5401.43(OUT1_CA_DET)
DPC_PORT_CLK_AUX_C1_DP: C3075.2(B) U3065.3
DPC_PORT_CLK_AUX_DP: C3075.1(A) R5417.1(A) U5401.26(OUT1_AUXP_SCL)
DPC_PORT_DATA_AUX_C1_DN: C3076.2(B) U3065.4
DPC_PORT_DATA_AUX_DN: C3076.1(A) R5416.2(B) U5401.27(OUT1_AUXN_SDA)
DPC_PORT_HPD: R3071.2(B) U3065.13 U5401.48(OUT1_HPD)
DPPC10: R5301.1(A) R5302.1(A) U5301.56(PC10)
DPPC11: R5303.1(A) R5304.1(A) U5301.55(PC11)
DPPC20: R5305.1(A) R5306.1(A) U5301.54(PC20)
DPPC21: R5307.1(A) R5308.1(A) U5301.53(PC21)
DPWROK: R4936.2(B) R7001.2(B) U7000.4(OUT-Y)
EDP_AUX_C_DN: C3009.2(B) CN3000.26
EDP_AUX_C_DP: C3010.2(B) CN3000.27
EDP_AUX_DN: C3009.1(A) U4555.A45(EDP_AUXN)
EDP_AUX_DP: C3010.1(A) U4555.B45(EDP_AUXP)
EDP_HPD#: CN3000.20 R3021.1(A) U4555.D6(EDP_HPD)
EDP_TX0_C_DN: C3012.2(B) CN3000.30
EDP_TX0_C_DP: C3011.2(B) CN3000.29
EDP_TX0_DN: C3012.1(A) U4555.C45(EDP_TXN0)
EDP_TX0_DP: C3011.1(A) U4555.B46(EDP_TXP0)
EDP_TX1_C_DN: C3014.2(B) CN3000.33
EDP_TX1_C_DP: C3013.2(B) CN3000.32
EDP_TX1_DN: C3014.1(A) U4555.A47(EDP_TXN1)
EDP_TX1_DP: C3013.1(A) U4555.B47(EDP_TXP1)
EMCLK: R312.1(A) U300.66(PS2_CLK0/GPIO046)
EMDAT: R313.1(A) U300.67(PS2_DAT0/GPIO047)
EN_1V2A: C7036.1(A) R7021.2(B) R7023.2(B) U6450.5
EN_1V05A: C7037.1(A) R7019.2(B) U6300.2(EN)
EN_1V5S: C7035.1(A) R7020.2(B) U6350.5
EN_3V: R6110.1(A) R7112.1(A) U6100.13
EN_3VLDO: R7117.2(B) U6100.12
EN_5V: R6160.1(A) R7113.1(A) U6150.13
EN_5V_3V: R7110.1(A) R7112.2(B) R7113.2(B) U4411.3(OT)
EN_5VLDO: R6150.1(A) R6151.2(B) R6167.1(A) R7116.2(B) U6150.12
EN_PVCORE: R4593.2(B) R6643.2(B) U4555.F60(VR_EN)
EN_VRPVDDQ: R7118.2(B) U6200.2(EN) U6240.9(S5)
EN_VRPVTT: R7119.2(B) U6240.7(S3)
EXT_MIC_JACK: L602.2(INB) R602.1(A) R604.1(A) R605.1(A) R620.1(A)
FET_A: R305.1(A) R332.1(A) U300.123(GPIO044/NSMI)
FET_B: R304.1(A) R327.1(A) U300.116(GPIO163)
FPR_LOCK#: CN2200.5 R2200.1(A) R4706.2(B) U4555.U4(GPIO48)
FPR_OFF: CN2200.6 R2204.2(B) R2205.2(B)
FPR_OFF_GPIO11: R2201.1(A) R2204.1(A) U4555.AN2(SMBALERT/GPIO11*)
FPR_OFF_GPIO65: R2205.1(A) R4745.1(A) U4555.F4(SDIO_CMD/GPIO65)
GPIO3: R4906.1(A) U4555.J4(UART1_CTS/GPIO3*)
GPIO4: R4859.1(A) U4555.F2(I2C0_SDA/GPIO4)
GPIO5: R4735.1(A) U4555.F3(I2C0_SCL/GPIO5)
GPIO10: R4960.2(B) U4555.AM2(GPIO10)
GPIO13: R4961.2(B) U4555.AT3(GPIO13)
GPIO14: R4741.2(B) U4555.AH4(GPIO14)
GPIO24: R4908.2(B) U4555.AD5(GPIO24)
GPIO25: R4909.2(B) U4555.AM4(GPIO25)
GPIO34: R4818.2(B) U4555.V1(SATA0GP/GPIO34)
GPIO35: R4817.1(A) U4555.U1(SATA1GP/GPIO35)
GPIO43: R4778.1(A) U4555.AV3(OC3/GPIO43*)
GPIO44: R4911.2(B) U4555.AK4(GPIO44)
GPIO47: R4916.2(B) U4555.AB6(GPIO47)
GPIO51: R4782.1(A) R4868.2(B) U4555.R5(GPIO51)
GPIO64: R4738.1(A) U4555.E3(SDIO_CLK/GPIO64)
GPIO67: R4749.1(A) U4555.E4(SDIO_D1/GPIO67)
GPIO68: R4750.1(A) U4555.C3(SDIO_D2/GPIO68)
GPIO69: R4752.1(A) U4555.E2(SDIO_D3/GPIO69)
GPIO83: R4764.1(A) U4555.R6(GSPI0_CS/GPIO83*)
GPIO84: R4754.1(A) U4555.L6(GSPI0_CLK/GPIO84)
GPIO85: R4806.1(A) U4555.N6(GSPI0_MISO/GPIO85)
GPIO86: R4809.1(A) U4555.L8(GSPI0_MOSI/GPIO86)
GPIO87: R4810.1(A) U4555.R7(GSPI1_CS/GPIO87*)
GPIO88: R4813.1(A) U4555.L5(GSPI1_CLK/GPIO88)
GPIO89: R4814.1(A) U4555.N7(GSPI1_MISO/GPIO89)
GPIO90: R4755.1(A) U4555.K2(GSPI_MOSI/GPIO90)
GPIO94: R4763.1(A) U4555.G1(UART0_CTS/GPIO94*)
GPIO134: R391.1(A) U300.110(I2C0_CLK1/GPIO134)
GPS_XMIT_OFF#: CN1400.26(AUDIO_3) R4708.1(A) U4555.V4(RCIN/GPIO82*)
GPU_THRM_DMINUS: C5010.2(B) Q5000.2(E) U5000.3
GPU_THRM_DPLUS: C5010.1(A) Q5000.1(B) Q5000.3(C) U5000.2
H_BPM0_XDP#: CN4920.21(OBSFN_B0) U4555.J60(BPM#0)
H_BPM1_XDP#: CN4920.23(OBSFN_B1) U4555.H60(BPM#1)
H_BPM2_XDP#: TP4552.1 U4555.H61(BPM#2)
H_BPM3_XDP#: TP4553.1 U4555.H62(BPM#3)
H_BPM4_XDP#: TP4554.1 U4555.K59(BPM#4)
H_BPM5_XDP#: TP4555.1 U4555.H63(BPM#5)
H_BPM6_XDP#: TP4556.1 U4555.K60(BPM#6)
H_BPM7_XDP#: TP4557.1 U4555.J61(BPM#7)
H_PECI: R328.2(B) U4555.N62(PECI)
H_PRDY#: CN4920.5(OBSFN_A1) U4555.J62(PRDY*)
H_PREQ#: CN4920.3(OBSFN_A0) U4555.K62(PREQ*)
H_PWRGD: R4527.2(B) U4555.C61(PROCPWRGD)
H_TCK: CN4920.57(TCK0) R4509.2(B) R4822.2(B) U4555.E60(PROC_TCK)
H_TDI: Q4921.1(S1) R4508.1(A) U4555.F63(PROC_TDI)
H_TDO: Q4920.1(S1) R4920.1(A) U4555.F62(PROC_TDO)
H_TMS: Q4921.4(S2) R4507.1(A) U4555.E61(PROC_TMS)
H_TRST#: Q4920.4(S2) R4526.1(A) U4555.AU62(PCH_TRST*) U4555.E59(PROC_TRST*)
HDA_SDO_R: Q4754.3(D) Q4756.3(D) R4874.2(B) U4555.AU11(HDA_SDO/I2S0_TXD)
HDD_HALTLED: CN200.17 R4867.1(A)
HDD_HALTLED_R: R4867.2(B) U4555.N2(PIRQD/GPIO80*)
HDD_SM_HALTLED: CN9000.17 Q9032.5(G2) R9035.2(B) R9037.1(A)
HDD_STP#: D9030.3(-) Q9032.2(G1) Q9032.3(D2) R9036.2(B)
HP_AMP_PD#: D501.3 R503.1(A) R570.1(A) U550.6(SD) U551.6(SD)
HP_OUT_AMP_L1: C575.1(A) C602.1(A) JACK600.4 L550.2(INB)
HP_OUT_AMP_R1: C574.1(A) C601.1(A) JACK600.1 L551.2(INB)
HP_OUT_L1: C572.2(B) U501.31(HP-OUT-L)
HP_OUT_R1: C573.2(B) U501.32(HP-OUT-R)
HPOUT_DET: Q600.3(D) R515.2(B)
HUB_XTAL_IN: C2566.2(B) R2500.2(B) U2550.62(XTALI/CLK_IN) X2500.3
HUB_XTAL_OUT: C2550.2(B) R2500.1(A) U2550.61(XTALO) X2500.1
I2C_CLK: CN3601.32 R4835.2(B)
I2C_DATA: CN3601.33 R4836.2(B)
ICCINSERTN: CN9001.9(SW-CD) U9000.19(ICCINSERTN)
ICS: C6049.1(A) R6913.1(A) U6000.7(IOUT)
IM_5S_CLK: CN200.9 R385.1(A) U300.35(PS2_CLK2/GPIO051)
IM_5S_CLK_SM: CN9000.9 CN9021.3
IM_5S_DATA: CN200.10 R386.1(A) U300.32(PS2_DAT2/GPIO052)
IM_5S_DATA_SM: CN9000.10 CN9021.4
INTLWAKE#: R4717.2(B) R4934.1(A) U4555.AN5(GPIO27)
INTRUDER#: Q4831.3(D) R1405.2(B) R4833.2(B) U4555.AU6(INTRUDER*)
INTVRMEN_R: R4842.2(B) R4876.2(B) U4555.AV7(INTVRMEN)
INV_PWM: C3015.1(A) CN3000.18 U4555.B8(EDP_BKLCTL)
ISCT_LED#: Q113.1(G) R319.1(A) R323.1(A)
ISO_PREP#: C486.1(A) CN3601.47 Q486.1(B) R4700.1(A) R4857.2(B)
JTAG_RST#: R335.1(A) R371.1(A) U300.49(JTAG_NRST)
KBC_ECPH_CLK: Q4753.6(D1) R4829.1(A) U300.126(GPIO024/I2C3_CLK0)
KBC_ECPH_DATA: Q4753.3(D2) R4838.1(A) U300.125(GPIO025/I2C3_DAT0)
KBC_PROCHOT: Q4501.1(G) R4516.1(A) U300.90(GPIO021/I2C2_DAT0)
KBC_PWR_ON: Q7350.2(G1) R352.2(B) R7019.1(A) R7021.1(A)
KBL_DET#: CN301.6 R4729.2(B) U4555.Y1(GPIO16)
KSCAN_3S_IN<0>: CN300.26 D302.1 SW154.1
KSCAN_3S_IN<1>: CN300.23 D302.5 SW152.1
KSCAN_3S_IN<2>: CN300.24 D304.1
KSCAN_3S_IN<3>: CN300.22 D304.5
KSCAN_3S_IN<4>: CN300.25 D303.1
KSCAN_3S_IN<5>: CN300.14 D303.5
KSCAN_3S_IN<6>: CN300.13 D301.1
KSCAN_3S_IN<8>: CN300.29 D302.2
KSCAN_3S_IN<9>: CN300.9 D302.4
KSCAN_3S_IN<10>: CN300.27 D304.2
KSCAN_3S_IN<11>: CN300.10 D304.4
KSCAN_3S_IN<12>: CN300.28 D303.2
KSCAN_3S_IN<13>: CN300.11 D303.4
KSCAN_3S_IN<14>: CN300.30 D301.2
L_BKLT_EN: R3008.1(A) R3009.1(A) U4555.A9(EDP_BKLEN)
LAN_DIS#: R405.1(A) R488.1(A) R4721.2(B) U400.3 U4555.AM7(LAN_PHY_PWR_CTRL/GPIO12)
LANLINK_STATUS: CN3601.11 Q487.3(C) R4734.2(B) U4555.AL3(OC0/GPIO40*)
LED_3S_LANACT#: CN3601.12 D486.1 JACK485.B1 R403.1(A)
LED_3S_LANLINK#: Q487.2(E) R402.2(B) R489.2(B) U400.26
LED_3S_LANLINK#_R: D485.1 JACK485.A1 R402.1(A)
LED_3S_SATA#: CN200.18 R4816.2(B) U4555.U3(SATALED*)
LED_3S_SM_SATA#: CN9000.18 Q9032.1(S1)
LED_PWRSTBY#: CN200.21 CN290.2 CN3601.23 R303.1(A) R361.2(B) TP291.1 U302.6(Y1)
LED_PWRSTBY#_PB: CN9100.5 D9100.1(A1)
LED_SM_PWRSTBY#: CN9000.21 D9031.1(OUT)
LED_WWAN_LINK#: CN1400.10(LED1#/DAS/DSS#) Q112.2(S) R113.1(A)
LID_SW#_3: CN290.4 D3000.3(A1) Q115.1(G) R314.1(A) TP293.1 U300.64(GPIO027)
LID_SW#_3_PB: CN9100.3 U9100.2
LIMIT_SIGNAL: CN3601.46 D6015.2 JACK6000.2 R6918.1(A)
LIMIT_SIGNAL_100R: Q6902.2(S) R6910.1(A) R6918.2(B) R6998.1(A)
LINE_IN_DET: Q528.6(D1) R528.2(B)
LINE_IN_SENSE: CN3601.14 Q528.2(G1) R529.2(B)
LINE_OUT_DET: Q528.3(D2) R531.2(B)
LINE_OUT_SENSE: CN3601.15 Q528.5(G2) R530.1(A)
LPC_3S_AD<0>: CN375.8 U300.46(LAD0/GPIO112) U3500.26 U4555.AU14(LAD0)
LPC_3S_AD<1>: CN375.9 U300.48(LAD1/GPIO114) U3500.23 U4555.AW12(LAD1)
LPC_3S_AD<2>: CN375.10 U300.50(LAD2/GPIO113) U3500.20 U4555.AY12(LAD2)
LPC_3S_AD<3>: CN375.11 U300.51(LAD3/GPIO111) U3500.17 U4555.AW11(LAD3)
LPC_3S_FRAME#: CN375.4 U300.52(NLFRAME/GPIO120) U3500.22 U4555.AV12(LFRAME*)
LPC_RESET#: R4868.1(A) U300.53(NLRESET/GPIO116)
LVDS_VDD_EN: R3003.1(A) R3013.1(A) U3000.3 U4555.C6(EDP_VDDEN)
M_A_A<0>: CN4100.98(A0) U4555.AU36(SA_MA0)
M_A_A<1>: CN4100.97(A1) U4555.AY37(SA_MA1)
M_A_A<2>: CN4100.96(A2) U4555.AR38(SA_MA2)
M_A_A<3>: CN4100.95(A3) U4555.AP36(SA_MA3)
M_A_A<4>: CN4100.92(A4) U4555.AU39(SA_MA4)
M_A_A<5>: CN4100.91(A5) U4555.AR36(SA_MA5)
M_A_A<6>: CN4100.90(A6) U4555.AV40(SA_MA6)
M_A_A<7>: CN4100.86(A7) U4555.AW39(SA_MA7)
M_A_A<8>: CN4100.89(A8) U4555.AY39(SA_MA8)
M_A_A<9>: CN4100.85(A9) U4555.AU40(SA_MA9)
M_A_A<10>: CN4100.107(A10_AP) U4555.AP35(SA_MA10)
M_A_A<11>: CN4100.84(A11) U4555.AW41(SA_MA11)
M_A_A<12>: CN4100.83(A12) U4555.AU41(SA_MA12)
M_A_A<13>: CN4100.119(A13) U4555.AR35(SA_MA13)
M_A_A<14>: CN4100.80(A14) U4555.AV42(SA_MA14)
M_A_A<15>: CN4100.78(A15) U4555.AU42(SA_MA15)
M_A_BS0: CN4100.109(BA0) U4555.AU35(SA_BA0)
M_A_BS1: CN4100.108(BA1) U4555.AV35(SA_BA1)
M_A_BS2: CN4100.79(BA2) U4555.AY41(SA_BA2)
M_A_CAS#: CN4100.115(CAS#) U4555.AU34(SA_CAS*)
M_A_DQ<0>: CN4100.129(DQ32) U4555.AH63(SA_DQ0)
M_A_DQ<1>: CN4100.131(DQ33) U4555.AH62(SA_DQ1)
M_A_DQ<2>: CN4100.141(DQ34) U4555.AK63(SA_DQ2)
M_A_DQ<3>: CN4100.143(DQ35) U4555.AK62(SA_DQ3)
M_A_DQ<4>: CN4100.130(DQ36) U4555.AH61(SA_DQ4)
M_A_DQ<5>: CN4100.132(DQ37) U4555.AH60(SA_DQ5)
M_A_DQ<6>: CN4100.140(DQ38) U4555.AK61(SA_DQ6)
M_A_DQ<7>: CN4100.142(DQ39) U4555.AK60(SA_DQ7)
M_A_DQ<8>: CN4100.5(DQ0) U4555.AM63(SA_DQ8)
M_A_DQ<9>: CN4100.7(DQ1) U4555.AM62(SA_DQ9)
M_A_DQ<10>: CN4100.15(DQ2) U4555.AP63(SA_DQ10)
M_A_DQ<11>: CN4100.17(DQ3) U4555.AP62(SA_DQ11)
M_A_DQ<12>: CN4100.4(DQ4) U4555.AM61(SA_DQ12)
M_A_DQ<13>: CN4100.6(DQ5) U4555.AM60(SA_DQ13)
M_A_DQ<14>: CN4100.16(DQ6) U4555.AP61(SA_DQ14)
M_A_DQ<15>: CN4100.18(DQ7) U4555.AP60(SA_DQ15)
M_A_DQ<16>: CN4100.159(DQ43) U4555.AP58(SA_DQ16)
M_A_DQ<17>: CN4100.157(DQ42) U4555.AR58(SA_DQ17)
M_A_DQ<18>: CN4100.149(DQ41) U4555.AM57(SA_DQ18)
M_A_DQ<19>: CN4100.148(DQ45) U4555.AK57(SA_DQ19)
M_A_DQ<20>: CN4100.147(DQ40) U4555.AL58(SA_DQ20)
M_A_DQ<21>: CN4100.146(DQ44) U4555.AK58(SA_DQ21)
M_A_DQ<22>: CN4100.158(DQ46) U4555.AR57(SA_DQ22)
M_A_DQ<23>: CN4100.160(DQ47) U4555.AN57(SA_DQ23)
M_A_DQ<24>: CN4100.21(DQ8) U4555.AP55(SA_DQ24)
M_A_DQ<25>: CN4100.23(DQ9) U4555.AR55(SA_DQ25)
M_A_DQ<26>: CN4100.33(DQ10) U4555.AM54(SA_DQ26)
M_A_DQ<27>: CN4100.35(DQ11) U4555.AK54(SA_DQ27)
M_A_DQ<28>: CN4100.22(DQ12) U4555.AL55(SA_DQ28)
M_A_DQ<29>: CN4100.24(DQ13) U4555.AK55(SA_DQ29)
M_A_DQ<30>: CN4100.34(DQ14) U4555.AR54(SA_DQ30)
M_A_DQ<31>: CN4100.36(DQ15) U4555.AN54(SA_DQ31)
M_A_DQ<32>: CN4100.163(DQ48) U4555.AY58(SA_DQ32)
M_A_DQ<33>: CN4100.165(DQ49) U4555.AW58(SA_DQ33)
M_A_DQ<34>: CN4100.176(DQ55) U4555.AY56(SA_DQ34)
M_A_DQ<35>: CN4100.175(DQ50) U4555.AW56(SA_DQ35)
M_A_DQ<36>: CN4100.164(DQ52) U4555.AV58(SA_DQ36)
M_A_DQ<37>: CN4100.166(DQ53) U4555.AU58(SA_DQ37)
M_A_DQ<38>: CN4100.174(DQ54) U4555.AV56(SA_DQ38)
M_A_DQ<39>: CN4100.177(DQ51) U4555.AU56(SA_DQ39)
M_A_DQ<40>: CN4100.39(DQ16) U4555.AY54(SA_DQ40)
M_A_DQ<41>: CN4100.41(DQ17) U4555.AW54(SA_DQ41)
M_A_DQ<42>: CN4100.51(DQ18) U4555.AY52(SA_DQ42)
M_A_DQ<43>: CN4100.53(DQ19) U4555.AW52(SA_DQ43)
M_A_DQ<44>: CN4100.40(DQ20) U4555.AV54(SA_DQ44)
M_A_DQ<45>: CN4100.42(DQ21) U4555.AU54(SA_DQ45)
M_A_DQ<46>: CN4100.50(DQ22) U4555.AV52(SA_DQ46)
M_A_DQ<47>: CN4100.52(DQ23) U4555.AU52(SA_DQ47)
M_A_DQ<48>: CN4100.70(DQ31) U4555.AK40(SA_DQ48)
M_A_DQ<49>: CN4100.69(DQ27) U4555.AK42(SA_DQ49)
M_A_DQ<50>: CN4100.57(DQ24) U4555.AM43(SA_DQ50)
M_A_DQ<51>: CN4100.59(DQ25) U4555.AM45(SA_DQ51)
M_A_DQ<52>: CN4100.56(DQ28) U4555.AK45(SA_DQ52)
M_A_DQ<53>: CN4100.58(DQ29) U4555.AK43(SA_DQ53)
M_A_DQ<54>: CN4100.68(DQ30) U4555.AM40(SA_DQ54)
M_A_DQ<55>: CN4100.67(DQ26) U4555.AM42(SA_DQ55)
M_A_DQ<56>: CN4100.194(DQ63) U4555.AM46(SA_DQ56)
M_A_DQ<57>: CN4100.192(DQ62) U4555.AK46(SA_DQ57)
M_A_DQ<58>: CN4100.180(DQ60) U4555.AM49(SA_DQ58)
M_A_DQ<59>: CN4100.182(DQ61) U4555.AK49(SA_DQ59)
M_A_DQ<60>: CN4100.191(DQ58) U4555.AM48(SA_DQ60)
M_A_DQ<61>: CN4100.193(DQ59) U4555.AK48(SA_DQ61)
M_A_DQ<62>: CN4100.183(DQ57) U4555.AM51(SA_DQ62)
M_A_DQ<63>: CN4100.181(DQ56) U4555.AK51(SA_DQ63)
M_A_DQS0_DN: CN4100.135(DQS#4) U4555.AJ61(SA_DQSN0)
M_A_DQS0_DP: CN4100.137(DQS4) U4555.AJ62(SA_DQSP0)
M_A_DQS1_DN: CN4100.10(DQS#0) U4555.AN62(SA_DQSN1)
M_A_DQS1_DP: CN4100.12(DQS0) U4555.AN61(SA_DQSP1)
M_A_DQS2_DN: CN4100.152(DQS#5) U4555.AM58(SA_DQSN2)
M_A_DQS2_DP: CN4100.154(DQS5) U4555.AN58(SA_DQSP2)
M_A_DQS3_DN: CN4100.27(DQS#1) U4555.AM55(SA_DQSN3)
M_A_DQS3_DP: CN4100.29(DQS1) U4555.AN55(SA_DQSP3)
M_A_DQS4_DN: CN4100.169(DQS#6) U4555.AV57(SA_DQSN4)
M_A_DQS4_DP: CN4100.171(DQS6) U4555.AW57(SA_DQSP4)
M_A_DQS5_DN: CN4100.45(DQS#2) U4555.AV53(SA_DQSN5)
M_A_DQS5_DP: CN4100.47(DQS2) U4555.AW53(SA_DQSP5)
M_A_DQS6_DN: CN4100.62(DQS#3) U4555.AL43(SA_DQSN6)
M_A_DQS6_DP: CN4100.64(DQS3) U4555.AL42(SA_DQSP6)
M_A_DQS7_DN: CN4100.186(DQS#7) U4555.AL48(SA_DQSN7)
M_A_DQS7_DP: CN4100.188(DQS7) U4555.AL49(SA_DQSP7)
M_A_RAS#: CN4100.110(RAS#) U4555.AY34(SA_RAS*)
M_A_WE#: CN4100.113(WE#) U4555.AW34(SA_WE*)
M_B_A<0>: CN4125.98(A0) U4555.AP40(SB_MA0)
M_B_A<1>: CN4125.97(A1) U4555.AR40(SB_MA1)
M_B_A<2>: CN4125.96(A2) U4555.AP42(SB_MA2)
M_B_A<3>: CN4125.95(A3) U4555.AR42(SB_MA3)
M_B_A<4>: CN4125.92(A4) U4555.AR45(SB_MA4)
M_B_A<5>: CN4125.91(A5) U4555.AP45(SB_MA5)
M_B_A<6>: CN4125.90(A6) U4555.AW46(SB_MA6)
M_B_A<7>: CN4125.86(A7) U4555.AY46(SB_MA7)
M_B_A<8>: CN4125.89(A8) U4555.AY47(SB_MA8)
M_B_A<9>: CN4125.85(A9) U4555.AU46(SB_MA9)
M_B_A<10>: CN4125.107(A10_AP) U4555.AK36(SB_MA10)
M_B_A<11>: CN4125.84(A11) U4555.AV47(SB_MA11)
M_B_A<12>: CN4125.83(A12) U4555.AU47(SB_MA12)
M_B_A<13>: CN4125.119(A13) U4555.AK33(SB_MA13)
M_B_A<14>: CN4125.80(A14) U4555.AR46(SB_MA14)
M_B_A<15>: CN4125.78(A15) U4555.AP46(SB_MA15)
M_B_BS0: CN4125.109(BA0) U4555.AL35(SB_BA0)
M_B_BS1: CN4125.108(BA1) U4555.AM36(SB_BA1)
M_B_BS2: CN4125.79(BA2) U4555.AU49(SB_BA2)
M_B_CAS#: CN4125.115(CAS#) U4555.AM33(SB_CAS*)
M_B_DQ<0>: CN4125.129(DQ32) U4555.AY31(SB_DQ0)
M_B_DQ<1>: CN4125.131(DQ33) U4555.AW31(SB_DQ1)
M_B_DQ<2>: CN4125.140(DQ38) U4555.AY29(SB_DQ2)
M_B_DQ<3>: CN4125.143(DQ35) U4555.AW29(SB_DQ3)
M_B_DQ<4>: CN4125.130(DQ36) U4555.AV31(SB_DQ4)
M_B_DQ<5>: CN4125.132(DQ37) U4555.AU31(SB_DQ5)
M_B_DQ<6>: CN4125.142(DQ39) U4555.AV29(SB_DQ6)
M_B_DQ<7>: CN4125.141(DQ34) U4555.AU29(SB_DQ7)
M_B_DQ<8>: CN4125.5(DQ0) U4555.AY27(SB_DQ8)
M_B_DQ<9>: CN4125.6(DQ5) U4555.AW27(SB_DQ9)
M_B_DQ<10>: CN4125.15(DQ2) U4555.AY25(SB_DQ10)
M_B_DQ<11>: CN4125.17(DQ3) U4555.AW25(SB_DQ11)
M_B_DQ<12>: CN4125.4(DQ4) U4555.AV27(SB_DQ12)
M_B_DQ<13>: CN4125.16(DQ6) U4555.AU27(SB_DQ13)
M_B_DQ<14>: CN4125.7(DQ1) U4555.AV25(SB_DQ14)
M_B_DQ<15>: CN4125.18(DQ7) U4555.AU25(SB_DQ15)
M_B_DQ<16>: CN4125.146(DQ44) U4555.AM29(SB_DQ16)
M_B_DQ<17>: CN4125.148(DQ45) U4555.AK29(SB_DQ17)
M_B_DQ<18>: CN4125.160(DQ47) U4555.AL28(SB_DQ18)
M_B_DQ<19>: CN4125.158(DQ46) U4555.AK28(SB_DQ19)
M_B_DQ<20>: CN4125.147(DQ40) U4555.AR29(SB_DQ20)
M_B_DQ<21>: CN4125.149(DQ41) U4555.AN29(SB_DQ21)
M_B_DQ<22>: CN4125.157(DQ42) U4555.AR28(SB_DQ22)
M_B_DQ<23>: CN4125.159(DQ43) U4555.AP28(SB_DQ23)
M_B_DQ<24>: CN4125.24(DQ13) U4555.AN26(SB_DQ24)
M_B_DQ<25>: CN4125.22(DQ12) U4555.AR26(SB_DQ25)
M_B_DQ<26>: CN4125.33(DQ10) U4555.AR25(SB_DQ26)
M_B_DQ<27>: CN4125.35(DQ11) U4555.AP25(SB_DQ27)
M_B_DQ<28>: CN4125.23(DQ9) U4555.AK26(SB_DQ28)
M_B_DQ<29>: CN4125.21(DQ8) U4555.AM26(SB_DQ29)
M_B_DQ<30>: CN4125.34(DQ14) U4555.AK25(SB_DQ30)
M_B_DQ<31>: CN4125.36(DQ15) U4555.AL25(SB_DQ31)
M_B_DQ<32>: CN4125.163(DQ48) U4555.AY23(SB_DQ32)
M_B_DQ<33>: CN4125.165(DQ49) U4555.AW23(SB_DQ33)
M_B_DQ<34>: CN4125.175(DQ50) U4555.AY21(SB_DQ34)
M_B_DQ<35>: CN4125.177(DQ51) U4555.AW21(SB_DQ35)
M_B_DQ<36>: CN4125.164(DQ52) U4555.AV23(SB_DQ36)
M_B_DQ<37>: CN4125.166(DQ53) U4555.AU23(SB_DQ37)
M_B_DQ<38>: CN4125.174(DQ54) U4555.AV21(SB_DQ38)
M_B_DQ<39>: CN4125.176(DQ55) U4555.AU21(SB_DQ39)
M_B_DQ<40>: CN4125.39(DQ16) U4555.AY19(SB_DQ40)
M_B_DQ<41>: CN4125.41(DQ17) U4555.AW19(SB_DQ41)
M_B_DQ<42>: CN4125.52(DQ23) U4555.AY17(SB_DQ42)
M_B_DQ<43>: CN4125.53(DQ19) U4555.AW17(SB_DQ43)
M_B_DQ<44>: CN4125.40(DQ20) U4555.AV19(SB_DQ44)
M_B_DQ<45>: CN4125.42(DQ21) U4555.AU19(SB_DQ45)
M_B_DQ<46>: CN4125.50(DQ22) U4555.AV17(SB_DQ46)
M_B_DQ<47>: CN4125.51(DQ18) U4555.AU17(SB_DQ47)
M_B_DQ<48>: CN4125.194(DQ63) U4555.AR21(SB_DQ48)
M_B_DQ<49>: CN4125.182(DQ61) U4555.AR22(SB_DQ49)
M_B_DQ<50>: CN4125.191(DQ58) U4555.AL21(SB_DQ50)
M_B_DQ<51>: CN4125.183(DQ57) U4555.AM22(SB_DQ51)
M_B_DQ<52>: CN4125.180(DQ60) U4555.AN22(SB_DQ52)
M_B_DQ<53>: CN4125.193(DQ59) U4555.AP21(SB_DQ53)
M_B_DQ<54>: CN4125.192(DQ62) U4555.AK21(SB_DQ54)
M_B_DQ<55>: CN4125.181(DQ56) U4555.AK22(SB_DQ55)
M_B_DQ<56>: CN4125.57(DQ24) U4555.AN20(SB_DQ56)
M_B_DQ<57>: CN4125.59(DQ25) U4555.AR20(SB_DQ57)
M_B_DQ<58>: CN4125.67(DQ26) U4555.AK18(SB_DQ58)
M_B_DQ<59>: CN4125.69(DQ27) U4555.AL18(SB_DQ59)
M_B_DQ<60>: CN4125.56(DQ28) U4555.AK20(SB_DQ60)
M_B_DQ<61>: CN4125.58(DQ29) U4555.AM20(SB_DQ61)
M_B_DQ<62>: CN4125.68(DQ30) U4555.AR18(SB_DQ62)
M_B_DQ<63>: CN4125.70(DQ31) U4555.AP18(SB_DQ63)
M_B_DQS0_DN: CN4125.135(DQS#4) U4555.AW30(SB_DQSN0)
M_B_DQS0_DP: CN4125.137(DQS4) U4555.AV30(SB_DQSP0)
M_B_DQS1_DN: CN4125.10(DQS#0) U4555.AV26(SB_DQSN1)
M_B_DQS1_DP: CN4125.12(DQS0) U4555.AW26(SB_DQSP1)
M_B_DQS2_DN: CN4125.152(DQS#5) U4555.AN28(SB_DQSN2)
M_B_DQS2_DP: CN4125.154(DQS5) U4555.AM28(SB_DQSP2)
M_B_DQS3_DN: CN4125.27(DQS#1) U4555.AN25(SB_DQSN3)
M_B_DQS3_DP: CN4125.29(DQS1) U4555.AM25(SB_DQSP3)
M_B_DQS4_DN: CN4125.169(DQS#6) U4555.AW22(SB_DQSN4)
M_B_DQS4_DP: CN4125.171(DQS6) U4555.AV22(SB_DQSP4)
M_B_DQS5_DN: CN4125.45(DQS#2) U4555.AV18(SB_DQSN5)
M_B_DQS5_DP: CN4125.47(DQS2) U4555.AW18(SB_DQSP5)
M_B_DQS6_DN: CN4125.186(DQS#7) U4555.AN21(SB_DQSN6)
M_B_DQS6_DP: CN4125.188(DQS7) U4555.AM21(SB_DQSP6)
M_B_DQS7_DN: CN4125.62(DQS#3) U4555.AN18(SB_DQSN7)
M_B_DQS7_DP: CN4125.64(DQS3) U4555.AM18(SB_DQSP7)
M_B_RAS#: CN4125.110(RAS#) U4555.AM35(SB_RAS*)
M_B_WE#: CN4125.113(WE#) U4555.AK35(SB_WE*)
M_CKE0: CN4100.73(CKE0) U4555.AU43(SA_CKE0)
M_CKE1: CN4100.74(CKE1) U4555.AW43(SA_CKE1)
M_CKE2: CN4125.73(CKE0) U4555.AY49(SB_CKE0)
M_CKE3: CN4125.74(CKE1) U4555.AU50(SB_CKE1)
M_CLK_DDR0_DN: CN4100.103(CK0#) U4555.AU37(SA_CLK#0)
M_CLK_DDR0_DP: CN4100.101(CK0) U4555.AV37(SA_CLK0)
M_CLK_DDR1_DN: CN4100.104(CK1#) U4555.AW36(SA_CLK#1)
M_CLK_DDR1_DP: CN4100.102(CK1) U4555.AY36(SA_CLK1)
M_CLK_DDR2_DN: CN4125.103(CK0#) U4555.AM38(SB_CK#0)
M_CLK_DDR2_DP: CN4125.101(CK0) U4555.AN38(SB_CK0)
M_CLK_DDR3_DN: CN4125.104(CK1#) U4555.AK38(SB_CK#1)
M_CLK_DDR3_DP: CN4125.102(CK1) U4555.AL38(SB_CK1)
M_CS#0: CN4100.114(S0#) U4555.AP33(SA_CS#0)
M_CS#1: CN4100.121(S1#) U4555.AR32(SA_CS#1)
M_CS#2: CN4125.114(S0#) U4555.AM32(SB_CS#0)
M_CS#3: CN4125.121(S1#) U4555.AK32(SB_CS#1)
M_ODT0: CN4100.116(ODT0) R4117.2(B)
M_ODT1: CN4100.120(ODT1) R4118.2(B)
M_ODT2: CN4125.116(ODT0) R4119.2(B)
M_ODT3: CN4125.120(ODT1) R4120.2(B)
M_PWROK: R2952.1(A) R2953.2(B) R2954.2(B) R4723.1(A) R7415.1(A) U300.122(GPIO135/KBRST) U2950.4
MAIN_BAT_DET#: R6057.1(A) R6058.2(B) U300.92(GPIO105/TACH1)
MIC_BIAS: R602.2(B) U501.23(LINE1-VREFO)
MIC_VREF: Q320.5(G2) R334.1(A) R383.2(B) U501.30(MIC1-VREFO)
MPHY_PRW_EN: Q4942.5(G2) R4753.2(B) U4555.Y2(HSIOPC/GPIO71)
MSATA_DET#: Q1950.3(D) R1953.1(A) R4820.1(A) R4824.1(A) U4555.AC1(SATA3GP/GPIO37)
MSR_ENABLE_N: CN4920.60(GND17) R4939.1(A)
MUX_SELECT#: R4924.2(B) U4555.L1(GPIO52)
NB671LGQ_LP#: U6150.3
NFC_3S_CLK_DB: CN9000.35 CN9002.8
NFC_3S_DATA_DB: CN9000.34 CN9002.9
NFC_3S_SMCLK: CN200.35 Q4759.1(S1) R4776.1(A)
NFC_3S_SMDATA: CN200.34 Q4759.4(S2) R4783.1(A)
NFC_DWL_REQ: CN200.31 R4769.2(B) R4771.2(B) U4555.C4(SDIO_POWER_EN/GPIO70)
NFC_DWL_REQ_DB: CN9000.31 CN9002.5
NFC_INT: CN200.33 R4724.2(B) U4555.AN3(GPIO26)
NFC_INT_DB: CN9000.33 CN9002.11
NFC_RST#: CN200.36 R4725.2(B) U4555.AD7(GPIO28)
NFC_RST#_DB: CN9000.36 CN9002.6
NFC_SWP: CN200.32
NFC_SWP_DB: CN9000.32
NIC_XTAL_IN: C400.2(B) R400.2(B) U400.10 X400.3
NIC_XTAL_OUT: C404.2(B) R400.1(A) U400.9 X400.1
NMI_SMI_DBG#: CN375.7 Q302.2(S) R4765.1(A) U4555.V6(SATA2GP/GPIO36)
NUM_LOCK_LED#: CN375.15 R320.1(A) R394.1(A) U300.83(GPIO010/KSO15)
OCP_A_IN: D6901.1(A1) R315.1(A) R6917.2(B) R6936.2(B)
OCP_OC#: Q4700.3(D) R4780.1(A) U4555.N5(DEVSLP2/GPIO39)
OCP_PWM_OUT: Q4700.1(G) U300.59(ADC_TO_PWM_OUT/GPIO041)
OCS_N2: C2584.1(A) R2562.1(A) U2400.5 U2550.47(TMS/GPIO3/OCS2)
OCS_N3: C2582.1(A) R2563.1(A) U2401.5 U2550.44(TDI/UART_RX/GPIO6/OCS3)
ON_OFF#: CN290.3 Q115.2(S) TP292.1
ON_OFF#1: CN3601.43 CN4941.11 Q115.3(D) R100.1(A)
ON_OFF#_PB: CN9100.4 SW9100.3
OSC_IN: C3072.1(A) U3065.33 X3065.3
OSC_OUT: C3071.1(A) U3065.34 X3065.1
PCBEEP: C518.1(A) U501.12(PCBEEP)
PCBEEP_IC_C: C518.2(B) C519.1(A) R510.1(A) R513.2(B)
PCH_3A_SMCLK: Q4752.6(D1) R4830.2(B) U4555.AP2(SMBCLK)
PCH_3A_SMDATA: Q4752.3(D2) R4792.2(B) U4555.AH1(SMBDATA)
PCH_3M_SMCLK: Q4759.6(D1) R4797.2(B) U400.28 U4555.AN1(SML0CLK)
PCH_3M_SMDATA: Q4759.3(D2) R4884.2(B) U400.31 U4555.AK1(SML0DATA)
PCH_3S_SMCLK: CN200.4 CN4100.202(SCL) CN4125.202(SCL) CN4920.53(SCL) Q4752.1(S1) R3082.1(A) R4835.1(A) R4913.2(B)
PCH_3S_SMCLK_SM: CN9000.4 CN9021.6
PCH_3S_SMDATA: CN200.5 CN4100.200(SDA) CN4125.200(SDA) CN4920.51(SDA) Q4752.4(S2) R3083.1(A) R4828.2(B) R4836.1(A)
PCH_3S_SMDATA_SM: CN9000.5 CN9021.7
PCH_GPIO9: R4736.2(B) U4555.AM3(GPIO9)
PCH_JTAG: R4822.1(A) R4823.2(B) U4555.AE63(JTAGX)
PCH_KBC_SMCLK: Q5314.6(D1) R310.1(A) U300.89(GPIO022/I2C1_CLK0)
PCH_KBC_SMDATA: Q5314.3(D2) R311.1(A) U300.88(GPIO023/I2C1_DAT0)
PCH_PWROK: R4722.1(A) R4925.1(A) U4555.AY7(PCH_PWROK)
PCH_SLP_SUS#: R340.1(A) R4860.2(B) U300.75(32KHZ_OUT/GPIO013)
PCH_SLP_WLAN_N: U4555.AM5(SLP_WLAN/GPIO29*)
PCH_SML1CLK: Q4753.1(S1) R4827.2(B) U4555.AU3(SML1CLK/GPIO75)
PCH_SML1DATA: Q4753.4(S2) R4856.1(A) U4555.AH3(SML1DATA/GPIO74)
PCH_TCK: CN4920.55(TCK1) R4808.1(A) U4555.AE62(PCH_TCK)
PCH_TDI: CN4920.56(TDI) Q4921.6(D1) R4891.2(B) U4555.AD61(PCH_TDI)
PCH_TDO: CN4920.52(TDO) Q4920.6(D1) R4807.2(B) U4555.AE61(PCH_TDO)
PCH_TMS: CN4920.58(TMS) Q4921.3(D2) R4886.2(B) U4555.AD62(PCH_TMS)
PCH_WAKE#: R4747.2(B) U300.105(GPIO152/PS2_DAT3) U4555.AJ5(WAKE*)
PCI_3S_CLKRUN#: R4727.1(A) U300.55(NCLKRUN/GPIO014) U4555.V5(CLKRUN/GPIO32*)
PCI_3S_SERIRQ: CN375.5 R333.2(B) R4912.1(A) U3500.27 U4555.T4(SERIRQ)
PCIE_RX2_C_DN: C811.1(A) U4555.F15(PERN2/USB3RN4)
PCIE_RX2_C_DP: C813.1(A) U4555.G15(PERP2/USB3RP4)
PCIE_RX2_DN: C811.2(B) U800.8(HSON)
PCIE_RX2_DP: C813.2(B) U800.7(HSOP)
PCIE_RX3_C_DN: C407.1(A) U4555.G11(PERN3)
PCIE_RX3_C_DP: C408.1(A) U4555.F11(PERP3)
PCIE_RX3_DN: C407.2(B) U400.39
PCIE_RX3_DP: C408.2(B) U400.38
PCIE_RX4_C_DN: CN1300.43 U4555.F13(PERN4)
PCIE_RX4_C_DP: CN1300.41 U4555.G13(PERP4)
PCIE_RX6_L0_C_DN: CN1951.43(PERP0/SATA-B-) U4555.F5(SATA_RN3/PERN6_L0)
PCIE_RX6_L0_C_DP: CN1951.41(PERN0/SATA-B+) U4555.E5(SATA_RP3/PERP6_L0)
PCIE_RX6_L1_C_DN: CN1951.29(PERN1) U4555.J6(SATA_RN2/PERN6_L1)
PCIE_RX6_L1_C_DP: CN1951.31(PERP1) U4555.H6(SATA_RP2/PERP6_L1)
PCIE_TX2_C_DN: C4822.1(A) U800.4(HSIN)
PCIE_TX2_C_DP: C4823.1(A) U800.3(HSIP)
PCIE_TX2_DN: C4822.2(B) U4555.B31(PETN2/USB3TN4)
PCIE_TX2_DP: C4823.2(B) U4555.A31(PETP2/USB3TP4)
PCIE_TX3_C_DN: C4834.1(A) U400.42
PCIE_TX3_C_DP: C4831.1(A) U400.41
PCIE_TX3_DN: C4834.2(B) U4555.C29(PETN3)
PCIE_TX3_DP: C4831.2(B) U4555.B30(PETP3)
PCIE_TX4_C_DN: C4832.1(A) CN1300.37
PCIE_TX4_C_DP: C4833.1(A) CN1300.35
PCIE_TX4_DN: C4832.2(B) U4555.B29(PETN4)
PCIE_TX4_DP: C4833.2(B) U4555.A29(PETP4)
PCIE_TX6_L0_C_DN: C4818.2(B) CN1951.47(PETN0/SATA-A-)
PCIE_TX6_L0_C_DP: C4819.2(B) CN1951.49(PETP0/SATA-A+)
PCIE_TX6_L0_DN: C4818.1(A) U4555.C17(SATA_TN3/PETN6_L0)
PCIE_TX6_L0_DP: C4819.1(A) U4555.D17(SATA_TP3/PETP6_L0)
PCIE_TX6_L1_C_DN: C4820.2(B) CN1951.35(PETN1)
PCIE_TX6_L1_C_DP: C4821.2(B) CN1951.37(PETP1)
PCIE_TX6_L1_DN: C4820.1(A) U4555.B14(SATA_TN2/PETN6_L1)
PCIE_TX6_L1_DP: C4821.1(A) U4555.C15(SATA_TP2/PETP6_L1)
PCIE_WAKE#: R4934.2(B) U400.2
PLAY_MUTE_LED_CNTR: Q125.2(G1) R124.1(A) U501.1(GPIO3/SPDIFO)
PLT_DET: R309.1(A) U300.102(GPIO045/A20M/PVT_NCS1)
PLT_ID1: R4760.1(A) R4803.1(A) U4555.J1(UART0_RXD/GPIO91)
PLT_ID2: R4761.1(A) R4804.1(A) U4555.K3(UART0_TXD/GPIO92)
PLT_ID3: R4762.1(A) R4805.1(A) U4555.J2(UART0_RTS/GPIO93*)
PLT_RST#: Q302.1(G) U400.36 U4555.AG7(PLTRST*) U4700.2(A1)
PM_EXTTS#1_R: CN4100.198(EVENT#) CN4125.198(EVENT#) R4200.2(B)
PM_PWROK: C4937.1(A) CN4920.47(HOOK3) R321.1(A) R4802.1(A) U300.60(NRESET_OUT/GPIO121)
PM_SLP_A: Q7150.2(G1) Q7150.5(G2) Q7152.3(D) R7154.2(B)
PM_SLP_A#: CN4941.6 Q7152.1(G) R2957.1(A) R4718.2(B) U300.93(GPIO145)
PR_AOUT_L_AB: C560.1(A) U501.39(LINE2-L)
PR_AOUT_L_DOCK: CN3601.20 R566.2(B)
PR_AOUT_R_AB: C561.1(A) U501.40(LINE2-R)
PR_AOUT_R_DOCK: CN3601.21 R567.2(B)
PROC_DETECT_N: TP4501.1 U4555.D61(PROC_DETECT*)
PRTPWR2: R2565.2(B) U2403.2 U2550.35(PRT_CTL2/GPIO9)
PRTPWR3: R2566.2(B) U2402.2 U2550.33(PRT_CTL3/GPIO10)
PVADPTR: C3600.1(A) C3601.1(A) C6017.1(A) C6018.1(A) C6019.1(A) C7616.1(A) CN3601.P1 L6035.1 Q6010.1(S) Q6010.2(SX) Q6010.3(SXX) R6016.1(A) R6017.1(A) R6021.1(A) R6902.1(A) R6996.1(A)
PVCORE: C4521.1(A) C4522.1(A) C4529.1(A) C4530.1(A) C4531.1(A) C4532.1(A) C4533.1(A) C4534.1(A) C4535.1(A) C4536.1(A) C4537.1(A) C4538.1(A) C4539.1(A) C4540.1(A) C4542.1(A) C4544.1(A) C4545.1(A) C4547.1(A) C4548.1(A) C4549.1(A) C4559.1(A) C4560.1(A) C4561.1(A) C7459.2(B) C7460.2(B) C7461.2(B) C7462.2(B) C7463.2(B) C7464.2(B) C7465.2(B) C7466.2(B) C7612.1(A) C7622.1(A) D7617.2 D7618.2 L6610.2 R4521.1(A) U4555.AB57(VCC_AB57) U4555.AD57(VCC_AD57) U4555.AG57(VCC_AG57) U4555.C24(VCC_C24) U4555.C28(VCC_C28) U4555.C32(VCC_C32) U4555.C36(VCC_C36) U4555.C40(VCC_C40) U4555.C44(VCC_C44) U4555.C48(VCC_C48) U4555.C52(VCC_C52) U4555.C56(VCC_C56) U4555.E23(VCC_E23) U4555.E25(VCC_E25) U4555.E27(VCC_E27) U4555.E29(VCC_E29) U4555.E31(VCC_E31) U4555.E33(VCC_E33) U4555.E35(VCC_E35) U4555.E37(VCC_E37) U4555.E39(VCC_E39) U4555.E41(VCC_E41) U4555.E43(VCC_E43) U4555.E45(VCC_E45) U4555.E47(VCC_E47) U4555.E49(VCC_E49) U4555.E51(VCC_E51) U4555.E53(VCC_E53) U4555.E55(VCC_E55) U4555.E57(VCC_E57) U4555.F24(VCC_F24) U4555.F28(VCC_F28) U4555.F32(VCC_F32) U4555.F36(VCC_F36) U4555.F40(VCC_F40) U4555.F44(VCC_F44) U4555.F48(VCC_F48) U4555.F52(VCC_F52) U4555.F56(VCC_F56) U4555.F59(VCC) U4555.G23(VCC_G23) U4555.G25(VCC_G25) U4555.G27(VCC_G27) U4555.G29(VCC_G29) U4555.G31(VCC_G31) U4555.G33(VCC_G33) U4555.G35(VCC_G35) U4555.G37(VCC_G37) U4555.G39(VCC_G39) U4555.G41(VCC_G41) U4555.G43(VCC_G43) U4555.G45(VCC_G45) U4555.G47(VCC_G47) U4555.G49(VCC_G49) U4555.G51(VCC_G51) U4555.G53(VCC_G53) U4555.G55(VCC_G55) U4555.G57(VCC_G57) U4555.H23(VCC_H23) U4555.J23(VCC_J23) U4555.K23(VCC_K23) U4555.K57(VCC_K57) U4555.L22(VCC_L22) U4555.M23(VCC_M23) U4555.M57(VCC_M57) U4555.P57(VCC_P57) U4555.U57(VCC_U57) U4555.W57(VCC_W57)
PVCORE_PG: R4593.1(A) U4555.C59(VR_READY) U6600.3
PVPACK: C6000.1(A) C6001.1(A) C6002.1(A) C7502.1(A) C7609.1(A) C7611.1(A) C7618.1(A) C7619.1(A) C7621.1(A) CN4941.G2 CN6050.1 CN6050.2 D6019.1(A1) D7609.2 D7610.2 Q6012.5(DXXX) Q6012.6(DXX) Q6012.7(DX) Q6012.8(D) R6001.2
PVSIM: C1413.1(A) C1414.1(A) C1415.1(A) CN1400.2(3P3VAUX_2) CN1400.4(3P3VAUX_4) CN1400.70(3P3VAUX_70) CN1400.72(3P3VAUX_72) CN1400.74(3P3VAUX_74) D1451.1(A1) PAD1411.1 Q1400.1(D) Q1400.2(D1) Q1400.5(D3) Q1400.6(D2) R1407.1(A) R1408.1(A)
PVSM_VCC_SM: C9004.1(A) C9015.1(A) CN9001.1(VCC) R9000.1(A) U9000.11(SCPWR0)
PVT_CS#: R355.2(B) U300.96(GPIO146/PVT_NCS0) U366.1
PVT_MISO: R390.1(A) U300.94(GPIO164/PVT_MISO)
PVT_MISO_R: R390.2(B) U366.2
PVT_MOSI: R396.2(B) U366.5
PVT_SCLK: R362.1(A) U366.6
PWM#_LED: Q301.1(G) U300.118(GPIO136/PWM1)
PWM_3S_FAN#: Q4300.2(G1) U300.121(GPIO034/PWM2/TACH2PWM_OUT)
PWR_BTN_OUT#: CN4920.41(HOOK1) D100.1(A2) R103.2(B) U300.4(GPIO011/KSO16) U4555.AL7(PWRBTN*)
PWR_DEBUG: CN4920.45(HOOK2) R4590.1(A) U4555.H59(PWR_DEBUG*)
PWR_GOOD_3: C4920.1(A) Q4920.2(G1) Q4920.5(G2) Q4921.2(G1) Q4921.5(G2) Q4926.5(G2) R4925.2(B) R7404.2(B) R7406.2(B) R7407.2(B) U300.72(VCC_PWRGD/GPIO063) U7400.1(OUT) U7400.7(OUT)
PWRBTN#: C100.1(A) D100.3(A1) R100.2(B) R101.2(B) U300.73(GPIO110)
R_SPI_CLK_FLH: C7488.2(B) R4794.2(B) U4555.AA3(SPI_CLK)
R_SPI_CS0#_FLH: R4790.2(B) U4555.Y7(SPI_CS0*)
R_SPI_HOLD#_DB: R4795.2(B) U4555.AF1(SPI_IO3)
R_SPI_SI_FLH: R4796.2(B) U4555.AA2(SPI_MOSI)
R_SPI_WP#: R4793.2(B) U4555.Y6(SPI_IO2)
RD_DN: CN3601.3 JACK485.6 U470.19
RD_DP: CN3601.2 JACK485.3 U470.20
REC_MUTE_LED: Q320.6(D1) R392.1(A)
RSMRST#: R330.2(B) R7010.2(B) U4555.AW6(RSMRST*)
RTC_X1: C4767.2(B) R4862.1(A) U4555.AW5(RTCX1) X4750.4
RTC_X2: C4788.2(B) R4862.2(B) U4555.AY5(RTCX2) X4750.1
RTCRST#: C4768.1(A) CN4941.9 R4845.2(B) U4555.AU7(RTCRST*)
RUNSCI_EC#: R4785.1(A) U300.76(NEC_SCI/GPIO026) U4555.G4(I2C1_SDA/GPIO6)
SA0_DIM0: CN4100.197(SA0) R4101.1(A) R4103.2(B)
SA0_DIM1: CN4125.197(SA0) R4125.1(A)
SA1_DIM0: CN4100.201(SA1) R4100.1(A)
SA1_DIM1: CN4125.201(SA1) R4126.2(B)
SATA_RX1_C_DN: C1702.1(A) U4555.J8(SATA_RN1/PERN6_L2)
SATA_RX1_C_DP: C1703.1(A) U4555.H8(SATA_RP1/PERP6_L2)
SATA_RX1_DN: C1702.2(B) CN1700.S5
SATA_RX1_DP: C1703.2(B) CN1700.S6
SATA_TX1_C_DN: C1704.1(A) U4555.A17(SATA_TN1/PETN6_L2)
SATA_TX1_C_DP: C1705.1(A) U4555.B17(SATA_TP1/PETP6_L2)
SATA_TX1_DN: C1704.2(B) CN1700.S3
SATA_TX1_DP: C1705.2(B) CN1700.S2
SC_PWRSV#: CN200.13 R4757.1(A) U4555.J3(UART1_RST/GPIO2*)
SC_PWRSV#_SM: CN9000.13 R9011.2(B)
SCAN_3S_IN<0>: D302.6 RS340.1 U300.29(KSI0/GPIO125/TRACEDATA3)
SCAN_3S_IN<1>: D302.3 RS340.2 U300.28(KSI1/GPIO126/TRACEDATA2)
SCAN_3S_IN<2>: D304.6 RS340.3 U300.27(KSI2/GPIO144/TRACEDATA1)
SCAN_3S_IN<3>: D304.3 RS340.4 U300.26(KSI3/GPIO032/TRACEDATA0)
SCAN_3S_IN<4>: D303.6 RS340.6 U300.25(KSI4/GPIO142/TRACECLK)
SCAN_3S_IN<5>: D303.3 RS340.7 U300.24(KSI5/GPIO040)
SCAN_3S_IN<6>: D301.3 RS340.8 U300.23(KSI6/GPIO042)
SCAN_3S_IN<7>: CN300.12 RS340.9 U300.22(KSI7/GPIO043)
SCAN_3S_OUT<0>: CN300.33 R339.1(A) U300.21(KSO00/GPIO000/JTAG_TCK)
SCAN_3S_OUT<1>: CN300.15 R338.1(A) U300.20(KSO01/GPIO100/JTAG_TMS)
SCAN_3S_OUT<2>: CN300.32 R336.1(A) U300.19(KSO02/GPIO101/JTAG_TDI)
SCAN_3S_OUT<3>: CN300.21 R337.1(A) U300.18(KSO03/GPIO102/JTAG_TDO)
SCAN_3S_OUT<4>: CN300.19 U300.17(KSO04/GPIO103/TFDP_DATA/XNOR)
SCAN_3S_OUT<5>: CN300.31 TP332.1 U300.16(KSO05/GPIO104/TFDP_CLK)
SCAN_3S_OUT<6>: CN300.17 U300.13(KSO06/GPIO001)
SCAN_3S_OUT<7>: CN300.18 U300.12(KSO07/GPIO002)
SCAN_3S_OUT<8>: CN300.20 U300.10(KSO08/GPIO003)
SCAN_3S_OUT<9>: CN300.8 U300.9(KSO09/GPIO106)
SCAN_3S_OUT<10>: CN300.16 U300.8(KSO10/GPIO004)
SCAN_3S_OUT<11>: CN300.34 U300.7(KSO11/GPIO107)
SCAN_3S_OUT<17>: SW152.3 SW154.3 U300.108(GPIO012/KSO17)
SCARDC6: CN9001.6(VPP) U9000.2(SCARD0C6)
SCARDC8: CN9001.8(C8) U9000.1(SCARD0C8)
SCARDCLK: CN9001.3(CLK) U9000.6(SCARD0CLK)
SCARDDATA: CN9001.7(IO) R9001.1(A)
SCARDFCB: CN9001.4(C4) U9000.3(SCARD0FCB)
SCARDRST: CN9001.2(RST) U9000.5(SCARD0RST)
SCL_BAT_CHG: R307.1(A) R6053.1(A) U300.112(I2C0_CLK0/GPIO015) U6000.9(SCL)
SD_MMC_CD#: CN820.11 U800.30(SD_CD#)
SD_MMC_CLK: CN820.5 U800.17(SP3)
SD_MMC_CMD: CN820.2 U800.19(SP4)
SD_MMC_DATA0: CN820.7 U800.16
SD_MMC_DATA1: CN820.8 U800.15
SD_MMC_DATA2: CN820.9 U800.21(SP6)
SD_MMC_DATA3: CN820.1 U800.20(SP5)
SD_MMC_WP: CN820.10 U800.29(SP7)
SDA_BAT_CHG: R306.1(A) R6051.1(A) U300.111(I2C0_DAT0/GPIO016) U6000.8(SDA)
SG_IN: R4730.1(A) R4731.1(A) U4555.K4(UART1_RXD/GPIO0)
SLP_A: R4718.1(A) U4555.AL5(SLP_A*)
SLP_LAN#: Q7056.5(G2) U300.34(GPIO151) U4555.AJ7(SLP_LAN*)
SLP_S3#_3R: CN4941.2 Q7002.1(G) R398.1(A) R3600.1(A) R7020.1(A) R7414.1(A) U2511.6 U3051.4 U3300.3 U4555.AT4(SLP_S3*)
SLP_S3#_3R_DOCK: CN3601.40 R3600.2(B)
SLP_S3#_3R_KBC: R398.2(B) U300.81(GPIO007/KSO14)
SLP_S3_5R: Q1003.1(G) Q1302.5(G2) Q1402.1(G) Q7002.3(D) Q7051.2(G1) Q7051.5(G2) Q7101.1(G) Q7154.1(G) Q7155.1(G) R7005.2(B)
SLP_S4#_3R: CN4941.5 R4588.1(A) R7023.1(A) R7118.1(A) U2511.7 U4555.AJ6(SLP_S4*)
SLP_S4#_KBC: C3602.1(A) CN3601.41 R301.2(B) R2592.1(A) R2594.1(A) R4588.2(B)
SLP_S5#_3R: CN4941.4 U4555.AP5(SLP_S5/GPIO63*)
SLP_SUS#: R4860.1(A) U4555.AP4(SLP_SUS*)
SLPSUS#_EC: R326.1(A) R352.1(A) U300.100(GPIO161/BC_NINT)
SP_CLK: CN202.5 R387.1(A) U300.61(PS2_CLK1/GPIO050)
SP_DATA: CN202.4 R388.1(A) U300.62(PS2_DAT1/GPIO065)
SPI_CLK_FLH: C7475.2(B) CN365.6(SCK) R366.1(A) R4794.1(A) U365.6
SPI_CLK_FLH_KR: R366.2(B) U300.3(GPIO122/SHD_SCLK)
SPI_CLK_FLH_R6_R: CN375.17 R339.2(B)
SPI_CS0#_FLH: CN365.1(CE#) R331.2(B) R4790.1(A) U300.97(GPIO150/SHD_NCS0) U365.1
SPI_CS0#_FLH_R6_R: CN375.18 R338.2(B)
SPI_HOLD#_DB: CN365.7(HOLD#) R368.1(A) R4795.1(A) U365.7
SPI_HOLD#_DB_R6_R: CN375.21 R335.2(B)
SPI_SI_FLH: CN365.5(SI) R365.2(B) R4796.1(A) U365.5
SPI_SI_FLH_KR: R365.1(A) U300.128(GPIO064/SHD_MOSI)
SPI_SI_FLH_R6_R: CN375.19 R337.2(B)
SPI_SO_FLH: R367.1(A) U300.95(GPIO124/SHD_MISO) U4555.AA4(SPI_MISO)
SPI_SO_FLH_R: CN365.2(SO) R367.2(B) U365.2
SPI_SO_FLH_R6_R: CN375.20 R336.2(B)
SPI_WP#: CN365.3(WP#) R369.1(A) R370.1(A) R4793.1(A) U365.3
SPK_OUT_L_DN: C642.1(A) CN640.3 TP642.1 U501.43(SPK-L-)
SPK_OUT_L_DP: C643.1(A) CN640.4 TP643.1 U501.42(SPK-L+)
SPK_OUT_R_DN: C641.1(A) CN640.2 TP641.1 U501.44(SPK-R-)
SPK_OUT_R_DP: C640.1(A) CN640.1 TP640.1 U501.45(SPK-R+)
SPKR_EN_AB: C527.1(A) D500.3 R509.2(B) R517.2(B) U501.48
SPWON: C7152.1(A) Q7050.3(G) Q7051.6(D1) Q7100.3(G) Q7153.4(G) R7101.2(B)
ST_LEFT: CN200.2 CN202.6
ST_LEFT_SM: CN9000.2 CN9021.2
ST_RIGHT: CN200.1 CN202.8
ST_RIGHT_SM: CN9000.1 CN9021.1
SUS_PWR_WARN#: R347.1(A) U300.98(GPIO157/BC_CLK)
SUSCLK32_PCH: R382.2(B) U4555.AE6(SUSCLK/GPIO62)
SUSWARN#: R347.2(B) R4746.2(B) R4815.1(A) U4555.AV4(SUSWARN/SUSPWRDNACK/GPIO30*)
TACH_FAN_IN: CN4300.3 R4301.1(A) U300.101(GPIO140/TACH2/TACH2PWM_IN)
TD1_DN: U400.14 U470.2(TD1-)
TD1_DP: U400.13 U470.1(TD+)
TD2_DN: U400.18 U470.6
TD2_DP: U400.17 U470.5
TD3_DN: U400.21 U470.8
TD3_DP: U400.20 U470.7
TD4_DN: U400.24 U470.12(TD4-)
TD4_DP: U400.23 U470.11
TD_DN: CN3601.6 JACK485.2 U470.23(TX1-)
TD_DP: CN3601.5 JACK485.1 U470.24(TX+)
TD_IREF: R4841.2(B) U4555.B12(TD_IREF)
THERM#: Q4300.5(G2) R5039.2(B) R5049.1(A)
THERM_CLK: Q5314.1(S1) R5044.2(B) U1000.4(SCL_SPC) U5000.8
THERM_DATA: Q5314.4(S2) R5032.2(B) U1000.6(SDA_SDI_SDO) U5000.7
THERM_SCI#: R5043.2(B) U4555.F1(I2C1_SCL/GPIO7) U5000.6
THRMTRIP#: R4732.1(A) U4555.D60(THRMTRIP*)
TLS_ENCRYTION: R4733.2(B) U4555.AD6(GPIO15)
TP_DC_TEST_A4: U4555.A4(DAISY_CHAIN_NCTF_A4)
TP_DC_TEST_A60: U4555.A60(DAISY_CHAIN_NCTF_A60)
TP_DC_TEST_AV1: U4555.AV1(DAISY_CHAIN_NCTF_AV1)
TP_DC_TEST_AY60: U4555.AY60(DAISY_CHAIN_NCTF_AY60)
TRAVEL_BAT_DET#: R6074.1(A) U300.65(GPIO033)
UIM_CD: CN1400.66(SIM DETECT) CN1451.CD R1452.2(B)
UIM_CLK: C1453.1(A) CN1400.32(UIM-CLK) CN1451.P3(CLK)
UIM_DATA: CN1400.34(UIM-DATA) CN1451.P7(DATA) R1451.2(B)
UIM_PWR: C1451.1(A) C1452.1(A) CN1400.36(UIM-PWR) CN1451.P1(VCC) D1451.3(C) R1451.1(A) R1452.1(A)
UIM_RST: C1405.1(A) CN1400.30(UIM-RESET) CN1451.P2(RST)
UIM_VPP: CN1451.P6(VPP)
UNNAMED_5_BQ24736RGRR_I30_ACDET: C6022.1(A) D6018.1(A1) R6021.2(B) R6022.1(A) R6023.1(A) U6000.6(ACDET)
UNNAMED_5_BQ24736RGRR_I30_ACDRV: R6018.2(B) U6000.4(ACDRV)
UNNAMED_5_BQ24736RGRR_I30_ACN: C6028.2(B) C6030.1(A) R6000.4 U6000.1(ACN)
UNNAMED_5_BQ24736RGRR_I30_ACP: C6028.1(A) C6029.2(B) R6000.3 U6000.2(ACP)
UNNAMED_5_BQ24736RGRR_I30_BTST: R6015.1(A) U6000.17(BTST)
UNNAMED_5_BQ24736RGRR_I30_CMSRC: D6017.3(C) R6028.2(B) U6000.3(CMSRC)
UNNAMED_5_BQ24736RGRR_I30_DLIM: C6031.1(A) R6049.2(B) U6000.11(DLIM)
UNNAMED_5_BQ24736RGRR_I30_REGN: C6025.1(A) D6016.1(A1) D6016.2(A2) U6000.16(REGN)
UNNAMED_5_BQ24736RGRR_I30_SRN: R6020.1(A) U6000.12(SRN)
UNNAMED_5_BQ24736RGRR_I30_SRP: R6025.1(A) U6000.13(SRP)
UNNAMED_5_BQ24736RGRR_I30_VCC: C6027.1(A) R6027.2(B) U6000.20(VCC)
UNNAMED_5_CHOKE2PIN_I90_INB: L6000.2(INB) R6001.1
UNNAMED_5_CSC0402_I48_B: C6019.2(B) Q6009.6(D1) Q6010.4(G) R6017.2(B)
UNNAMED_5_CSC0402_I59_A: C6015.1(A) D6016.3(C) R6015.2(B)
UNNAMED_5_CSC0402_I61_A: C7600.1(A) R7600.2(B)
UNNAMED_5_CSC0402_I73_A: C6023.1(A) C6024.1(A) R6001.3 R6025.2(B)
UNNAMED_5_CSC0402_I74_B: C6021.1(A) C6023.2(B) R6001.4 R6020.2(B)
UNNAMED_5_DIODESCH_I86_A2: D6018.2(A2) R6029.2(B) R6030.1(A)
UNNAMED_5_NMOS4D3S_I34_D0: Q6011.5(D3) Q6011.6(D2) Q6011.7(D1) Q6011.8(D0) Q6012.1(S) Q6012.2(SX) Q6012.3(SXX) R6000.1
UNNAMED_5_NMOS4D3S_I34_G: Q6011.4(G) R6018.1(A)
UNNAMED_5_NMOSDUALC_I46_D2: Q6009.2(G1) Q6009.3(D2) R6016.2(B)
UNNAMED_5_NMOSDUALC_I46_S1: Q6009.1(S1) R6005.1(A)
UNNAMED_6_COMPARATOR_I63_1: R6930.1(A) R6931.2(B) R6933.1(A) U6903.1
UNNAMED_6_COMPARATOR_I63_3: C6906.1(A) R6934.1(A) U6903.3
UNNAMED_6_NMOS_I73_D: Q6998.3(D) R6998.2(B)
UNNAMED_6_NPND_I54_B: Q6901.1(B) R6915.2(B)
UNNAMED_6_PNPA_I55_E: Q6900.2(E) R6909.1(A) R6910.2(B)
UNNAMED_7_CSC0402_I44_A: C6166.1(A) R6166.2(B) R6167.2(B)
UNNAMED_7_CSC0402_I51_B: C6172.2(B) R6151.1(A) R6160.2(B) R6199.2(B) U6150.14
UNNAMED_7_CSC0402_I69_B: C6122.2(B) R6110.2(B) R6149.2(B) U6100.14
UNNAMED_7_CSC0805_I17_A: C6160.1(A) C6161.1(A) PAD6160.2 U6150.1
UNNAMED_7_CSC0805_I24_A: C6110.1(A) C6111.1(A) PAD6110.2 U6100.1
UNNAMED_8_CSC0402_I5_A: C6999.1(A) R6995.1(A) R6996.2(B)
UNNAMED_9_AOZ1268QI02_I10_22: C6210.1(A) C6211.1(A) PAD6210.2 R6207.2(B) R6211.2(B) U6200.8 U6200.9 U6200.22
UNNAMED_9_AOZ1268QI02_I10_AIN: R6207.1(A) U6200.7(AIN)
UNNAMED_9_AOZ1268QI02_I10_BST: R6215.1(A) U6200.20(BST)
UNNAMED_9_AOZ1268QI02_I10_FB: R6200.2(B) R6201.1(A) U6200.5(FB)
UNNAMED_9_AOZ1268QI02_I10_PFM: R6209.2(B) U6200.3(PFM)
UNNAMED_9_AOZ1268QI02_I10_SS: C6217.2(B) U6200.23(SS)
UNNAMED_9_AOZ1268QI02_I10_TON: R6211.1(A) U6200.6(TON)
UNNAMED_9_AOZ1268QI02_I10_VCC: C6216.2(B) R6210.1(A) U6200.21(VCC)
UNNAMED_9_CSC0402_I20_A: C7620.1(A) R7620.2(B)
UNNAMED_9_CSC0402_I32_A: C6215.1(A) R6215.2(B)
UNNAMED_9_CSC0402_I67_A: C6242.1(A) PAD6241.2 U6240.10(VIN)
